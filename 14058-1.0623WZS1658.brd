# Allegro board 14058-1.0623WZS1658.brd (continued)
## Nets (continued)
LPSS_GSPI0_MOSI: R218.2 R79875.1 U2.BD28
LPSS_GSPI1_CS_N: TP172.1 U2.BC27
LPSS_GSPI1_MISO: TP171.1 U2.AR29
LPSS_GSPI1_MOSI: R222.2 R223.1 U2.AT29
LVDS_BL_ADJ: R134.2 R79717.1 R79721.1 R79723.2
LVDS_DET_A*: LVDS1.17 R79730.2 U109.116
LVDS_DET_B*: Q103.D R79732.2 U109.117
LVDS_DET_B_C*: C12223.1 LVDS1.1 Q103.G
LVDS_PU_5: LVDS1.5 R1163.2
LVDS_PU_6: LVDS1.6 R79731.2
LVDS_PU_24: LVDS1.24 R79729.2
LX: D32.A L61.2 Q1259.5 Q1259.6 Q1259.7 Q1259.8
M1_SMB_CLK: NGFF1.60 R702.2
M1_SMB_DATA: NGFF1.58 R704.2
M_CAS_A_N: CPU1.AY11 DIMM1.115
M_CAS_B_N: CPU1.AP16 DIMM2.115
M_DATA_A0: CPU1.AE40 DIMM1.5
M_DATA_A1: CPU1.AE37 DIMM1.7
M_DATA_A2: CPU1.AG38 DIMM1.15
M_DATA_A3: CPU1.AG37 DIMM1.17
M_DATA_A4: CPU1.AE39 DIMM1.4
M_DATA_A5: CPU1.AE38 DIMM1.6
M_DATA_A6: CPU1.AG39 DIMM1.16
M_DATA_A7: CPU1.AG40 DIMM1.18
M_DATA_A8: CPU1.AJ40 DIMM1.21
M_DATA_A9: CPU1.AJ37 DIMM1.23
M_DATA_A10: CPU1.AL38 DIMM1.33
M_DATA_A11: CPU1.AL37 DIMM1.35
M_DATA_A12: CPU1.AJ39 DIMM1.22
M_DATA_A13: CPU1.AJ38 DIMM1.24
M_DATA_A14: CPU1.AL39 DIMM1.34
M_DATA_A15: CPU1.AL40 DIMM1.36
M_DATA_A16: CPU1.AN40 DIMM1.39
M_DATA_A17: CPU1.AN37 DIMM1.41
M_DATA_A18: CPU1.AR38 DIMM1.51
M_DATA_A19: CPU1.AR37 DIMM1.53
M_DATA_A20: CPU1.AN39 DIMM1.40
M_DATA_A21: CPU1.AN38 DIMM1.42
M_DATA_A22: CPU1.AR39 DIMM1.50
M_DATA_A23: CPU1.AR40 DIMM1.52
M_DATA_A24: CPU1.AV37 DIMM1.57
M_DATA_A25: CPU1.AW37 DIMM1.59
M_DATA_A26: CPU1.AU35 DIMM1.67
M_DATA_A27: CPU1.AV35 DIMM1.69
M_DATA_A28: CPU1.AU38 DIMM1.56
M_DATA_A29: CPU1.AU37 DIMM1.58
M_DATA_A30: CPU1.AT35 DIMM1.68
M_DATA_A31: CPU1.AW35 DIMM1.70
M_DATA_A32: CPU1.AY8 DIMM1.129
M_DATA_A33: CPU1.AU8 DIMM1.131
M_DATA_A34: CPU1.AV6 DIMM1.141
M_DATA_A35: CPU1.AU6 DIMM1.143
M_DATA_A36: CPU1.AW8 DIMM1.130
M_DATA_A37: CPU1.AV8 DIMM1.132
M_DATA_A38: CPU1.AY6 DIMM1.140
M_DATA_A39: CPU1.AW6 DIMM1.142
M_DATA_A40: CPU1.AV4 DIMM1.147
M_DATA_A41: CPU1.AV3 DIMM1.149
M_DATA_A42: CPU1.AT3 DIMM1.157
M_DATA_A43: CPU1.AT2 DIMM1.159
M_DATA_A44: CPU1.AY4 DIMM1.146
M_DATA_A45: CPU1.AW4 DIMM1.148
M_DATA_A46: CPU1.AT4 DIMM1.158
M_DATA_A47: CPU1.AT1 DIMM1.160
M_DATA_A48: CPU1.AP1 DIMM1.163
M_DATA_A49: CPU1.AP2 DIMM1.165
M_DATA_A50: CPU1.AM3 DIMM1.175
M_DATA_A51: CPU1.AM2 DIMM1.177
M_DATA_A52: CPU1.AP4 DIMM1.164
M_DATA_A53: CPU1.AP3 DIMM1.166
M_DATA_A54: CPU1.AM4 DIMM1.174
M_DATA_A55: CPU1.AM1 DIMM1.176
M_DATA_A56: CPU1.AK1 DIMM1.181
M_DATA_A57: CPU1.AK2 DIMM1.183
M_DATA_A58: CPU1.AH3 DIMM1.191
M_DATA_A59: CPU1.AH2 DIMM1.193
M_DATA_A60: CPU1.AK4 DIMM1.180
M_DATA_A61: CPU1.AK3 DIMM1.182
M_DATA_A62: CPU1.AH4 DIMM1.192
M_DATA_A63: CPU1.AH1 DIMM1.194
M_DATA_B0: CPU1.AE34 DIMM2.5
M_DATA_B1: CPU1.AE35 DIMM2.7
M_DATA_B2: CPU1.AH34 DIMM2.15
M_DATA_B3: CPU1.AH35 DIMM2.17
M_DATA_B4: CPU1.AD34 DIMM2.4
M_DATA_B5: CPU1.AD35 DIMM2.6
M_DATA_B6: CPU1.AG34 DIMM2.16
M_DATA_B7: CPU1.AG35 DIMM2.18
M_DATA_B8: CPU1.AL34 DIMM2.21
M_DATA_B9: CPU1.AL35 DIMM2.23
M_DATA_B10: CPU1.AK31 DIMM2.33
M_DATA_B11: CPU1.AL31 DIMM2.35
M_DATA_B12: CPU1.AK34 DIMM2.22
M_DATA_B13: CPU1.AK35 DIMM2.24
M_DATA_B14: CPU1.AK32 DIMM2.34
M_DATA_B15: CPU1.AL32 DIMM2.36
M_DATA_B16: CPU1.AP35 DIMM2.39
M_DATA_B17: CPU1.AN34 DIMM2.41
M_DATA_B18: CPU1.AN31 DIMM2.51
M_DATA_B19: CPU1.AP31 DIMM2.53
M_DATA_B20: CPU1.AN35 DIMM2.40
M_DATA_B21: CPU1.AP34 DIMM2.42
M_DATA_B22: CPU1.AN32 DIMM2.50
M_DATA_B23: CPU1.AP32 DIMM2.52
M_DATA_B24: CPU1.AM29 DIMM2.57
M_DATA_B25: CPU1.AM28 DIMM2.59
M_DATA_B26: CPU1.AR29 DIMM2.67
M_DATA_B27: CPU1.AR28 DIMM2.69
M_DATA_B28: CPU1.AL29 DIMM2.56
M_DATA_B29: CPU1.AL28 DIMM2.58
M_DATA_B30: CPU1.AP29 DIMM2.68
M_DATA_B31: CPU1.AP28 DIMM2.70
M_DATA_B32: CPU1.AR12 DIMM2.129
M_DATA_B33: CPU1.AP12 DIMM2.131
M_DATA_B34: CPU1.AL13 DIMM2.141
M_DATA_B35: CPU1.AL12 DIMM2.143
M_DATA_B36: CPU1.AR13 DIMM2.130
M_DATA_B37: CPU1.AP13 DIMM2.132
M_DATA_B38: CPU1.AM13 DIMM2.140
M_DATA_B39: CPU1.AM12 DIMM2.142
M_DATA_B40: CPU1.AP9 DIMM2.147
M_DATA_B41: CPU1.AR9 DIMM2.149
M_DATA_B42: CPU1.AP7 DIMM2.157
M_DATA_B43: CPU1.AP6 DIMM2.159
M_DATA_B44: CPU1.AP10 DIMM2.146
M_DATA_B45: CPU1.AR10 DIMM2.148
M_DATA_B46: CPU1.AR7 DIMM2.158
M_DATA_B47: CPU1.AR6 DIMM2.160
M_DATA_B48: CPU1.AM9 DIMM2.163
M_DATA_B49: CPU1.AL9 DIMM2.165
M_DATA_B50: CPU1.AL6 DIMM2.175
M_DATA_B51: CPU1.AL7 DIMM2.177
M_DATA_B52: CPU1.AM10 DIMM2.164
M_DATA_B53: CPU1.AL10 DIMM2.166
M_DATA_B54: CPU1.AM6 DIMM2.174
M_DATA_B55: CPU1.AM7 DIMM2.176
M_DATA_B56: CPU1.AJ7 DIMM2.181
M_DATA_B57: CPU1.AH6 DIMM2.183
M_DATA_B58: CPU1.AF7 DIMM2.191
M_DATA_B59: CPU1.AE7 DIMM2.193
M_DATA_B60: CPU1.AH7 DIMM2.180
M_DATA_B61: CPU1.AJ6 DIMM2.182
M_DATA_B62: CPU1.AF6 DIMM2.192
M_DATA_B63: CPU1.AE6 DIMM2.194
M_DQS_A_DN0: CPU1.AF39 DIMM1.10
M_DQS_A_DN1: CPU1.AK39 DIMM1.27
M_DQS_A_DN2: CPU1.AP39 DIMM1.45
M_DQS_A_DN3: CPU1.AU36 DIMM1.62
M_DQS_A_DN4: CPU1.AW7 DIMM1.135
M_DQS_A_DN5: CPU1.AU3 DIMM1.152
M_DQS_A_DN6: CPU1.AN3 DIMM1.169
M_DQS_A_DN7: CPU1.AJ3 DIMM1.186
M_DQS_A_DP0: CPU1.AF38 DIMM1.12
M_DQS_A_DP1: CPU1.AK38 DIMM1.29
M_DQS_A_DP2: CPU1.AP38 DIMM1.47
M_DQS_A_DP3: CPU1.AV36 DIMM1.64
M_DQS_A_DP4: CPU1.AV7 DIMM1.137
M_DQS_A_DP5: CPU1.AU2 DIMM1.154
M_DQS_A_DP6: CPU1.AN2 DIMM1.171
M_DQS_A_DP7: CPU1.AJ2 DIMM1.188
M_DQS_B_DN0: CPU1.AF34 DIMM2.10
M_DQS_B_DN1: CPU1.AK33 DIMM2.27
M_DQS_B_DN2: CPU1.AN33 DIMM2.45
M_DQS_B_DN3: CPU1.AN29 DIMM2.62
M_DQS_B_DN4: CPU1.AN13 DIMM2.135
M_DQS_B_DN5: CPU1.AR8 DIMM2.152
M_DQS_B_DN6: CPU1.AM8 DIMM2.169
M_DQS_B_DN7: CPU1.AG6 DIMM2.186
M_DQS_B_DP0: CPU1.AF35 DIMM2.12
M_DQS_B_DP1: CPU1.AL33 DIMM2.29
M_DQS_B_DP2: CPU1.AP33 DIMM2.47
M_DQS_B_DP3: CPU1.AN28 DIMM2.64
M_DQS_B_DP4: CPU1.AN12 DIMM2.137
M_DQS_B_DP5: CPU1.AP8 DIMM2.154
M_DQS_B_DP6: CPU1.AL8 DIMM2.171
M_DQS_B_DP7: CPU1.AG7 DIMM2.188
M_MAA_A0: CPU1.AW15 DIMM1.98
M_MAA_A1: CPU1.AU18 DIMM1.97
M_MAA_A2: CPU1.AU17 DIMM1.96
M_MAA_A3: CPU1.AV19 DIMM1.95
M_MAA_A4: CPU1.AT19 DIMM1.92
M_MAA_A5: CPU1.AU20 DIMM1.91
M_MAA_A6: CPU1.AV20 DIMM1.90
M_MAA_A7: CPU1.AU21 DIMM1.86
M_MAA_A8: CPU1.AT20 DIMM1.89
M_MAA_A9: CPU1.AT22 DIMM1.85
M_MAA_A10: CPU1.AY14 DIMM1.107
M_MAA_A11: CPU1.AU22 DIMM1.84
M_MAA_A12: CPU1.AV22 DIMM1.83
M_MAA_A13: CPU1.AV12 DIMM1.119
M_MAA_A14: CPU1.AV23 DIMM1.80
M_MAA_A15: CPU1.AU24 DIMM1.78
M_MAA_B0: CPU1.AL19 DIMM2.98
M_MAA_B1: CPU1.AL22 DIMM2.97
M_MAA_B2: CPU1.AM22 DIMM2.96
M_MAA_B3: CPU1.AM23 DIMM2.95
M_MAA_B4: CPU1.AP23 DIMM2.92
M_MAA_B5: CPU1.AL23 DIMM2.91
M_MAA_B6: CPU1.AW26 DIMM2.90
M_MAA_B7: CPU1.AY26 DIMM2.86
M_MAA_B8: CPU1.AU26 DIMM2.89
M_MAA_B9: CPU1.AW27 DIMM2.85
M_MAA_B10: CPU1.AP18 DIMM2.107
M_MAA_B11: CPU1.AU27 DIMM2.84
M_MAA_B12: CPU1.AV27 DIMM2.83
M_MAA_B13: CPU1.AR15 DIMM2.119
M_MAA_B14: CPU1.AY28 DIMM2.80
M_MAA_B15: CPU1.AU28 DIMM2.78
M_ODT_A0: CPU1.AW11 DIMM1.116
M_ODT_A1: CPU1.AU14 DIMM1.120
M_ODT_B0: CPU1.AM16 DIMM2.116
M_ODT_B1: CPU1.AL16 DIMM2.120
M_RAS_A_N: CPU1.AW13 DIMM1.110
M_RAS_B_N: CPU1.AN18 DIMM2.110
M_SBS_A0: CPU1.AY13 DIMM1.109
M_SBS_A1: CPU1.AV15 DIMM1.108
M_SBS_A2: CPU1.AW23 DIMM1.79
M_SBS_B0: CPU1.AL18 DIMM2.109
M_SBS_B1: CPU1.AM18 DIMM2.108
M_SBS_B2: CPU1.AW28 DIMM2.79
M_SCKE_A0: CPU1.AY24 DIMM1.73
M_SCKE_A1: CPU1.AW24 DIMM1.74
M_SCKE_B0: CPU1.AY29 DIMM2.73
M_SCKE_B1: CPU1.AV29 DIMM2.74
M_SCS_A_N0: CPU1.AW12 DIMM1.114
M_SCS_A_N1: CPU1.AU11 DIMM1.121
M_SCS_B_N0: CPU1.AP17 DIMM2.114
M_SCS_B_N1: CPU1.AN15 DIMM2.121
M_WE_A_N: CPU1.AV14 DIMM1.113
M_WE_B_N: CPU1.AL17 DIMM2.113
MAA0: GPU1.F26 RN7510.1(A) RN7510.2(A) VRAM1.N3 VRAM2.N3 VRAM3.N7 VRAM4.N7 VRAM5.N3 VRAM6.N3 VRAM7.N7 VRAM8.N7
MAA1: GPU1.G23 RN7508.1(A) RN7508.2(A) VRAM1.P7 VRAM2.P7 VRAM3.P3 VRAM4.P3 VRAM5.P7 VRAM6.P7 VRAM7.P3 VRAM8.P3
MAA2: GPU1.K22 RN7507.1(A) RN7507.2(A) VRAM1.P3 VRAM2.P3 VRAM3.P7 VRAM4.P7 VRAM5.P3 VRAM6.P3 VRAM7.P7 VRAM8.P7
MAA3: GPU1.F25 RN7501.1(A) RN7501.2(A) VRAM1.N2 VRAM2.N2 VRAM3.N8 VRAM4.N8 VRAM5.N2 VRAM6.N2 VRAM7.N8 VRAM8.N8
MAA4: GPU1.M25 RN7502.1(A) RN7502.2(A) VRAM1.P8 VRAM2.P8 VRAM3.P2 VRAM4.P2 VRAM5.P8 VRAM6.P8 VRAM7.P2 VRAM8.P2
MAA5: GPU1.J25 RN7505.1(A) RN7505.2(A) VRAM1.P2 VRAM2.P2 VRAM3.P8 VRAM4.P8 VRAM5.P2 VRAM6.P2 VRAM7.P8 VRAM8.P8
MAA6: GPU1.D26 RN7517.1(A) RN7517.2(A) VRAM1.R8 VRAM2.R8 VRAM3.R2 VRAM4.R2 VRAM5.R8 VRAM6.R8 VRAM7.R2 VRAM8.R2
MAA7: GPU1.M26 RN7501.3(A) RN7501.4(A) VRAM1.R2 VRAM2.R2 VRAM3.R8 VRAM4.R8 VRAM5.R2 VRAM6.R2 VRAM7.R8 VRAM8.R8
MAA8: GPU1.F23 RN7514.1(A) RN7514.2(A) VRAM1.T8 VRAM2.T8 VRAM3.T8 VRAM4.T8 VRAM5.T8 VRAM6.T8 VRAM7.T8 VRAM8.T8
MAA9: GPU1.D27 RN7504.1(A) RN7504.2(A) VRAM1.R3 VRAM2.R3 VRAM3.R7 VRAM4.R7 VRAM5.R3 VRAM6.R3 VRAM7.R7 VRAM8.R7
MAA10: GPU1.J23 RN7511.1(A) RN7511.2(A) VRAM1.L7 VRAM2.L7 VRAM3.L3 VRAM4.L3 VRAM5.L7 VRAM6.L7 VRAM7.L3 VRAM8.L3
MAA11: GPU1.K26 RN7516.1(A) RN7516.2(A) VRAM1.R7 VRAM2.R7 VRAM3.R3 VRAM4.R3 VRAM5.R7 VRAM6.R7 VRAM7.R3 VRAM8.R3
MAA12: GPU1.G22 RN7506.3(A) RN7506.4(A) VRAM1.N7 VRAM2.N7 VRAM3.N3 VRAM4.N3 VRAM5.N7 VRAM6.N7 VRAM7.N3 VRAM8.N3
MAA13: GPU1.F27 RN7513.1(A) RN7513.2(A) VRAM1.T3 VRAM2.T3 VRAM3.T7 VRAM4.T7 VRAM5.T3 VRAM6.T3 VRAM7.T7 VRAM8.T7
MAA14: GPU1.G27 RN7515.1(A) RN7515.2(A) VRAM1.T7 VRAM2.T7 VRAM3.T3 VRAM4.T3 VRAM5.T7 VRAM6.T7 VRAM7.T3 VRAM8.T3
MCLK: RN3.1(A) U109.80
MCT_R: R79930.2 RV5.2 XF3.15 XF3.18 XF3.21 XF3.24
MCT_R_1: C12333.1 R79930.1
MDA0: GPU1.E18 VRAM2.F8 VRAM4.F2
MDA1: GPU1.F18 VRAM2.F7 VRAM4.E3
MDA2: GPU1.E16 VRAM2.H7 VRAM4.H3
MDA3: GPU1.F17 VRAM2.H8 VRAM4.G2
MDA4: GPU1.D20 VRAM2.H3 VRAM4.H7
MDA5: GPU1.D21 VRAM2.E3 VRAM4.F7
MDA6: GPU1.F20 VRAM2.G2 VRAM4.H8
MDA7: GPU1.E21 VRAM2.F2 VRAM4.F8
MDA8: GPU1.E15 VRAM1.F2 VRAM3.F8
MDA9: GPU1.D15 VRAM1.G2 VRAM3.H8
MDA10: GPU1.F15 VRAM1.H3 VRAM3.H7
MDA11: GPU1.F13 VRAM1.E3 VRAM3.F7
MDA12: GPU1.C13 VRAM1.H7 VRAM3.H3
MDA13: GPU1.B13 VRAM1.F7 VRAM3.E3
MDA14: GPU1.E13 VRAM1.H8 VRAM3.G2
MDA15: GPU1.D13 VRAM1.F8 VRAM3.F2
MDA16: GPU1.B15 VRAM1.C8 VRAM3.C2
MDA17: GPU1.C16 VRAM1.D7 VRAM3.C3
MDA18: GPU1.A13 VRAM1.B8 VRAM3.A2
MDA19: GPU1.A15 VRAM1.A7 VRAM3.A3
MDA20: GPU1.B18 VRAM1.A3 VRAM3.A7
MDA21: GPU1.A18 VRAM1.A2 VRAM3.B8
MDA22: GPU1.A19 VRAM1.C3 VRAM3.D7
MDA23: GPU1.C19 VRAM1.C2 VRAM3.C8
MDA24: GPU1.B24 VRAM2.C2 VRAM4.C8
MDA25: GPU1.C23 VRAM2.C3 VRAM4.D7
MDA26: GPU1.A25 VRAM2.A3 VRAM4.A7
MDA27: GPU1.A24 VRAM2.A2 VRAM4.B8
MDA28: GPU1.A21 VRAM2.B8 VRAM4.A2
MDA29: GPU1.B21 VRAM2.A7 VRAM4.A3
MDA30: GPU1.C20 VRAM2.C8 VRAM4.C2
MDA31: GPU1.C21 VRAM2.D7 VRAM4.C3
MDA32: GPU1.R22 VRAM5.H3 VRAM7.H7
MDA33: GPU1.R24 VRAM5.G2 VRAM7.H8
MDA34: GPU1.T22 VRAM5.E3 VRAM7.F7
MDA35: GPU1.R23 VRAM5.F2 VRAM7.F8
MDA36: GPU1.N25 VRAM5.H8 VRAM7.G2
MDA37: GPU1.N26 VRAM5.H7 VRAM7.H3
MDA38: GPU1.N23 VRAM5.F7 VRAM7.E3
MDA39: GPU1.N24 VRAM5.F8 VRAM7.F2
MDA40: GPU1.V23 VRAM6.F8 VRAM8.F2
MDA41: GPU1.V22 VRAM6.H7 VRAM8.H3
MDA42: GPU1.T23 VRAM6.H8 VRAM8.G2
MDA43: GPU1.U22 VRAM6.F7 VRAM8.E3
MDA44: GPU1.Y24 VRAM6.E3 VRAM8.F7
MDA45: GPU1.AA24 VRAM6.F2 VRAM8.F8
MDA46: GPU1.Y22 VRAM6.G2 VRAM8.H8
MDA47: GPU1.AA23 VRAM6.H3 VRAM8.H7
MDA48: GPU1.AD27 VRAM6.A2 VRAM8.B8
MDA49: GPU1.AB25 VRAM6.A3 VRAM8.A7
MDA50: GPU1.AD26 VRAM6.C3 VRAM8.D7
MDA51: GPU1.AC25 VRAM6.C2 VRAM8.C8
MDA52: GPU1.AA27 VRAM6.D7 VRAM8.C3
MDA53: GPU1.AA26 VRAM6.A7 VRAM8.A3
MDA54: GPU1.W26 VRAM6.B8 VRAM8.A2
MDA55: GPU1.Y25 VRAM6.C8 VRAM8.C2
MDA56: GPU1.R26 VRAM5.B8 VRAM7.A2
MDA57: GPU1.T25 VRAM5.A7 VRAM7.A3
MDA58: GPU1.N27 VRAM5.C8 VRAM7.C2
MDA59: GPU1.R27 VRAM5.D7 VRAM7.C3
MDA60: GPU1.V26 VRAM5.A2 VRAM7.B8
MDA61: GPU1.V27 VRAM5.A3 VRAM7.A7
MDA62: GPU1.W27 VRAM5.C3 VRAM7.D7
MDA63: GPU1.W25 VRAM5.C2 VRAM7.C8
MDAT: RN3.2(A) U109.79
ME_CNTL: R1836.2 R80244.1 U109.7
ME_CNTL1: Q5.B R1836.1
ME_CNTL2: Q5.E R150.2
MIC2-L: C263.1 U9.47
MIC2-L-1: C263.2 R410.1
MIC2-R: C265.1 U9.48
MIC2-R-1: C265.2 R411.1
MIC2-VREFO-L: R414.1 U9.1
MIC2-VREFO-R: R415.1 U9.30
MIC-CAP: C206.2 U9.36
MPCIE_DISABLE_N: R706.1 RN6.3(B) U109.56
MS_INS#: TP205.1 U14.31
NCP81172_FB1: PC8312.1 PR8318.1
NGFF_ALERT_N: NGFF1.62 R701.2
NGFF_BT_DISABLE: R707.1 U2.L44
NGFF_CLKREQ0_N: NGFF1.53 R709.1
NGFF_CLKREQ1_N: NGFF1.68 TP241.1
NGFF_DETECT_PCIE: R710.2 U2.AB33
NGFF_DETECT_PCIE_C: NGFF1.51 R710.1 R715.1
NGFF_DETECT_USB: R721.2 U2.AB41
NGFF_DETECT_USB_C: NGFF1.1 R721.1 R722.1
NGFF_PCIE0_RXN: NGFF1.43 R714.1
NGFF_PCIE0_RXP: NGFF1.41 R717.1
NGFF_PCIE0_TXN: NGFF1.37 R719.1
NGFF_PCIE0_TXP: NGFF1.35 R720.1
NGFF_PCIE1_RXN: NGFF1.67 TP245.1
NGFF_PCIE1_RXP: NGFF1.65 TP244.1
NGFF_PCIE1_TXN: NGFF1.61 TP247.1
NGFF_PCIE1_TXP: NGFF1.59 TP246.1
NGFF_PEWAKE0_N: NGFF1.55 R708.1
NGFF_PEWAKE1_N: NGFF1.70 TP254.1
NGFF_POWER_CTRL: R732.1 RN6.4(B) U109.55
NGFF_POWER_CTRL_1: Q58.G R729.2 R732.2
NGFF_POWER_CTRL_V2: C519.1 Q60.B R734.1
NGFF_REFCLKN0: NGFF1.49 R711.1
NGFF_REFCLKN1: NGFF1.73 TP243.1
NGFF_REFCLKP0: NGFF1.47 R712.1
NGFF_REFCLKP1: NGFF1.71 TP242.1
NGFF_W_DISABLE1_N: NGFF1.56 R706.2
NGFF_W_DISABLE2_N: NGFF1.54 R707.2
ODTA0: GPU1.C27 PR5523.1 VRAM1.K1 VRAM2.K1 VRAM3.K1 VRAM4.K1
ODTA1: GPU1.M24 PR232.1 VRAM5.K1 VRAM6.K1 VRAM7.K1 VRAM8.K1
OPC_1P8_AB37: CPU1.AB37 TP226.1
OS_MODE_SEL: R79938.1 SCA1.109 U2.V44
OSD_BIST_N: R535.1 R743.2
OSD_BIST_N_1: Q9628.2 R535.2
OSD_CONTROL_SEL: R79939.1 SCA1.111 U2.AN36
OSD_DN: C528.1 R748.1 R750.1 R79790.2 R79795.1
OSD_DN_IC: R79790.1 SCA1.50
OSD_DN_R: D5212.2 PWRCN1.2 R750.2
OSD_MENU: C12238.1 R753.1 R754.1 R79792.2 R79793.1 R80206.1
OSD_MENU_IC: R79792.1 SCA1.52
OSD_MENU_R: D5213.2 PWRCN1.1 R754.2
OSD_MENU_SIO: R80206.2 U109.109
OSD_UP: C524.1 R740.2 R742.1 R743.1 R79791.2 R79794.1
OSD_UP_IC: R79791.1 SCA1.51
OSD_UP_R: D5211.2 PWRCN1.3 R742.2
OZ554_ENA: C12227.1 R79704.1 R79707.1 U120.3
OZ554_PWM: C12228.1 R79694.1 R79702.1 U120.5
OZ554_VIN: C3457.1 R79706.2 U120.4
P1P2V: C12246.1 L9504.1 PC12172.1 U9601.2
P3P3V: C11358.1 C11359.1 C12172.1 C12245.1 L9503.1 L9505.1 Q9601.S R9609.1 R79810.2 U9601.3 U9615.1
PANEL_OFF: Q9619.D R79867.2 R79941.1 R80232.2 U2.AN41
PANEL_OFF_C: Q9619.G R79868.2 R80232.1 SCA1.113
PANEL_ON: R9542.1 R9544.2 SCA1.112
PANEL_ON1: Q9503.2 R9542.2
PANEL_ON2: Q9503.5 Q9503.6 R9543.2
PANEL_ON3: Q9503.3 R9556.2
PANEL_ON_1: R42.1 R79376.2 R79734.1 R79737.2
PANEL_ON_2: Q1263.B R42.2
PANEL_ON_3: C12114.1 Q1261.D R19.1 R79727.2 U1.3
PANEL_ON_4: Q1261.G Q1262.G Q1263.C R79728.1 R79738.2
PANEL_ON_5: Q1262.D R79735.1
PANEL_SEL1_CABLE: R79711.1 R79814.2 R79817.1
PANEL_SEL1_CABLE_C: CONVT1.7A CONVT1.7B R79711.2 R79715.2
PANEL_SEL1_CABLE_EC: R79814.1 U109.102
PANEL_SEL1_CABLE_S: R79799.2 R79802.1 R79817.2 SCA1.33
PANEL_SEL2_CABLE: R79712.1 R79815.2 R79818.1
PANEL_SEL2_CABLE_C: CONVT1.8A CONVT1.8B R79712.2 R79714.2
PANEL_SEL2_CABLE_EC: R79815.1 U109.103
PANEL_SEL2_CABLE_S: R79800.2 R79801.1 R79818.2 SCA1.32
PANEL_SEL3_CABLE: R79713.1 R79816.2 R79819.1
PANEL_SEL3_CABLE_C: CONVT1.9A CONVT1.9B R1733.2 R79713.2
PANEL_SEL3_CABLE_EC: R79816.1 U109.104
PANEL_SEL3_CABLE_S: R79797.1 R79798.2 R79819.2 SCA1.31
PB_IN_N_1: C199.1 R332.2 R333.2 R79873.2 U109.72
PB_IN_N_1_C: R79873.1 U109.111
PB_IN_SW1: D5210.2 PWRCN1.6 R745.2 R746.1
PC_MONITOR_SW: R9521.1 R79830.1 SCA1.104 U9615.5 U9615.7
PC_MONITOR_SW_G: C12127.1 Q7.G R79827.2 R79830.2
PCH_2_CPU_TRIGGER: CPU1.D1 R1811.2
PCH_2_CPU_TRIGGER_R: R1811.1 U2.AL2
PCH_AUD_RST_N: R314.1 R392.1 U109.19
PCH_AUD_RST_N_1: Q13.2 R392.2
PCH_BKLT_PWM_1: Q9614.3 Q9614.6 R79174.1
PCH_CHAR_CTL3: R454.2 R456.2 U2.R41
PCH_CLK_TO_LPC: R1983.1 U2.AV19
PCH_CPU_BCLK_DN: R7.1 U2.H2
PCH_CPU_BCLK_DP: R6.1 U2.G2
PCH_CPU_BCLK_R_DN: CPU1.W4 R7.2
PCH_CPU_BCLK_R_DP: CPU1.W5 R6.2
PCH_CPU_NSSC_CLK_DN: R15.1 U2.F1
PCH_CPU_NSSC_CLK_DP: R13.1 U2.G1
PCH_CPU_PCIBCLK_DN: R11.1 U2.J1
PCH_CPU_PCIBCLK_DP: R9.1 U2.J2
PCH_CPU_PCIBCLK_R_DN: CPU1.W2 R11.2
PCH_CPU_PCIBCLK_R_DP: CPU1.W1 R9.2
PCH_DPWROK: C12052.1 R1984.1 R79773.1 U2.AV11
PCH_DVI_CLK: Q9502.1 R9534.1
PCH_DVI_DATA: Q9502.4 R9535.1
PCH_HOT#: R1839.1 R1840.1 U2.AT27
PCH_INTRUDER_N: R1835.2 U2.BE11
PCH_JTAG_TCK: R1764.1 R79768.1 U2.AN3
PCH_JTAG_TDI: R43.2 R1841.1 U2.AP2
PCH_JTAG_TDO: R40.2 R132.1 U2.AP1
PCH_JTAG_TMS: R44.2 R1842.1 U2.AR2
PCH_JTAGX: R131.1 R79779.1 U2.AR3
PCH_OSD_DN: R79795.2 U2.AN43
PCH_OSD_MENU: R79793.2 U2.AM44
PCH_OSD_UP: R79794.2 U2.AN44
PCH_PCIECLKRQ1_N_1: Q57.S R709.2 R731.2
PCH_PECI: C11892.1 R41.2 R79772.1 U2.AL3
PCH_PWROK: DB1.1 R1980.2 R79943.2 U2.AW11
PCH_RTCRST_DOWN: BTRST1.1 R141.1
PCH_RTCRST_PULLUP: BTRST1.2 C12149.1 R138.2 R140.1 U2.BC10
PCH_RTCX1: C160.1 R180.1 U2.BC9 X2.1
PCH_RTCX2: R179.2 U2.BD10
PCH_SATA_LED_1: Q61.B Q62.C R741.2
PCH_SATA_LED_2: PWRCN1.8 Q61.C Q63.C
PCH_SATA_LED_N: Q9646.4 R191.2 R744.1 R79771.2
PCH_SATA_LED_R: Q62.B R744.2
PCH_SATA_LED_R_N: R191.1 U2.AD44
PCH_SIO_DPWROK: R1946.2 R1984.2 U109.14
PCH_SLP_A_N: R1786.1 TP67.1 U2.BC15
PCH_SLP_S0_N: TP69.1 U2.BC26
PCH_SMI_N: R199.2 R1923.2 U2.M45
PCH_SRCCLKREQ0: R156.1 R163.2 U2.BC24
PCH_SRCCLKREQ0_N: R163.1 R458.2
PCH_SRCCLKREQ1: R157.1 R164.2 U2.AW24
PCH_SRCCLKREQ1_N: Q57.D R164.1
PCH_SRCCLKREQ2: R158.1 R166.2 U2.AT24
PCH_SRCCLKREQ2_N: R166.1 R425.2
PCH_SRCCLKREQ3: R160.1 U2.BD25
PCH_SRCCLKREQ4: R161.1 U2.BB24
PCH_SRCCLKREQ5: R162.1 U2.BE25
PCH_SRCCLKREQ6: R165.1 U2.AT33
PCH_SRCCLKREQ7: R168.1 U2.AR31
PCH_SRCCLKREQ8: R169.1 U2.BD32
PCH_SRCCLKREQ9: R170.1 U2.BC32
PCH_SRCCLKREQ10: R172.1 U2.BB31
PCH_SRCCLKREQ11: R173.1 U2.BC33
PCH_SRCCLKREQ12: R174.1 U2.BA33
PCH_SRCCLKREQ13: R175.1 U2.AW33
PCH_SRCCLKREQ14: R176.1 U2.BB33
PCH_SRCCLKREQ15: R177.1 U2.BD33
PCH_SRTCRSTB_PULLUP: C12150.1 R140.2 R146.2 R147.1 U2.BB10
PCH_SYSPWROK: C156.1 DB2.1 R154.1 R155.2 R79765.2 U2.AY1
PCH_THERMTRIP_N: PR1.2 R38.1 R1804.2 R79980.1
PCH_THERMTRIP_R_N: R1804.1 U2.AJ3
PCH_WAKE_N: R115.1 R79780.1 U2.BC13
PCH_XDP_PRDY_R_N: R1774.1 U2.AT4
PCH_XDP_PREQ_R_N: R1773.1 U2.AT3
PCIE_RCOMPN: R181.1 U2.B18
PCIE_RCOMPP: R181.2 U2.C17
PCIE_RST#: NGFF1.52 NGFF1.66 RN2.1(A)
PCIRST1#: R79977.1 RN2.5(B) RN2.6(B) U109.30
PCIRST3#: R79976.1 RN2.7(B) RN2.8(B) U109.81
PD_N: Q1249.D U118.36
PECI_SIO: C12126.1 R79739.1 U109.51
PEG_C_RXN0: C12265.2 GPU1.AB9
PEG_C_RXN1: C12267.2 GPU1.AC10
PEG_C_RXN2: C12269.2 GPU1.AC11
PEG_C_RXN3: C12271.2 GPU1.AB12
PEG_C_RXN4: C12273.2 GPU1.AC13
PEG_C_RXN5: C12275.2 GPU1.AC14
PEG_C_RXN6: C12277.2 GPU1.AB15
PEG_C_RXN7: C12279.2 GPU1.AC16
PEG_C_RXP0: C12264.2 GPU1.AC9
PEG_C_RXP1: C12266.2 GPU1.AB10
PEG_C_RXP2: C12268.2 GPU1.AD11
PEG_C_RXP3: C12270.2 GPU1.AC12
PEG_C_RXP4: C12272.2 GPU1.AB13
PEG_C_RXP5: C12274.2 GPU1.AD14
PEG_C_RXP6: C12276.2 GPU1.AC15
PEG_C_RXP7: C12278.2 GPU1.AB16
PEG_C_TXN0: C11908.1 CPU1.T3
PEG_C_TXN1: C11907.1 CPU1.R1
PEG_C_TXN2: C11905.1 CPU1.P3
PEG_C_TXN3: C11904.1 CPU1.N2
PEG_C_TXN4: C11902.1 CPU1.M3
PEG_C_TXN5: C11900.1 CPU1.L2
PEG_C_TXN6: C11895.1 CPU1.K3
PEG_C_TXN7: C11898.1 CPU1.J2
PEG_C_TXP0: C12145.1 CPU1.T2
PEG_C_TXP1: C12144.1 CPU1.R2
PEG_C_TXP2: C12143.1 CPU1.P2
PEG_C_TXP3: C12142.1 CPU1.N1
PEG_C_TXP4: C12141.1 CPU1.M2
PEG_C_TXP5: C12140.1 CPU1.L1
PEG_C_TXP6: C12139.1 CPU1.K2
PEG_C_TXP7: C12138.1 CPU1.J1
PEG_COMP: CPU1.L7 R63.2
PEG_RXN0: C12265.1 CPU1.U4
PEG_RXN1: C12267.1 CPU1.T5
PEG_RXN2: C12269.1 CPU1.R4
PEG_RXN3: C12271.1 CPU1.P5
PEG_RXN4: C12273.1 CPU1.N4
PEG_RXN5: C12275.1 CPU1.M5
PEG_RXN6: C12277.1 CPU1.L4
PEG_RXN7: C12279.1 CPU1.K5
PEG_RXP0: C12264.1 CPU1.U5
PEG_RXP1: C12266.1 CPU1.T6
PEG_RXP2: C12268.1 CPU1.R5
PEG_RXP3: C12270.1 CPU1.P6
PEG_RXP4: C12272.1 CPU1.N5
PEG_RXP5: C12274.1 CPU1.M6
PEG_RXP6: C12276.1 CPU1.L5
PEG_RXP7: C12278.1 CPU1.K6
PEG_TXN0: C11908.2 GPU1.AG7
PEG_TXN1: C11907.2 GPU1.AE7
PEG_TXN2: C11905.2 GPU1.AF9
PEG_TXN3: C11904.2 GPU1.AG10
PEG_TXN4: C11902.2 GPU1.AE10
PEG_TXN5: C11900.2 GPU1.AF12
PEG_TXN6: C11895.2 GPU1.AG13
PEG_TXN7: C11898.2 GPU1.AE13
PEG_TXP0: C12145.2 GPU1.AG6
PEG_TXP1: C12144.2 GPU1.AF7
PEG_TXP2: C12143.2 GPU1.AE9
PEG_TXP3: C12142.2 GPU1.AG9
PEG_TXP4: C12141.2 GPU1.AF10
PEG_TXP5: C12140.2 GPU1.AE12
PEG_TXP6: C12139.2 GPU1.AG12
PEG_TXP7: C12138.2 GPU1.AF13
PEX_CLKREQ: GPU1.AC6 R591.2
PEX_PLLVDD_GPU: C427.1 C430.1 C435.1 C444.1 GPU1.AA14 GPU1.AA15 L9524.1
PEX_RST_GPU: GPU1.AC7 R605.1 R1212.1
PEX_TERMP: GPU1.AF25 R79978.1
PEX_TSTCLK_OUT: GPU1.AF22 R193.2
PEX_TSTCLK_OUT#: GPU1.AE22 R193.1
PLTRST*_SIO: C180.1 R251.1 R256.2 U109.46
PLTRST_CPU_N: CPU1.E7 R1771.1 U2.AK2
PLTRST_CR: RN2.4(A) U14.1
PLTRST_LAN_N: RN2.2(A) U9623.19
PLTRST_N: R256.1 R1982.2
PLTRST_N_1A: C12384.2 Q9630.G R605.2
PLTRST_N_C: Q6704.C R79980.2
PLTRST_N_CPU: R1982.1 U2.BB27
PLTRST_SL_N: LPC1.3 R80059.1 RN2.3(A) U9621.2
PM_PWRBTN_N: C151.1 R142.2 R333.1 R334.2
PM_SLP_S3#_R: R79789.2 SCA1.34
PME_N: R96.2 R79796.2 U2.BD17
PORTC_SPK_L: C12332.1 U9.43
PORTC_SPK_L_1: C12332.2 R384.1
PORTC_SPK_R: C12331.1 U9.44
PORTC_SPK_R_1: C12331.2 R383.1
PRE: R2088.2 R2090.1 U118.16
PRIM_XDP_JTAG_TCK_R: R1764.2 XDPC1.55
PROG: PR4458.1 PU4401.10
PSID_D: L21.2 Q24.D R501.1
PSID_D_1: Q26.B R501.2 R503.1
PSID_G: Q24.G Q26.C R499.2
PW_CLEAR: PSWD1.2 R151.1 U2.U39
PWM1: PU4.2 PU4401.34
PWM1A: PU19.2 PU4401.30
PWM2: PU9.2 PU4401.33
PWM2A: PU24.2 PU4401.31
PWM3: PU14.2 PU4401.32
PWM_SW_EN: Q9614.2 Q9614.5 R79205.1 SCA1.54
PWR_1D0V: PC107.1 PG17.2 PL11.2 PR213.2 PR215.2 PR216.2 PR217.2 PR218.2 PR219.2 PR220.2 PT29.1 PT30.1
PWR_1D0V_BOOT: PR209.1 PU44.10
PWR_1D0V_BOOT_R: PC103.2 PR209.2
PWR_1D0V_CS: PR208.1 PU44.2
PWR_1D0V_EN: PC105.1 PR4475.2 PU44.3 R1947.2
PWR_1D0V_FB: PC108.2 PR212.2 PR214.1 PU44.4
PWR_1D0V_FB_R: PC108.1 PG17.1 PR212.1
PWR_1D0V_LGATE: PU44.6 PU45.4 PU46.4
PWR_1D0V_PG: PR207.2 PU44.1
PWR_1D0V_PHASE: PC103.1 PC106.1 PL11.1 PU43.1 PU43.2 PU43.3 PU44.8 PU45.5 PU45.6 PU45.7 PU45.8 PU46.5 PU46.6 PU46.7 PU46.8
PWR_1D0V_RF: PR210.1 PU44.5
PWR_1D0V_SNB: PC106.2 PR211.1
PWR_1D0V_UGATE: PU43.4 PU44.9
PWR_1D35V: PC95.1 PL10.2 PR188.1 PR189.1 PR191.1 PR194.1 PR195.1 PR197.1 PR198.1 PR200.1 PR201.1 PR203.1 PR204.1 PT26.1 PT27.1
PWR_1D35V_VGA: PC8607.1 PC8611.1 PC8614.1 PC8616.1 PC8618.1 PL8602.2 PR8609.1 PR8612.1 PR8613.1 PR8614.1 PR8619.1 PR8620.1 PR8622.1
PWR_3D3V: PC12173.1 PG14.2 PL8.1 PR162.1 PR175.2 PR176.2 PR177.2 PT23.1
PWR_3D3V_BOOT2: PR153.2 PU35.7
PWR_3D3V_BOOT2_R: PC74.1 PR153.1
PWR_3D3V_ENTRIP2: PC85.1 PR169.1 PU35.4
PWR_3D3V_FB: PC79.2 PG14.1 PR158.1
PWR_3D3V_FB2: PC79.1 PR158.2 PR161.1 PU35.5
PWR_3D3V_HG2R: PR155.1 PU34.4
PWR_3D3V_LDO3: PC77.2 PG16.1 PU35.15
PWR_3D3V_LGATE2: PU35.10 PU37.4
PWR_3D3V_PHASE2: PC74.2 PL8.2 PR157.1 PU34.1 PU34.2 PU34.3 PU35.9 PU37.5 PU37.6 PU37.7 PU37.8
PWR_3D3V_SNB: PC82.1 PR157.2
PWR_3D3V_UGATE2: PR155.2 PU35.8
PWR_5V: PC78.1 PG15.1 PL9.2 PR167.2 PR170.2 PR171.2 PR172.2 PR173.2 PR174.2 PT24.1
PWR_5V3V_EMN: PR163.2 PR166.1 PU35.13
PWR_5V3V_ENLDO: PR152.2 PU35.12
PWR_5V3V_LDO5: PC73.1 PG13.1 PU35.14
PWR_5V3V_PGOOD: PR162.2 PU35.6
PWR_5V3V_TON: PR165.1 PU35.3
PWR_5V_BOOT1: PR154.1 PU35.19
PWR_5V_BOOT1_R: PC75.2 PR154.2
PWR_5V_BYP1: PC81.1 PC83.1 PG15.2 PR159.2 PU35.20
PWR_5V_ENTRIP1: PC84.1 PR168.1 PU35.2
PWR_5V_FB1: PC83.2 PR159.1 PR164.1 PU35.1
PWR_5V_LGATE1: PU35.16 PU38.4
PWR_5V_PHASE1: PC75.1 PL9.1 PR160.1 PU35.17 PU36.1 PU36.2 PU36.3 PU38.5 PU38.6 PU38.7 PU38.8
PWR_5V_SNB: PC80.1 PR160.2
PWR_5V_UGATE1: PR156.1 PU35.18
PWR_5V_UGATE1_G: PR156.2 PU36.4
PWR_12V: PC5304.1 PC5305.1 PC5306.1 PC5308.1 PC5310.1 PL5301.2 PR5301.1 PR5306.1
PWR_12V_BOOT: PR5308.2 PU5301.1
PWR_12V_BOOT_R: PC5307.1 PR5308.1
PWR_12V_DCBATOUT: PC5301.1 PC5302.1 PR5304.2 PU5301.7
PWR_12V_EN: PC5311.1 PQ5301.D PR5303.1 PR5305.1 PR5518.2 PU5301.5
PWR_12V_EN_G: PC5303.1 PQ5301.G PQ5302.D PR5302.2
PWR_12V_FB: PC5310.2 PR5306.2 PR5309.1 PU5301.4
PWR_12V_SNB: PC5309.1 PR5307.2
PWR_12V_SW: PC5307.2 PD5301.K PL5301.1 PR5307.1 PU5301.8
PWR_81203_ALERT: PR4467.2 PU4401.4
PWR_81203_COMP: PC4404.1 PC4405.1 PU4401.48
PWR_81203_COMP1: PC4403.1 PR4451.1
PWR_81203_COMP2: PC4404.2 PR4452.1
PWR_81203_COMPA: PC4410.1 PC4411.1 PU4401.18
PWR_81203_COMPA1: PC4409.2 PR4457.1
PWR_81203_COMPA2: PC4410.2 PR4454.1
PWR_81203_CSCOMP: PC4424.1 PC4425.1 PR4438.2 PR4439.1 PR4466.1 PU4401.47
PWR_81203_CSCOMP1: PR4439.2 PR4440.1 PR4466.2
PWR_81203_CSCOMPA: PC4418.1 PC4419.1 PR4424.2 PR4426.1 PR4465.1 PU4401.19
PWR_81203_CSCOMPA1: PR4425.1 PR4426.2 PR4465.2
PWR_81203_CSN3: PC4420.2 PR4444.1 PR4468.1 PU4401.42
PWR_81203_CSP1: PC4427.1 PR4443.2 PR4446.2 PU4401.39
PWR_81203_CSP1A: PC4422.1 PR4429.2 PR4430.2 PU4401.25
PWR_81203_CSP2: PC4426.1 PR4442.2 PR4445.2 PU4401.41
PWR_81203_CSP2A: PC4421.1 PR4427.2 PR4428.2 PU4401.23
PWR_81203_CSP3: PC4420.1 PR4441.2 PR4444.2 PR4477.2 PU4401.43
PWR_81203_CSREF: PC4423.1 PR4431.2 PR4432.2 PR4433.2 PU4401.44
PWR_81203_CSREFA: PC4417.1 PR4421.2 PR4422.2 PU4401.22
PWR_81203_CSSUM: PC4424.2 PC4425.2 PR4435.1 PR4436.1 PR4437.1 PR4440.2 PU4401.45
PWR_81203_CSSUMA: PC4418.2 PC4419.2 PR4423.1 PR4425.2 PR4434.1 PU4401.21
PWR_81203_DIFF: PR4450.2 PR4451.2 PU4401.50
PWR_81203_DIFFA: PR4455.2 PR4457.2 PU4401.16
PWR_81203_FB: PC4403.2 PC4405.2 PR4450.1 PR4452.2 PR4453.2 PU4401.49
PWR_81203_FBA: PC4409.1 PC4411.2 PR4454.2 PR4455.1 PR4456.1 PU4401.17
PWR_81203_ILIM: PR4438.1 PU4401.46
PWR_81203_ILIMA: PR4424.1 PU4401.20
PWR_81203_IOUT: PC4408.1 PR4409.2 PU4401.1
PWR_81203_IOUTA: PC4414.1 PR4414.2 PU4401.13
PWR_81203_ROSC: PR4418.1 PU4401.8
PWR_81203_SCLK: PR4460.1 PU4401.5
PWR_81203_SDIO: PR4459.1 PU4401.3
PWR_81203_TSEN: PC4415.1 PR4416.1 PU4401.37
PWR_81203_TSEN1: PR4416.2 PR4417.1 PR8624.2
PWR_81203_TSENA: PC4416.1 PR4419.1 PU4401.11
PWR_81203_TSENA1: PR4419.2 PR4420.1 PR4464.2
PWR_81203_VCC: PC4430.1 PR4404.2 PR4476.2 PU4401.7
PWR_81203_VRMP: PC4429.1 PR4403.2 PU4401.9
PWR_81203_VSN: PC4407.1 PR4408.2 PU4401.52
PWR_81203_VSNA: PC4413.1 PR4413.2 PU4401.14
PWR_81203_VSP: PC4406.1 PR4407.1 PU4401.51
PWR_81203_VSPA: PC4412.1 PR4412.1 PU4401.15
PWR_CHG_ACDET: PC5232.1 PR5270.2 PR5286.1 U55.6
PWR_CHG_ACN: PC5233.1 PC5235.2 PG4905.2 U55.1
PWR_CHG_ACP: PC5234.1 PC5235.1 PG4907.2 U55.2
PWR_CHG_BTST: PR5281.1 U55.17
PWR_CHG_BTST_1: PC5236.1 PD4401.K PR5281.2
PWR_CHG_CMPIN: PR5288.2 PR5467.2 PR5468.1 PR5469.2 PR5470.1 U55.4
PWR_CHG_CMPIN_R: PQ5006.6 PR5470.2
PWR_CHG_CMPIN_RR: PQ5006.3 PR5469.1
PWR_CHG_ILIM: PR5268.1 U55.10
PWR_CHG_IOUT: PC5245.1 PR5290.1 PR5467.1 U55.7
PWR_CHG_PHASE: PC5236.2 U55.19
PWR_CHG_SRN: PR5277.2 U55.12
PWR_CHG_SRN_R: PR5277.1 R79876.2
PWR_CHG_SRP: PR5285.2 U55.13
PWR_CHG_SRP_R: PR5285.1 R79876.1
PWR_CHG_VCC: PC4432.1 PR5284.2 U55.20
PWR_DCBATOUT_1D0V: PC101.1 PC102.1 PR205.2 PR206.2 PR5481.2 PR5482.2 PT28.1 PU43.5 PU43.6 PU43.7 PU43.8
PWR_DCBATOUT_3V: PC68.1 PC69.1 PC163.1 PR5519.2 PR5520.2 PU34.5 PU34.6 PU34.7 PU34.8
PWR_DCBATOUT_5V: PC71.1 PC72.1 PR148.2 PR149.2 PR5521.2 PT22.1 PU36.5 PU36.6 PU36.7 PU36.8
PWR_DCBATOUT_VCC: PC35.1 PR75.2 PR76.2 PR78.2 PT1.1 PU2.5 PU2.6 PU2.7 PU2.8 PU3.5 PU3.6 PU3.7 PU3.8
PWR_DCBATOUT_VCC2: PC38.1 PR5474.2 PR5475.2 PR5476.2 PT7.1 PU7.5 PU7.6 PU7.7 PU7.8 PU8.5 PU8.6 PU8.7 PU8.8
PWR_DCBATOUT_VCC3: PC42.1 PR4403.1 PR5471.2 PR5472.2 PR5473.2 PT8.1 PU12.5 PU12.6 PU12.7 PU12.8 PU13.5 PU13.6 PU13.7 PU13.8
PWR_DCBATOUT_VCCIO: PC61.1 PC117.1 PR133.1 PR134.1 PU31.5 PU31.6 PU31.7 PU31.8
PWR_DCBATOUT_VCCSA: PC4.1 PC12.1 PR3.1 PR5.1 PR6.1 PT16.1 PU27.5 PU27.6 PU27.7 PU27.8
PWR_DCBATOUT_VDDQ: PC88.1 PC89.1 PC90.1 PC91.1 PC12186.1 PC12187.1 PR178.2 PR179.2 PR180.2 PR182.2 PR187.1 PT25.1 PU39.5 PU39.6 PU39.7 PU39.8
PWR_LED_YELLOW_C: PWRCN1.9 Q65.D R757.2 R759.1
PWR_LED_YELLOW_C2: R756.2 R757.1
PWR_VCC_BST1: PR77.2 PU4.1
PWR_VCC_BST1R: PC33.1 PR77.1
PWR_VCC_BST2: PR84.2 PU9.1
PWR_VCC_BST2R: PC37.1 PR84.1
PWR_VCC_BST3: PR90.2 PU14.1
PWR_VCC_BST3R: PC41.1 PR90.1
PWR_VCC_DRH1: PR79.1 PU4.8
PWR_VCC_DRH1_G: PR79.2 PR80.1 PU2.4 PU3.4
PWR_VCC_DRH2: PR85.1 PU9.8
PWR_VCC_DRH2_G: PR85.2 PR86.1 PU7.4 PU8.4
PWR_VCC_DRH3: PR91.1 PU14.8
PWR_VCC_DRH3_G: PR91.2 PR92.1 PU12.4 PU13.4
PWR_VCC_DRL1: PU4.5 PU5.4 PU6.4
PWR_VCC_DRL2: PU9.5 PU10.4 PU11.4
PWR_VCC_DRL3: PU14.5 PU15.4 PU16.4
PWR_VCC_EN1: PR81.1 PU4.3
PWR_VCC_EN2: PR87.1 PU9.3
PWR_VCC_EN3: PR93.1 PU14.3
PWR_VCC_LX1: PC33.2 PG1.1 PL1.1 PR80.2 PR82.1 PU2.1 PU2.2 PU2.3 PU3.1 PU3.2 PU3.3 PU4.7 PU5.5 PU5.6 PU5.7 PU5.8 PU6.5 PU6.6 PU6.7 PU6.8
PWR_VCC_LX2: PC37.2 PG3.1 PL2.1 PR86.2 PR88.1 PU7.1 PU7.2 PU7.3 PU8.1 PU8.2 PU8.3 PU9.7 PU10.5 PU10.6 PU10.7 PU10.8 PU11.5 PU11.6 PU11.7 PU11.8
PWR_VCC_LX3: PC41.2 PG5.1 PL3.1 PR92.2 PR94.1 PU12.1 PU12.2 PU12.3 PU13.1 PU13.2 PU13.3 PU14.7 PU15.5 PU15.6 PU15.7 PU15.8 PU16.5 PU16.6 PU16.7 PU16.8
PWR_VCC_SNB1: PC36.1 PR82.2
PWR_VCC_SNB2: PC40.1 PR88.2
PWR_VCC_SNB3: PC44.1 PR94.2
PWR_VCC_VCC1: PC34.1 PR74.2 PU4.4
PWR_VCC_VCC2: PC39.1 PR83.2 PU9.4
PWR_VCC_VCC3: PC43.1 PR89.2 PU14.4
PWR_VCCIO: PC66.1 PL7.2 PR137.2 PR138.2 PR140.2 PR141.2 PR142.2 PR144.2 PR4801.1 PT20.1 R1985.1 R1986.1
PWR_VCCIO_BOOT: PR139.1 PU32.10
PWR_VCCIO_BOOT_R: PC62.1 PR139.2
PWR_VCCIO_CS: PR136.2 PU32.2
PWR_VCCIO_EN: PC64.1 PU32.3 R1968.2
PWR_VCCIO_EN_G1: C12055.1 R1961.2 R80228.2 U173.2
PWR_VCCIO_EN_G2: R1963.2 U173.5 U173.6
PWR_VCCIO_EN_R: R1964.2 R1967.2 R1968.1 U173.3
PWR_VCCIO_FB: PC67.2 PR146.2 PR147.1 PU32.4
PWR_VCCIO_FB_R: PC67.1 PR146.1 PR4801.2 PR4802.2
PWR_VCCIO_LGATE: PU32.6 PU33.4
PWR_VCCIO_PG: PC4431.1 PR135.2 PU32.1 R1966.1 R79947.1
PWR_VCCIO_PG_D: PR123.2 U9616.G U9617.D
PWR_VCCIO_PG_G: C12341.1 R79946.2 R79947.2 U9617.G
PWR_VCCIO_PHASE: PC62.2 PL7.1 PR145.1 PU31.1 PU31.2 PU31.3 PU32.8 PU33.5 PU33.6 PU33.7 PU33.8
PWR_VCCIO_RF: PR143.1 PU32.5
PWR_VCCIO_SNB: PC65.1 PR145.2
PWR_VCCIO_UGATE: PU31.4 PU32.9
PWR_VCCSA_BOOT: PR19.1 PU28.4
PWR_VCCSA_BOOT_R: PC5.1 PR19.2
PWR_VCCSA_COMP: PC7.1 PC8.1 PU28.8
PWR_VCCSA_COMP_R: C12442.1 PC7.2 PR11.1
PWR_VCCSA_CSN: PC10.2 PC11.1 PG12.2 PR13.2 PU28.12
PWR_VCCSA_CSP: PC10.1 PR10.2 PR13.1 PU28.13
PWR_VCCSA_CSP_R: PG11.2 PR10.1
PWR_VCCSA_EN: PR9.1 PU28.14 U9616.D
PWR_VCCSA_FB: C12442.2 PC8.2 PC9.1 PR11.2 PR12.1 PR14.1 PR15.1 PU28.9
PWR_VCCSA_FB_L: PC9.2 PR17.1
PWR_VCCSA_LGATE: PU28.2 PU29.4 PU30.4
PWR_VCCSA_PG: PC4701.2 PR4.2 PU28.6
PWR_VCCSA_PHASE: PC5.2 PG11.1 PL6.1 PU27.1 PU27.2 PU27.3 PU28.3 PU29.5 PU29.6 PU29.7 PU29.8 PU30.5 PU30.6 PU30.7 PU30.8
PWR_VCCSA_UGATE: PR20.1 PU28.5
PWR_VCCSA_UGATE_R: PR20.2 PU27.4
PWR_VCCSA_VCC: PC3.1 PR2.2 PU28.15
PWR_VCCSA_VCCP: PC1.1 PR8.2 PU28.1
PWR_VCCSA_VSEN: PR12.2 PU28.10
PWR_VDDQ_BOOT: PR186.1 PU40.18
PWR_VDDQ_BOOT_L: PC93.1 PR186.2
PWR_VDDQ_CS: PC87.2 PR183.2 PU40.13
PWR_VDDQ_EN: PU40.8 R1956.2 R1958.1 U171.3
PWR_VDDQ_FB: PC96.2 PR192.2 PR193.1 PU40.6
PWR_VDDQ_LGATE: PU40.15 PU41.4 PU42.4
PWR_VDDQ_PG: PR185.2 PU40.10
PWR_VDDQ_PHASE: PC93.2 PL10.1 PR190.1 PU39.1 PU39.2 PU39.3 PU40.16 PU41.5 PU41.6 PU41.7 PU41.8 PU42.5 PU42.6 PU42.7 PU42.8
PWR_VDDQ_SENSE: PC96.1 PR191.2 PR192.1 PU40.5
PWR_VDDQ_SNB: PC97.1 PR190.2
PWR_VDDQ_TON: PR187.2 PU40.9
PWR_VDDQ_UGATE: PU39.4 PU40.17
PWR_VDDQ_VDD: PC86.1 PC87.1 PR181.1 PR183.1 PU40.11
PWR_VDDQ_VDDP: PC92.1 PR184.1 PU40.12
PWR_VDDQ_VTTIN: PC94.1 PR188.2 PR189.2 PU40.19
PWR_VDDQ_VTTREF: PC98.1 PR196.2 PU40.4
PWR_VGA_CORE_BOOT1: PR43.1 U9619.1
PWR_VGA_CORE_BOOT1_1: PC19.1 PR43.2
PWR_VGA_CORE_COMP: PC8303.1 PR8326.2 U9619.12
PWR_VGA_CORE_COMP_1: PC8309.2 PR8326.1
PWR_VGA_CORE_EN: PC8501.1 PD8301.A PR8325.2 PR8328.2 U9619.3
PWR_VGA_CORE_FB: PC8303.2 PC8309.1 PR8311.1 PR8318.2 U9619.11
PWR_VGA_CORE_FBRTN: PR8306.2 U9619.10
PWR_VGA_CORE_FS: PR8334.1 U9619.9
PWR_VGA_CORE_LGATE1: PR8312.1 PU5202.4 PU5204.4 U9619.23
PWR_VGA_CORE_PGOOD: PR8304.1 PR8315.2 U9619.16
PWR_VGA_CORE_PHASE1: PC19.2 PL12.1 PR114.2 PR8331.2 PU1.1 PU1.2 PU1.3 PU5202.5 PU5202.6 PU5202.7 PU5202.8 PU5203.1 PU5203.2 PU5203.3 PU5204.5 PU5204.6 PU5204.7 PU5204.8 U9619.24
PWR_VGA_CORE_PSI: PC8315.1 PR8308.2 PR8335.1 R80016.1 U9619.4
PWR_VGA_CORE_PVCC: PC8302.1 PR8313.2 U9619.21
PWR_VGA_CORE_REFIN: PC8317.1 PR8305.2 PR8316.1 U9619.7
PWR_VGA_CORE_SENCE+: GPU1.F2 PR8317.1 PR8329.2
PWR_VGA_CORE_SENCE-: GPU1.F1 PR8306.1 PR8333.1
PWR_VGA_CORE_SENSE+_1: PC8312.2 PR8311.2 PR8317.2
PWR_VGA_CORE_SNB: PC5246.1 PR114.1
PWR_VGA_CORE_TALERT#: PR8319.2 PR8327.1 U9619.14
PWR_VGA_CORE_TSNS: PC8307.1 PR60.1 PR8323.2 U9619.13
PWR_VGA_CORE_UGATE1: PR8302.1 U9619.2
PWR_VGA_CORE_UGATE1_R: PR8302.2 PR8331.1 PU1.4 PU5203.4
PWR_VGA_CORE_VCC: PC8308.1 PR8330.2 U9619.15
PWR_VGA_CORE_VID: PC8311.1 PR8324.1 U9619.5
PWR_VGA_CORE_VIDBUF: PR8303.1 U9619.6
PWR_VGA_CORE_VREF: PC8314.1 PR8309.1 PR8323.1 U9619.8
PWR_VGA_CORE_VREF_1: PC8301.1 PR8303.2 PR8305.1 PR8309.2
PWR_VGA_CORE_VREF_2: PR8316.2 PR8320.1
PWR_VGA_VRAM_BOOT: PR8618.1 PU8602.20
PWR_VGA_VRAM_BOOT_RC: PC8608.1 PR8618.2
PWR_VGA_VRAM_FB: PC8614.2 PR8620.2 PR8621.1 PU8602.5
PWR_VGA_VRAM_LX: PC8608.2 PL8602.1 PR8615.2 PU8602.10 PU8602.11 PU8602.16 PU8602.17 PU8602.18 PU8602.25
PWR_VGA_VRAM_PFM: PR8338.1 PR8339.1 PU8602.3
PWR_VGA_VRAM_POK: PC12174.1 PR8623.2 PU8602.1 R80231.2
PWR_VGA_VRAM_SNB: PC8610.1 PR8615.1
PWR_VGA_VRAM_SS: PC8617.1 PU8602.23
PWR_VGA_VRAM_TON: PR8617.2 PU8602.6
PWR_VGA_VRAM_VCC: PC8615.1 PR8616.1 PU8602.21
PWR_VGT__BST1A: PR95.2 PU19.1
PWR_VGT_BST1AR: PC45.1 PR95.1
PWR_VGT_BST2A: PR105.2 PU24.1
PWR_VGT_BST2AR: PC49.1 PR105.1
PWR_VGT_DRH1A: PR103.1 PU19.8
PWR_VGT_DRH1A_G: PR101.1 PR103.2 PU17.4 PU18.4
PWR_VGT_DRH2A: PR107.1 PU24.8
PWR_VGT_DRH2A_G: PR107.2 PR108.1 PU22.4 PU23.4
PWR_VGT_DRVLA1: PU19.5 PU20.4 PU21.4
PWR_VGT_DRVLA2: PU24.5 PU25.4 PU26.4
PWR_VGT_EN1A: PR102.1 PU19.3
PWR_VGT_EN2A: PR109.1 PU24.3
PWR_VGT_LX1A: PC45.2 PG7.1 PL4.1 PR101.2 PR104.1 PU17.1 PU17.2 PU17.3 PU18.1 PU18.2 PU18.3 PU19.7 PU20.5 PU20.6 PU20.7 PU20.8 PU21.5 PU21.6 PU21.7 PU21.8
PWR_VGT_LX2A: PC49.2 PG9.1 PL5.1 PR108.2 PR110.1 PU22.1 PU22.2 PU22.3 PU23.1 PU23.2 PU23.3 PU24.7 PU25.5 PU25.6 PU25.7 PU25.8 PU26.5 PU26.6 PU26.7 PU26.8
PWR_VGT_SNB1A: PC48.1 PR104.2
PWR_VGT_SNB2A: PC52.1 PR110.2
PWR_VGT_VCC1A: PC47.1 PR98.2 PU19.4
PWR_VGT_VCC2A: PC51.1 PR106.2 PU24.4
PWR_VGT_VIN: PC46.1 PR96.1 PR97.1 PR99.1 PR100.1 PT9.1 PU17.5 PU17.6 PU17.7 PU17.8 PU18.5 PU18.6 PU18.7 PU18.8
PWR_VGT_VIN2: PC50.1 PR5477.1 PR5478.1 PR5479.1 PR5480.1 PT15.1 PU22.5 PU22.6 PU22.7 PU22.8 PU23.5 PU23.6 PU23.7 PU23.8
PWR_VTT_EN: Q1228.5 R31.1
PWRBTN_N: C526.2 R139.1 R332.1 R746.2 R1787.1 R1792.1
PWRBTN_N_CN: R1787.2 TP224.1
PWRCN_DET_N: D5214.2 PWRCN1.5 R79951.2 U2.AA44
PWRGD_3V: C201.1 Q3.G R155.1 R336.2 R338.1 R339.1 R1791.1 R79943.1
PWRGD_3V_B: Q2.B Q3.D R117.2
PWRGD_3V_B_1: Q10.5 Q10.6 R337.2
PWRGD_3V_C: C147.1 Q1.G Q2.C Q4.G R118.2
PWRGD_3V_LL: Q10.3 R338.2
PWRGD_PS_L: C189.1 Q6.2 R288.2 R293.1
PWRGD_PS_L1: Q6.5 Q6.6 R287.2
PWRGD_PS_L2: Q6.3 R292.1
PWROK3_1: R298.2 U109.29
PWROK3_1_R: R298.1 R335.2 R336.1
PWROK3_2: R295.1 U109.75
PWROK3_2_R: R265.1 R295.2 R340.1
Q28_B: Q76.B R1801.2
Q28_C: Q76.C R1957.1
QSA0: GPU1.E19 VRAM2.F3 VRAM4.F3
QSA1: GPU1.C15 VRAM1.F3 VRAM3.F3
QSA2: GPU1.B16 VRAM1.C7 VRAM3.C7
QSA3: GPU1.B22 VRAM2.C7 VRAM4.C7
QSA4: GPU1.R25 VRAM5.F3 VRAM7.F3
QSA5: GPU1.W23 VRAM6.F3 VRAM8.F3
QSA6: GPU1.AB26 VRAM6.C7 VRAM8.C7
QSA7: GPU1.T26 VRAM5.C7 VRAM7.C7
QSA#0: GPU1.F19 VRAM2.G3 VRAM4.G3
QSA#1: GPU1.C14 VRAM1.G3 VRAM3.G3
QSA#2: GPU1.A16 VRAM1.B7 VRAM3.B7
QSA#3: GPU1.A22 VRAM2.B7 VRAM4.B7
QSA#4: GPU1.P25 VRAM5.G3 VRAM7.G3
QSA#5: GPU1.W22 VRAM6.G3 VRAM8.G3
QSA#6: GPU1.AB27 VRAM6.B7 VRAM8.B7
QSA#7: GPU1.T27 VRAM5.B7 VRAM7.B7
RASA#: GPU1.G24 RN7512.1(A) RN7512.2(A) VRAM1.J3 VRAM2.J3 VRAM3.J3 VRAM4.J3 VRAM5.J3 VRAM6.J3 VRAM7.J3 VRAM8.J3
REMOTE1+: C12063.1 R79623.1 RT3.2 U109.87
REMOTE1-: C12063.2 R79619.2 RT3.1
REXT: R2082.1 U118.18
RING2: Q15.2 R80227.1 U9.31
RING2_CON: C266.1 R404.2 R80227.2 UHS1.3
ROM_CS*: GPU1.D12 R609.1
ROM_CS_R*: R607.2 R609.2 U33.1
ROM_SCLK: GPU1.C12 R626.1 R79993.1
ROM_SCLK_R: R626.2 U33.6
ROM_SI: GPU1.B12 R625.1 R633.2 R79986.1
ROM_SI_R: R625.2 U33.5
ROM_SO: GPU1.A12 R79982.1 U33.2
RREF: R79840.1 U14.9
RSMRST*_R: Q10.2 R340.2
RSMRST_N: Q9635.C R291.2 R1778.1 R1993.1 R1994.1 U2.BA11
RSMRST_N_B: Q9635.B R80222.2
RSVD_AE17: TP153.1 U2.AE17
RSVD_AF17: TP152.1 U2.AF17
RSVD_AG14: TP151.1 U2.AG14
RSVD_AG15: TP150.1 U2.AG15
RT: R79708.1 U120.10
RTCX_L: C159.1 R179.1 R180.2 X2.4
RTD2482_VREF: C12190.1 SCA1.44
RTD_PIN2: R9519.2 R9531.2 SCA1.2
RTD_PIN105: R79236.1 R79237.2 R79832.1 SCA1.102
RTD_PIN119: R9525.1 SCA1.119
RTD_PIN121: R9527.2 SCA1.121
RTD_PIN122: R9530.2 SCA1.122
RTD_PIN123: R9536.2 SCA1.123
RTD_PIN124: R9546.2 SCA1.124
RTD_RESETB: C12174.1 R9548.1 SCA1.125
RTL_ISOLATE_N: Q23.6 R436.2 R439.1 U9623.20
RTL_ISOLATE_N_1: C282.1 Q23.5 R438.2 R440.1
RTL_ISOLATE_N_2: Q23.2 Q23.3 R435.2
RTN1: CONVT1.1A CONVT1.1B R79693.2
RTN2: CONVT1.2A CONVT1.2B R79696.2
RTN3: CONVT1.5A CONVT1.5B R79699.2
RTN4: CONVT1.6A CONVT1.6B R79705.2
S_LVDS_BL_EN: R135.1 R143.2 R79719.1 R79722.1 R79724.2
S_TXE0+: LVDS1.18 SCA1.82
S_TXE0-: LVDS1.19 SCA1.83
S_TXE1+: LVDS1.15 SCA1.80
S_TXE1-: LVDS1.16 SCA1.81
S_TXE2+: LVDS1.12 SCA1.78
S_TXE2-: LVDS1.13 SCA1.79
S_TXE3+: LVDS1.8 SCA1.74
S_TXE3-: LVDS1.9 SCA1.75
S_TXEC+: LVDS1.10 SCA1.76
S_TXEC-: LVDS1.11 SCA1.77
S_TXO0+: LVDS1.29 SCA1.94
S_TXO0-: LVDS1.30 SCA1.95
S_TXO1+: LVDS1.27 SCA1.92
S_TXO1-: LVDS1.28 SCA1.93
S_TXO2+: LVDS1.25 SCA1.90
S_TXO2-: LVDS1.26 SCA1.91
S_TXO3+: LVDS1.20 SCA1.86
S_TXO3-: LVDS1.21 SCA1.87
S_TXOC+: LVDS1.22 SCA1.88
S_TXOC-: LVDS1.23 SCA1.89
SA0_DIM0: DIMM1.197 R75.1
SA0_DIM1: DIMM2.197 R86.1
SA1_DIM0: DIMM1.201 R74.1
SA1_DIM1: DIMM2.201 R85.2
SATA__RXN2_C: C495.2 HDD1.5
SATA__RXN3_C: C499.2 ODD2.5
SATA__RXP2_C: C494.2 HDD1.6
SATA__RXP3_C: C498.2 ODD2.6
SATA__TXN2_C: C496.2 HDD1.3
SATA__TXN3_C: C500.2 ODD2.3
SATA__TXP2_C: C497.2 HDD1.2
SATA__TXP3_C: C501.2 ODD2.2
SATA_LED_N_C_1: Q9646.3 Q9646.6 R80201.2
SATAHDR_RX_DN2: L4102.1 U2.F41
SATAHDR_RX_DN2_EMI: C495.1 L4102.2
SATAHDR_RX_DN3: C499.1 U2.D43
SATAHDR_RX_DP2: L4102.4 U2.E41
SATAHDR_RX_DP2_EMI: C494.1 L4102.3
SATAHDR_RX_DP3: C498.1 U2.E42
SATAHDR_TX_DN2: L4103.4 U2.B39
SATAHDR_TX_DN2_EMI: C496.1 L4103.3
SATAHDR_TX_DN3: C500.1 U2.A41
SATAHDR_TX_DP2: L4103.1 U2.A39
SATAHDR_TX_DP2_EMI: C497.1 L4103.2
SATAHDR_TX_DP3: C501.1 U2.A40
SB3V: C278.1 C279.1 C280.1 C377.1 C380.1 C512.1 C513.1 C11836.1 C12166.2 C12237.1 F6.1 MEJ1.1 PR123.1 PR207.1 PR4475.1 PR5302.1 Q56.S Q1264.S Q9601.D R20.1 R96.1 R103.2 R104.2 R105.2 R150.1 R151.2 R203.1 R205.2 R221.1 R222.1 R253.1 R254.1 R279.1 R280.2 R283.2 R284.2 R285.2 R287.1 R300.2 R304.2 R337.1 R341.1 R435.1 R455.2 R474.1 R531.1 R723.1 R727.1 R731.1 R755.1 R760.1 R886.1 R1730.2 R1732.2 R1733.1 R1734.1 R1735.1 R1794.1 R1812.2 R1815.2 R1816.2 R1817.2 R1820.2 R1826.2 R1834.1 R1837.1 R1838.1 R1839.2 R1922.1 R1963.1 R1970.1 R1993.2 R2091.1 R5216.1 R7916.1 R7918.1 R9606.1 R79714.1 R79715.1 R79730.1 R79732.1 R79740.2 R79741.2 R79743.1 R79744.1 R79806.1 R79833.1 R79836.2 R79839.1 R79925.2 R79976.2 R79977.2 R80055.2 R80201.1 R80202.1 R80229.1 R80240.2 RN5.1(A) RN5.2(A) U2.AD41 U2.AJ41 U2.AL41 U2.AN5 U2.BA20 U2.BC42 U2.BD40 U3.5 U22.8 U22.9
SB3V_CT2: C382.1 U22.10
SB3V_EN: C381.1 PR7.2 R513.2 U22.3 U22.5
SB5V: C378.1 C379.1 CN3.1 PC63.1 PR2.1 PR8.1 PR181.2 PR184.2 PR4476.1 PR4477.1 PU32.7 R117.1 R250.2 R515.1 R751.1 R756.1 R1954.1 R1956.1 RN3.5(B) RN3.6(B) RN3.7(B) RN3.8(B) U22.13 U22.14
SB5V_CT1: C383.1 U22.12
SCALAR_ACK: R79940.1 SCA1.53 U2.AL39
SCALAR_EN: R9606.2 R79809.2 U109.120
SCALAR_EN_G: PQ5007.2 R79809.1
SCALAR_MUTE: Q9620.2 R79949.2 SCA1.35
SCALAR_OUT_L: C12192.1 SCA1.45
SCALAR_OUT_L_C: C12192.2 U9615.2
SCALAR_OUT_R: C12193.1 SCA1.46
SCALAR_OUT_R_C: C12193.2 U9615.10
SCALAR_PC_SW1: Q9602.E R9601.2
SCALAR_PC_SW2: Q9602.B R9602.2 R9603.1
SCALAR_PC_SW3: C12171.1 Q9601.G Q9602.C R9604.1 R9605.1
SCALAR_PC_SW4: PQ5007.5 PQ5007.6 R9603.2
SCALAR_PC_SW5: PQ5007.3 R9605.2
SCALAR_SIO_PU: R277.1 R304.1 R305.2 R314.2 R316.2 R317.2 R318.1 R1946.1 R79637.2 R79638.2 R79820.2 R80236.2 R80244.2 RN6.1(A) RN6.2(A)
SD_CD#: MEMCD1.CD U14.30
SD_CLK_C_1: MEMCD1.5 R79846.2
SD_CMD: MEMCD1.2 R79847.2
SD_DAT0: MEMCD1.7 R79845.2
SD_DAT1: MEMCD1.8 R79844.2
SD_DAT2: MEMCD1.9 R79849.2
SD_DAT3: MEMCD1.1 R79848.2
SD_LN0_M: MEMCD1.12 U14.25
SD_LN0_P: MEMCD1.11 U14.26
SD_LN1_M: MEMCD1.16 U14.23
SD_LN1_P: MEMCD1.15 U14.22
SD_VDD2: C311.1 C312.2 MEMCD1.14 U14.13
SD_WAKE#: R79862.1 U2.AE44
SD_WAKE#_IC: R79852.1 R79862.2 U14.32
SD_WP: MEMCD1.WP R79851.2
SDIN: R9502.2 SCA1.116
SDIN_1: R9502.1 U9501.5
SDOUT: R9506.1 SCA1.117
SDREG2: C12156.2 U14.24
SENSE_B: R365.2 R366.2 U9.33
SENSEA: R79936.2 U9.34
SENSEA_D: Q7.D R79936.1
SER_IRQ: R197.2 R200.1 U2.BA17
SER_IRQ_LT_R: R200.2 R264.1 U109.36
SHDN_MUTE_AP_CTL: R9554.1 SCA1.36
SIDE_USB3_RX1+: L20.3 SSUSB1.6 U15.2 U15.9
SIDE_USB3_RX1-: L20.2 SSUSB1.5 U15.1 U15.10
SIDE_USB3_RX2+: L18.3 SSUSB2.6 U16.2 U16.9
SIDE_USB3_RX2-: L18.2 SSUSB2.5 U16.1 U16.10
SIDE_USB3_TX1+: L19.3 SSUSB1.9 U15.5 U15.6
SIDE_USB3_TX1-: L19.2 SSUSB1.8 U15.4 U15.7
SIDE_USB3_TX2+: L17.3 SSUSB2.9 U16.5 U16.6
SIDE_USB3_TX2-: L17.2 SSUSB2.8 U16.4 U16.7
SIO_AGND: C179.2 C181.2 C183.2 C184.2 C188.2 C12446.2 R252.2 R259.2 R272.2 R79619.1 R79620.1 R79621.1 R79945.2 R80238.2 U109.83 U109.84
SIO_AMD SVID_EN: R296.1 U109.26
SIO_ATXPG: R290.1 R292.2 U109.16
SIO_AVCC3: C186.2 C187.1 L1.1 U109.96
SIO_CE_N: R308.1 U6.1 U109.27
SIO_CLK_DB: R79687.1 U109.48
SIO_COPEN#: R303.1 U109.65
SIO_DAT_DB: R79975.1 U109.49
SIO_DEBUG_RX: R268.1 TP104.1 U109.122
SIO_DEBUG_TX: R267.1 TP103.1 U109.121
SIO_GPU_EN: D5205.K D5206.K D5209.K PD8301.K R80018.1 U109.124
SIO_GPU_RST: R79922.1 U109.126 U9621.1
SIO_GREEN: Q9646.2 Q9646.5 R80202.2 U109.23
SIO_GREEN_PWM: R762.1 U109.15
SIO_GREEN_R: Q65.G Q9646.1 R758.1 R760.2 R762.2
SIO_HDD_LED: R747.2 R749.1 U109.11
SIO_HDD_LED_1: Q63.B R749.2
SIO_HOLD#: R311.1 U6.7
SIO_INT#: R80236.1 U109.100
SIO_K8PWR_EN: R269.1 TP105.1 U109.123
SIO_LVDS_BL_ADJ: R284.1 U109.10
SIO_MAIN_VCC3: R286.1 U109.89
SIO_MEM_EVENT_L: R279.2 U109.53
SIO_PCIRSTIN#: R316.1 U109.128
SIO_PSON_D: Q8.D R323.1
SIO_PSON_N: Q8.G R318.2 U109.73
SIO_SCK: C197.1 R294.2 R312.1 U6.6
SIO_SCK_R: R294.1 U109.22
SIO_SI: R313.1 U6.5 U109.21
SIO_SMB2_CLK: R306.1 U109.63
SIO_SMB2_DATA: R307.1 U109.62
SIO_SMCLK0: R79690.1 RN5.3(B) U109.60
SIO_SMDAT0: R79691.1 RN5.4(B) U109.61
SIO_SO: R309.1 U6.2 U109.45
SIO_UART1_RX: R317.1 R9553.2 U109.17
SIO_UART1_RX_R: R9553.1 SCA1.59
SIO_UART1_TX: R9555.2 R79820.1 U109.18
SIO_UART1_TX_R: R9555.1 SCA1.58
SIO_VCORE: C191.1 C12151.1 U109.33
SIO_VIN1: R80215.1 R80216.2 U109.94
SIO_VIN2: C12446.1 R80238.1 R80239.1 TP107.1 U109.93
SIO_VIN3: C179.1 R250.1 R252.1 U109.92
SIO_VIN4: C181.1 R255.1 R259.1 U109.91
SIO_VIN5: C183.1 R266.1 R272.1 U109.90
SIO_VREF: C188.1 R79622.2 R79623.2 R79624.2 U109.88
SIO_WP#: R310.1 U6.3
SIO_WRST#: C12152.1 R319.2 U109.47
SIO_YELLOW: Q64.G R299.1 R755.2 R759.2
SIO_YELLOW_IC: R299.2 U109.31
SKEW1: R1687.2 R1688.1 U2.P44
SKEW2: R79932.2 R79933.1 U2.U43
SKEW3: R1684.2 R1685.1 U2.U42
SKL_CNL_N: CPU1.AB36 R24.2
SKL_PCUDEBUG_0: CPU1.H15 R46.1 R1766.1 XDPC1.9
SKL_PCUDEBUG_1: CPU1.F15 R47.1 XDPC1.11
SKL_PCUDEBUG_2: CPU1.F16 R48.1 XDPC1.15
SKL_PCUDEBUG_3: CPU1.H16 R10.1 R49.1 TP137.1 XDPC1.17
SKL_PCUDEBUG_4: CPU1.F19 R50.1 XDPC1.27
SKL_PCUDEBUG_5: CPU1.H18 R51.1 XDPC1.29
SKL_PCUDEBUG_6: CPU1.G21 R52.1 XDPC1.33
SKL_PCUDEBUG_7: CPU1.H20 R53.1 XDPC1.35
SKL_PCUDEBUG_8: CPU1.G16 R54.1 XDPC1.10
SKL_PCUDEBUG_9: CPU1.E16 R55.2 R56.1 XDPC1.12
SKL_PCUDEBUG_10: CPU1.F17 R57.1 XDPC1.16
SKL_PCUDEBUG_11: CPU1.H17 R58.1 XDPC1.18
SKL_PCUDEBUG_12: CPU1.G20 R59.1 XDPC1.28
SKL_PCUDEBUG_13: CPU1.F20 R60.1 XDPC1.30
SKL_PCUDEBUG_14: CPU1.F21 R61.1 XDPC1.34
SKL_PCUDEBUG_15: CPU1.H19 R62.1 XDPC1.36
SKL_PCUSTB_0_DN: CPU1.E14 XDPC1.6
SKL_PCUSTB_0_DP: CPU1.F14 XDPC1.4
SKL_PCUSTB_1_DN: CPU1.G18 XDPC1.24
SKL_PCUSTB_1_DP: CPU1.F18 XDPC1.22
SKL_XDP_MBP_0: CPU1.D16 XDPC1.21
SKL_XDP_MBP_1: CPU1.D17 XDPC1.23
SLEEVE: Q14.D Q15.1 R80226.1 U9.32
SLEEVE_CON: C264.1 R405.2 R80226.2 UHS1.4
SLEEVE_G: Q14.G Q18.C R407.2 R408.1
SLP_A#_CN: R1786.2 TP222.1
SLP_S3_N: PC5312.1 PQ5302.G R451.2 R505.1 R506.1 R1736.2 R1785.1 R79789.1 R80228.1 U2.AW15 U109.68 U175.2
SLP_S3_N_CN: R1785.2 TP223.1
SLP_S3_N_R3: TP256.1 U109.76
SLP_S4_N: Q31.G R453.2 R1683.1 R1784.1 R1951.2 R1953.1 U2.BD15
SLP_S4_N_C: R297.1 U109.74
SLP_S4_N_CN: R1784.2 TP221.1
SLP_S4_N_R: C12168.1 R1953.2 R1958.2 U171.2
SLP_S4_N_SFR: C12060.1 Q1233.2 R1683.2
SLP_S4_N_SFR_1: Q1233.5 Q1233.6 R1988.2 R1990.1
SLP_S4_N_SFR_2: Q1233.3 R1989.2 R1991.1 R1992.1
SLP_S4_N_SFR_G: C12058.1 C12059.1 Q1234.G R1992.2
SLP_S4_N_SIO: R297.2 R1950.2 R1951.1
SLP_S5_N: R1950.1 U2.BA13
SLP_SUSB: R513.1 R1947.1 R80220.1 U2.BB13 U109.3
SLP_SUSB_C: Q9634.C R80221.1 R80222.1
SLP_SUSB_R: Q9634.B R80218.1 R80219.1 R80220.2
SLP_WLAN_N: R123.1 R729.1 U2.AV13
SMB0_CVT_CLK: C12231.1 R79690.2 U120.6
SMB0_CVT_DATA: C12232.1 R79691.2 U120.7
SMB_CLK_MAIN: DIMM1.202 DIMM2.202 Q4.S Q9501.1 R133.2 R632.2 U6701.4 XDPC1.53
SMB_CLK_RESUME: C146.1 Q4.D R702.1 R1837.2 U2.AW44
SMB_DATA_MAIN: DIMM1.200 DIMM2.200 Q1.S Q9501.4 R124.2 R79992.2 U6701.6 XDPC1.51
SMB_DATA_RESUME: C145.1 Q1.D R704.1 R1838.2 U2.BB43
SMBALERT#: R227.1 R701.1 R1794.2 U2.BB41
SMBUS_ISP: C182.1 Q9501.2 Q9501.5 Q9502.2 Q9502.5 R257.2 R9557.2 R9563.1 U109.115
SML0ALERT#: R221.2 R224.1 U2.BA40
SMLICLK_PCH: C142.2 R79740.1 U2.AW42
SMLIDATA_PCH: C144.2 R79741.1 U2.AW45
SMLINK0_CLK: C140.2 R104.1 U2.AY44
SMLINK0_DATA: C141.2 R105.1 U2.BB39
SO_1: R9506.2 U9501.2
SP1: R79844.1 U14.15
SP2: R79845.1 U14.16
SP3: R79846.1 U14.17
SP4: R79847.1 U14.19
SP5: R79848.1 U14.20
SP6: R79849.1 U14.21
SP7: R79851.1 U14.29
SP_PLLVDD: C463.1 C467.1 C468.2 C469.1 GPU1.M6 L28.2
SPDIF_IC: SCA1.68 U9.16
SPEAKER1_L1: C241.1 R79812.2 U9615.3
SPEAKER1_R1: C234.1 R79813.2 U9615.9
SPEED_100*_CON: RJ1.12 UR6.2
SPEED_100_N: U9623.26 U9624.6 UR6.1
SPEED_1000*_CON: RJ1.11 UR7.2
SPEED_1000_N: U9623.25 U9624.1 UR7.1
SPI_CLK: R352.2 U2.BC31
SPI_CLK_1: R352.1 SRCON1.6 U9622.6
SPI_CS0_N: SRCON1.1 U2.BD31 U9622.1
SPI_CS1_N: TP220.1 U2.AW31
SPI_IO2: R351.1 R1797.1 R1798.2 R1832.1 U2.BC29
SPI_IO3: R348.2 R1799.1 R1800.1 U2.BD30
SPI_MISO: R236.1 R347.1 R1829.2 U2.BE30
SPI_MISO_ROM_1: R347.2 SRCON1.2 U9622.2
SPI_MOSI: R239.2 R355.2 R1779.1 R1828.1 U2.BB29
SPI_MOSI_1: R355.1 SRCON1.5 U9622.5
SPI_WP_N_1: R343.2 R351.2 R1830.1 SRCON1.3 U9622.3
SPKR: R217.2 R371.1 R79861.1 U2.BD26
SPKR_DET: R283.1 R1203.1 U109.59
SPKR_DET_C: R1203.2 SPK1.6
SPKR_IN_L: C241.2 C243.2 U10.6
SPKR_IN_R: C234.2 U10.31
SPKR_L+_C: C253.1 L7.2 R400.1 SPK1.1
SPKR_L+_SNB: C255.1 R400.2
SPKR_L-_C: C254.1 L8.2 R401.1 SPK1.2
SPKR_L-_SNB: C256.1 R401.2
SPKR_OUT_L+: C244.2 C251.1 L7.1 U10.16
SPKR_OUT_L-: C242.2 C252.1 L8.1 U10.18
SPKR_OUT_R+: C235.2 C257.1 L10.1 U10.25
SPKR_OUT_R-: C239.2 C258.1 L11.1 U10.23
SPKR_R+_C: C259.1 L10.2 R402.1 SPK1.4
SPKR_R+_SNB: C261.1 R402.2
SPKR_R-_C: C260.1 L11.2 R403.1 SPK1.3
SPKR_R-_SNB: C262.1 R403.2
SST_HOLDJ_1: R345.2 R348.1 SRCON1.7 U9622.7
SSTCMP: R79695.1 U120.11
SSTCMP_1: C12234.1 R79695.2
STATUS: R79700.1 U120.8
STRAP0: GPU1.D1 R231.1 R234.2
STRAP1: GPU1.D2 R237.2 R238.1
STRAP2: GPU1.E4 R79989.1 R79991.2
STRAP3: GPU1.E3 R219.1 R79783.2
STRAP4: GPU1.D3 R240.2 R243.1
STRAP_REF0: GPU1.F6 R610.2
SUS_LED_GREEN_C: PWRCN1.7 Q64.D R752.2 R758.2
SUS_LED_GREEN_C2: R751.2 R752.1
SUS_PWR_ACK: R126.2 R1949.1 U2.BB19
SUS_PWR_ACK_SIO: R1949.2 R79836.1 U109.13
SUS_WARNB: R126.1 R127.1 R1948.1 U2.BD19
SUS_WARNB_SIO: R1948.2 U109.12
SUSCLK: R137.1 R145.1 U2.AN15
SUSCLK_NGFF: NGFF1.50 R145.2
SW_ON_N: C149.1 R120.1 R139.2 R142.1 U2.AT13
SW_ON_N_SIO: R277.2 R334.1 U109.69
SYS_3VSB: R300.1 U109.67
SYS_FAN_TACH1_1: FANC3.3 R361.2 R364.1
SYS_FAN_TACH1_2: R362.2 R363.1 R364.2
SYSTEM_FAN_PWM1_1: D4.A FANC3.4 R359.2 R360.2
THERMAL_SHUT#_SIO: R285.1 U109.20
TMDS_3V3: C12185.1 C12186.1 C12187.1 L9502.2 R9531.1 SCA1.1 SCA1.20
TP3131_GVDD: C249.2 R396.1 R398.2 U10.2
TP_AC37: CPU1.AC37 TP8.1
TP_BD1: TP63.1 U2.BD1
TP_BE2: TP64.1 U2.BE2
TP_CK_48M_SIO: TP163.1 U2.AR17
TP_CPU_AU9: CPU1.AU9 TP187.1
TP_CPU_AU10: CPU1.AU10 TP188.1
TP_CPU_AU39: CPU1.AU39 TP183.1
TP_CPU_AU40: CPU1.AU40 TP184.1
TP_CPU_AV1: CPU1.AV1 TP20.1
TP_CPU_AV39: CPU1.AV39 TP19.1
TP_CPU_AW2: CPU1.AW2 TP21.1
TP_CPU_AW38: CPU1.AW38 TP149.1
TP_CPU_B39: CPU1.B39 TP180.1
TP_CPU_C40: CPU1.C40 TP179.1
TP_CPU_D15: CPU1.D15 TP189.1
TP_CPU_G38: CPU1.G14 TP9.1
TP_CPU_H11: CPU1.H11 TP13.1
TP_CPU_H12: CPU1.H12 TP15.1
TP_CPU_H37: CPU1.H14 TP10.1
TP_CPU_J7: CPU1.J7 TP14.1
TP_CPU_J8: CPU1.J8 TP12.1
TP_CPU_J11: CPU1.J11 TP192.1
TP_CPU_J13: CPU1.J13 TP191.1
TP_CPU_J14: CPU1.J14 TP186.1
TP_CPU_J15: CPU1.J15 TP185.1
TP_CPU_J17: CPU1.J17 TP178.1
TP_CPU_J19: CPU1.J19 TP177.1
TP_CPU_K8: CPU1.K8 TP17.1
TP_CPU_K10: CPU1.K10 TP182.1
TP_CPU_K11: CPU1.K11 TP190.1
TP_CPU_K12: CPU1.K12 TP262.1
TP_CPU_K13: CPU1.K13 R1996.1
TP_CPU_L8: CPU1.L8 TP16.1
TP_CPU_L10: CPU1.L10 TP181.1
TP_CPU_L12: CPU1.L12 TP261.1
TP_DDR0_DQSN8: CPU1.AU32 TP4.1
TP_DDR0_DQSP8: CPU1.AV32 TP3.1
TP_DDR0_PAR: CPU1.AY15 TP1.1
TP_DDR1_DQSN8: CPU1.AN26 TP6.1
TP_DDR1_DQSP8: CPU1.AN25 TP5.1
TP_DDR1_PAR: CPU1.AL20 TP2.1
TP_DET: R738.2 TOUCH2.1 U109.118
TP_FM_OPC_ZVM_N: CPU1.AC38 TP7.1
TP_FPC_VREF: TP34.1 U2.AR19
TP_FPF_MON: TP36.1 U2.AN17
TP_GPP_A_8: R79766.1 U2.AW22
TP_GPP_A_12: TP58.1 U2.BB17
TP_GPP_B4: TP41.1 U2.BD24
TP_GPP_B_0: TP62.1 U2.AR27
TP_GPP_B_1: TP61.1 U2.AL27
TP_GPP_B_11: TP66.1 U2.AN24
TP_GPP_D_2: TP52.1 U2.AN38
TP_GPP_D_21: TP56.1 U2.AG44
TP_GPP_D_22: TP54.1 U2.AH43
TP_GPP_F6: TP85.1 U2.AB42
TP_GPP_F7: TP266.1 U2.AB43
TP_GPP_F8: TP83.1 U2.AB36
TP_GPP_G20: TP217.1 U2.R35
TP_GPP_G21: TP216.1 U2.U35
TP_GPP_G_12: R99.1 TP31.1 U2.R39
TP_GPP_G_13: TP32.1 U2.R36
TP_GPP_G_14: R100.1 TP33.1 U2.R42
TP_GPP_G_17: TP65.1 U2.N44
TP_GPP_H_10: TP55.1 U2.BD34
TP_GPP_H_11: TP53.1 U2.AW35
TP_GPP_H_12: R1833.1 R1834.2 TP51.1 U2.BD35
TP_GPP_H_13: TP49.1 U2.BC35
TP_GPP_H_14: TP47.1 U2.BA35
TP_GPP_H_15: TP45.1 U2.BB36
TP_GPP_H_16: TP44.1 U2.BD39
TP_GPP_H_17: TP155.1 U2.BE34
TP_GPP_H_18: TP154.1 U2.BC36
TP_H_CATERR_N: CPU1.D13 TP11.1
TP_L_BKLTEN: TP165.1 U2.W35
TP_L_VDDEN: TP142.1 U2.W42
TP_NGFF_COEX1: NGFF1.48 TP113.1
TP_NGFF_COEX2: NGFF1.46 TP114.1
TP_NGFF_COEX3: NGFF1.44 TP115.1
TP_NGFF_LED1: NGFF1.6 TP118.1
TP_NGFF_LED2: NGFF1.16 TP116.1
TP_NGFF_MLDIR: NGFF1.17 TP117.1
TP_PCH_AB13: TP71.1 U2.AB13
TP_PCH_AR22: TP265.1 U2.AR22
TP_PCH_BD14: TP164.1 U2.BD14
TP_PCH_C1: TP263.1 U2.C1
TP_PCH_D1: TP264.1 U2.D1
TP_SDI: TP60.1 U2.BC8
TP_SLP_LAN_N: TP68.1 U2.AV15
TPA3113_SD: Q12.G Q13.6 R390.2 R79871.1
TPA3113_SD1#: C245.1 Q12.D Q9626.G R381.1 R389.2 R79919.1 U10.29
TPA3131_BSNL: C242.1 U10.19
TPA3131_BSNR: C239.1 U10.22
TPA3131_BSPL: C244.1 U10.15
TPA3131_BSPR: C235.1 U10.26
TPA3131_FAULT#: R381.2 U10.30
TPA3131_GAIN: R396.2 R399.1 U10.3
TPA3131_LINN: C240.2 U10.5
TPA3131_LINN_1: C240.1 R387.2
TPA3131_MUTE: Q9626.D R388.1 R79934.2 U10.7
TPA3131_PLIMIT: C250.2 R397.2 R398.1 U10.1
TPA3131_RINN: C236.2 U10.32
TPA3131_RINN_1: C236.1 R382.2
TPA3131_SYNC: TP109.1 U10.11
TPEV_CFG_RCOMP: CPU1.M11 R45.1
TS#_DIMM0_1: DIMM1.198 DIMM2.198 R73.1
U15_ZQ: R235.1 VRAM1.L8
U19_ZQ: R587.1 VRAM5.L8
U35_ZQ: R620.1 VRAM2.L8
U36_ZQ: R79998.1 VRAM6.L8
U9626_ZQ: R80028.1 VRAM4.L8
U9627_ZQ: R80020.1 VRAM3.L8
U9628_ZQ: R80034.1 VRAM8.L8
U9629_ZQ: R80040.1 VRAM7.L8
UART0_RX: CN3.3 U2.BA41
UART0_TX: CN3.2 U2.AV44
USB2_COMP: R188.1 U2.AG3
USB2_ID: R189.1 U2.AG2
USB2_VBUSSENSE: R190.1 U2.AD10
USB3_RX1_DN: L20.1 U2.B7
USB3_RX1_DP: L20.4 U2.A7
USB3_RX2_DN: L18.1 U2.C8
USB3_RX2_DP: L18.4 U2.B8
USB3_TX1_C_DN: C347.1 U2.C11
USB3_TX1_C_DP: C348.1 U2.B11
USB3_TX1_EMI_DN: C347.2 L19.1
USB3_TX1_EMI_DP: C348.2 L19.4
USB3_TX2_C_DN: C349.1 U2.B12
