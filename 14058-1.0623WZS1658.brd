# Allegro board 14058-1.0623WZS1658.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
A20GATE: length 4.7
  TOP w0.102: v2(113.64,63.46) 113.77,63.6 U109.43 113.77,65.81 113.99,66.03 113.99,66.85 R249.1
  BOTTOM w0.102: v3(113.64,64.27) v2(113.64,63.46)
A_BA0: length 120.2
  TOP w0.102: v5(55.36,117.06) 54.96,117.46 54.96,117.89 55.2,118.12 55.7,118.12 55.87,118.29 55.99,118.29 56.2,118.5 56.2,119.12 56.37,119.29 56.37,119.95 VRAM6.M2 ; v5(83.71,85.43) 82.89,86.24 82.28,86.24 VRAM1.M2 ; VRAM2.M2 67.91,85.88 68.24,86.21 68.92,86.21 69.03,86.1 69.96,85.17 69.96,84.86 70.23,84.59 70.57,84.59 70.86,84.88 70.86,84.98 71.06,85.18 v5(71.06,85.43) ; VRAM5.M2 56.37,105.92 56.37,105.3 56.21,105.14 56.21,105.05 v5(55.6,104.45)
  TOP w0.127: GPU1.K25 71.58,107.2 69.74,107.2 67.49,104.95 67.49,99.15 66.72,98.39 ; 66.72,98.39 65.57,97.23 65.34,97.01 65.34,96.27 64.34,95.27 64.34,95.26 64.08,95 64.07,95 64.01,94.94 63.56,94.94 63.55,94.93 63.54,94.93 63.49,94.88 63.06,94.88 v5(63.04,94.86) ; 66.72,98.39 v1(66.72,98.39)
  L3 w0.127: v5(55.6,104.45) 55.6,105.24 56.69,106.32 56.69,108.32 56.15,108.85 56.15,110.98 56.1,111.03 v5(56.1,111.42) ; v5(71.06,85.43) 71.4,85.43 71.59,85.62 72.34,85.62 72.42,85.54 75.33,85.54 75.42,85.62 76.89,85.62 v5(77.26,85.99) 77.53,85.71 79.87,85.71 80.08,85.5 80.56,85.5 80.59,85.53 83.6,85.53 v5(83.71,85.43)
  L4 w0.127: v5(55.36,117.06) 57.27,115.15 57.27,112.72 56.1,111.55 v5(56.1,111.42) 56.1,111.03 56.15,110.98 56.15,110.07 57.06,109.16 57.06,106.21 58.4,104.88 58.4,104.38 57.87,103.85 57.87,103.01 57.93,102.95 57.93,102.9 58.89,101.94 58.89,101.22 59.25,100.86 59.25,99.87 62.96,96.16 62.96,94.96 63.04,94.88 v5(63.04,94.86) 63.06,94.83 63.06,94.52 64.38,93.2 64.38,91.76 65.73,90.41 66.26,90.41 66.58,90.73 68.46,90.73 69.85,89.34 70.28,89.34 70.66,88.96 70.66,88.91 72.49,87.08 74.28,87.08 75.38,85.99 v5(77.26,85.99)
  BOTTOM w0.102: VRAM8.M2 55.62,115.89 55.62,116.8 v5(55.36,117.06) ; RN7506.1 54.56,95.73 54.75,95.54 54.29,95.08 RN7506.2 ; v5(83.71,85.43) 85.1,85.43 85.55,85.88 85.55,85.98 85.78,86.21 86.39,86.21 VRAM3.M2 ; VRAM4.M2 72.26,85.45 71.07,85.45 v5(71.06,85.43) ; v5(55.6,104.45) 55.67,104.38 55.67,103.32 56.37,102.62 56.37,101.78 VRAM7.M2
  BOTTOM w0.127: v5(63.04,94.86) 63.02,94.88 62.93,94.88 62.85,94.96 60.19,94.96 59.82,95.32 58.8,95.32 58.59,95.54 54.75,95.54
A_BA1: length 107.9
  TOP w0.102: v5(55.63,115.08) 55.62,115.08 55.24,115.46 VRAM6.N8 ; v5(72.3,84.7) 72.31,84.7 72.69,85.08 VRAM2.N8 ; v5(71.59,104.71) 71.98,105.1 GPU1.G25 ; v5(86.32,84.69) 86.32,84.7 86.7,85.08 VRAM1.N8 ; VRAM5.N8 54.86,101.83 v5(54.86,101.84)
  L3 w0.127: v5(79.52,85.25) 79.52,84.92 79.38,84.78 75.67,84.78 75.32,84.43 73.87,84.43 73.5,84.8 73.5,84.82 73.24,85.08 VRAM2.N8 72.31,84.7 v5(72.3,84.7) ; v5(55.16,110.6) 55.16,110.42 55.2,110.39 55.2,108.38 54.89,108.08 54.89,108.05 54.88,108.04 54.88,107.69 55.01,107.57 55.01,104.77 54.96,104.71 54.96,104.68 54.3,104.02 54.3,102.39 54.84,101.84 54.84,101.84 54.85,101.84 v5(54.86,101.84)
  L3 w0.165: v5(71.59,104.71) 71.59,104.12 71.35,103.88 71.28,103.88 71.19,103.8 70.65,103.8 69.75,102.89 69.58,102.89 69.32,102.63 69.32,101.96 69.21,101.85 69.21,99.3 64.13,94.22 64.12,94.22 63.93,94.04 63.55,94.04 63.37,94.22 62.64,94.22 62.19,93.78 62.19,93.18 62.32,93.05 v5(62.32,92.9)
  L4 w0.127: v5(55.63,115.08) 56.1,115.08 56.61,114.57 56.61,113.91 56.55,113.85 56.55,113.19 56.43,113.07 56.12,113.07 56,112.94 56,112.48 55.87,112.36 55.69,112.36 55.56,112.48 55.56,113.27 55.44,113.4 55.26,113.4 55.13,113.27 55.13,110.63 v5(55.16,110.6) 55.16,110.42 55.23,110.35 55.23,110.07 56.61,108.7 56.61,105.54 57.09,105.06 57.09,104 56.75,103.66 56.75,101.75 58.01,100.49 58.01,100.16 58.14,100.03 58.14,99.92 58.52,99.54 58.63,99.54 60.33,97.84 60.33,97.82 62.19,95.96 62.19,93.18 62.32,93.05 v5(62.32,92.9) 62.62,92.6 62.64,92.6 62.9,92.34 62.9,92.2 64.88,90.22 64.88,90.08 66.69,88.26 67.68,88.26 67.7,88.29 69.63,88.29 70.13,87.78 70.59,87.78 70.69,87.88 71.04,87.88 71.28,87.63 71.28,87.54 72.47,86.35 73.16,86.35 73.79,85.72 73.98,85.53 74.56,85.53 74.96,85.13 77.81,85.13 78.08,84.86 79.12,84.86 v5(79.52,85.25) 79.52,85.64 80.35,86.47 81.98,86.47 83.71,84.75 83.71,84.18 83.96,83.93 84.56,83.93 84.7,84.07 84.73,84.07 84.95,84.29 85.68,84.29 v5(86.32,84.69)
  BOTTOM w0.102: v5(55.63,115.08) 55.24,115.47 VRAM6.N8 ; RN7509.2 55.5,91.53 55.86,91.53 56.04,91.71 56.06,91.71 56.2,91.85 56.2,91.89 55.9,92.18 RN7509.1 ; v5(72.3,84.7) 72.31,84.7 72.69,85.08 VRAM2.N8 ; VRAM1.N8 86.71,85.08 v5(86.32,84.69) ; VRAM5.N8 55.23,101.45 54.86,101.82 v5(54.86,101.84)
  BOTTOM w0.127: 56.2,91.85 56.33,91.73 56.82,91.73 56.9,91.64 57.28,91.64 57.37,91.73 57.47,91.73 58.74,93 60.65,93 60.75,92.9 v3(61.38,92.9) v5(62.32,92.9)
A_BA2: length 126
  TOP w0.102: VRAM2.M3 69.64,84.93 69.64,84.03 v5(69.81,83.85) ; VRAM5.M3 55.44,104.85 55.44,104.85 54.7,104.12 51.69,104.12 50.03,105.77 v1(50.03,105.97) 50.03,106.64 50.59,107.19 50.59,107.8 50.4,107.99 v5(50.4,109.94) ; VRAM1.M3 82.72,85.68 83.78,84.62 83.78,81.99 82.36,80.58 78.7,80.58 78.47,80.35 v5(77.08,80.35) ; VRAM6.M3 55.66,119.1 55.66,118.83 55.18,118.35 54.88,118.35 v5(54.48,117.94) ; v5(72.37,106.39) 72.37,106.39 GPU1.J24
  L3 w0.165: v5(72.37,106.39) 72.29,106.31 69.9,106.31 69.3,105.7 69.3,104.94 68.4,104.03 68.4,102.8 67.68,102.09 67.68,100.82 59.38,92.52 59.38,91.63 v5(57.96,90.21)
  L4 w0.127: v5(54.48,117.94) 54.36,117.83 54.19,117.83 52.12,115.75 52.12,115.33 51.25,114.46 50.94,112.96 50.83,112.38 50.83,111.66 50.85,111.64 50.85,110.63 50.61,110.39 50.61,110.15 v5(50.4,109.94) 50.62,109.72 50.62,107.45 50.35,107.17 50.35,99.66 51.58,98.42 51.59,98.42 51.68,98.33 52.39,98.33 53.2,97.52 53.2,96.78 55.19,94.8 55.19,93.89 55.68,93.4 55.68,92.77 57.36,91.09 57.36,90.83 57.96,90.23 v5(57.96,90.21) 57.96,90.16 58.15,89.96 58.15,89.83 58.87,89.11 58.87,88.02 60.38,86.51 61.54,86.51 65.37,82.69 65.37,82.32 66.37,81.32 67,81.32 68.04,80.28 74.54,80.28 75.12,80.85 75.7,80.85 75.85,80.69 76.59,80.69 76.93,80.35 v5(77.08,80.35)
  BOTTOM w0.102: v5(69.81,83.85) 69.81,83.22 71.82,81.21 73.72,81.21 74.31,81.8 74.62,81.8 75.09,81.33 75.58,80.83 75.69,80.83 75.82,80.71 76.72,80.71 v5(77.08,80.35)
  BOTTOM w0.127: RN7505.3 53.91,87.74 54.22,88.05 54.56,88.05 ; 54.56,88.05 RN7505.4 ; 54.56,88.05 54.61,88.05 56.04,89.48 56.04,89.53 56.3,89.79 57.23,89.79 57.57,90.13 57.88,90.13 v5(57.96,90.21)
AC_OK#: length 43.4
  TOP w0.102: v2(87.81,38.53) 87.82,38.53 87.82,39.71 v1(88.07,39.97) 89.22,41.12 89.22,42.44 92.24,45.45 93.85,45.45 94.53,44.77 102.25,44.77 102.75,45.26 R79855.1 ; U55.5 72.48,41.15 72.74,41.41 PR5279.2 72.55,41.98 71.98,41.41 v2(71.16,41.41)
  L4 w0.127: v2(87.81,38.53) 87.19,39.15 87.19,40.94 85.97,42.16 72.85,42.16 72.1,41.41 v2(71.16,41.41)
AC_OK#_C: length 4.6
  TOP w0.102: U109.99 106.18,48.31 104.72,46.85 v1(104.46,46.85) 103.64,46.02 R79855.2
AC_PROTECT: length 10.5
  TOP w0.102: v1(71.14,46.19) 71.43,45.9 PR5291.2 72.62,46.18 PQ4408.G 73.92,45.64 73.17,44.89 73.17,43.88 73.63,43.42 74.03,43.42 PR5288.1 74.65,41.98 73.48,40.8 U55.3
ACPRESENT: length 12.1
  TOP w0.102: U2.BB15 150.53,73.81 150.88,73.46 151.65,73.46 151.9,73.71 153.93,73.71 154.37,73.27 v2(154.45,73.27) ; R876.1 161.3,72.5 161.29,72.5 v2(159.41,72.5)
  BOTTOM w0.102: v2(159.41,72.5) 159.41,72.5 v3(158.31,72.5) 158.18,72.63 156.53,72.63 156.28,72.88 154.83,72.88 v2(154.45,73.27)
AD+_2: length 14.8
  TOP w0.635: C358.2 85.41,28.31 R486.1 v1(85.92,30.24) 85.67,30.49 84.68,30.49 U18.4 84.27,31.23 83.64,31.86 v2(78.94,31.86)
  BOTTOM w0.635: U17.4 80.46,30.47 80.14,30.78 R484.2 v2(78.94,31.86)
AD_IA: length 25.7
  TOP w0.254: R80216.1 92.21,46.21 v2(90.14,44.14)
  L4 w0.254: v2(70.24,42.81) 71.08,43.65 80.18,43.65 80.67,44.14 v2(90.14,44.14)
  BOTTOM w0.254: PR5290.2 69.94,43.1 v2(70.24,42.81) 70.34,42.7 v3(70.6,42.15)
AD_IA_HW1: length 50.3
  TOP w0.254: PQ5006.2 70.81,44.31 v2(70.93,44.19) ; R79637.1 106.43,38.72 105.48,38.72 104.72,39.48 104.72,41.13 103.83,42.02 v2(103.83,42.79) 104.08,43.04 105.61,43.04 106.88,44.31 R79859.2
  L4 w0.254: v2(103.83,42.79) 102.41,44.21 91.25,44.21 90.65,43.61 81.05,43.61 80.59,43.14 71.33,43.14 70.46,42.27 70.02,42.27 69.71,42.59 69.71,43.03 70.86,44.18 70.93,44.18 v2(70.93,44.19)
  BOTTOM w0.254: v2(70.93,44.19) 70.94,44.19 70.94,43.8 v3(71.44,43.29)
AD_IA_HW1_C: length 4.6
  TOP w0.203: v1(108.02,47.23) 108.02,47.48 108.98,48.44 U109.106
  TOP w0.254: R79859.1 106.88,45.71 108.02,46.85 v1(108.02,47.23)
AD_IA_HW2: length 51.4
  TOP w0.254: R79638.1 106.56,39.23 105.77,39.23 105.23,39.77 105.23,41.39 v2(104.46,42.15) 104.84,42.53 105.82,42.53 106.5,43.22 v1(107.21,43.22) 107.25,43.26 107.25,43.73 108.02,44.5 R79860.2 ; PQ5006.5 66.87,44.31 v2(66.74,44.18)
  L4 w0.254: v2(66.74,44.18) 68.11,44.18 69.16,43.13 69.16,42.42 69.81,41.77 70.67,41.77 71.54,42.63 80.8,42.63 81.26,43.1 90.86,43.1 91.46,43.7 102.15,43.7 103.7,42.15 v2(104.46,42.15)
AD_IA_HW2_C: length 4.4
  TOP w0.203: 109.38,47.82 U109.107
  TOP w0.254: R79860.1 108.08,45.52 108.42,45.86 108.55,45.86 109.24,46.55 v1(109.24,46.6) 109.38,46.73 109.38,47.82
AD_JK: length 19.3
  TOP w0.635: 74.71,24.76 DCIN1.1 ; DCIN1.1 74.71,26.9 ; DCIN1.1 76.28,25.83
  L3 w0.635: DCIN1.1 76.28,25.83 ; DCIN1.1 74.71,24.76 ; DCIN1.1 74.71,26.9
  L4 w0.635: DCIN1.1 76.28,25.83 ; DCIN1.1 74.71,26.9 ; DCIN1.1 74.71,24.76
  BOTTOM w0.508: PR5270.1 71.7,33.51 73.98,31.23
  BOTTOM w0.635: 74.71,24.76 DCIN1.1 ; DCIN1.1 76.28,25.83 ; DCIN1.1 74.71,26.9
  vias: v1(81.93,28.43) v1(82.16,21.32) v3(74.97,32.47) v3(78.4,27.39) v3(78.96,33.01) v3(82.26,25.49) v4(77.67,26.15) v4(77.67,25.13) v4(78.07,24.14) v4(78.07,23.13) v4(78.53,28.54) v4(78.81,26.15) v4(78.81,25.13) v4(79.11,24.12) v4(79.11,23.1) v4(79.83,28.18) v4(79.83,27.16) v4(79.83,26.15) v4(79.83,25.13) v4(80.13,24.12) v4(80.13,23.1) v4(80.97,28.18) v4(80.97,27.16) v4(81.98,27.16)
ADAPTOR_PSID_R: length 2.9
  BOTTOM w0.102: Q24.S 49.71,29.29 R495.1 48.93,28.88 v3(48.3,28.26)
ADAPTOR_PSID_SIO: length 90.2
  TOP w0.102: v2(54.96,30.97) 54.64,30.66 R492.2 53.35,30.66 53.03,30.97 53.03,31.48 52.39,32.12 D13.3 50.17,31.93 51.12,30.97 v2(51.12,30.21) ; U109.119 114.17,49.99 113.86,50.3 113.61,50.3 111.76,52.16 110.33,52.16 109.47,51.29 109.05,51.29 108.65,51.69 108.65,52.21 v2(108.86,52.41)
  L3 w0.127: v2(108.86,52.41) 108.7,52.26 108.7,51.75 103.31,46.37 90.04,46.37 87.86,44.19 87.86,41.59 85.73,39.45 85.73,37.28 84.83,36.38 78.97,36.38 77.09,34.5 66.67,34.5 65.8,33.64 62.07,33.64 59.85,35.86 58.55,35.86 55.21,32.52 55.21,31.22 v2(54.96,30.97)
  BOTTOM w0.102: v3(51.37,31.02) 51.12,30.77 v2(51.12,30.21) 51.68,29.65 51.68,29.08 50.78,28.18 49.48,28.18 R495.2
ADC_1V2: length 5.6
  TOP w0.305: SCA1.23 45.44,39.46 45.45,39.45 v1(45.77,39.45)
  TOP w0.508: L9523.2 C12189.1 48.01,39.8 C12188.1 46.56,39.8 46.21,39.45 v1(45.77,39.45)
ALL_PWRGD_2: length 6.2
  TOP w0.102: R1129.1 96.4,110.41 v1(96.46,110.48) 96.46,111.86 Q53.D 95.19,113.13 R1195.1
ALL_SYS_PWRGD: length 6.1
  TOP w0.102: v2(23.18,255.13) 23.18,254.34 v1(23.25,254.27) 23.01,254.27 23.01,254.27 22.52,254.27 22.04,254.75 R1972.1 R1980.1 R1973.2
  BOTTOM w0.102: R1979.2 23.56,255.51 v2(23.18,255.13)
AMD_RST#_L: length 7.5
  TOP w0.102: R80059.2 101.48,110.91 U9621.4 100.92,111.98 100.65,112.25 100.65,113.52 100.15,114.03 100.15,114.58 R1212.2 100.44,114.87 R80060.2 v1(101.38,115.96)
AMP_SPKR_L: length 7
  TOP w0.203: R384.2 174.3,42.79 v1(174.3,43.92) ; U9615.4 175.47,45.09 v1(174.3,43.92) ; R79835.1 174.38,44.96 173.91,44.49 173.47,44.49 173.17,44.18 R385.1 174.29,43.93 v1(174.3,43.92)
AMP_SPKR_R: length 7.3
  TOP w0.203: U9615.8 181.42,45.59 181.63,45.38 181.63,44.97 182.03,44.56 R386.1 ; v1(185.16,42.99) 184.86,43.29 R383.2 183.88,43.38 182.7,44.56 R386.1 ; R386.1 182.44,45.74 R79834.1
AMP_SWITCH_C_L: length 2.9
  TOP w0.203: R79812.1 172.22,46.52 171.63,45.93 v1(171.63,45.76) 171.95,45.44 172.2,45.44 172.44,45.2 R79835.2
AMP_SWITCH_C_R: length 3.2
  TOP w0.203: R79834.2 184.7,45.83 v1(185.29,46.42) 184.47,47.23 R79813.1
AUD_AZACPU_SCLK: length 174.9
  TOP w0.102: v2(142.64,58.99) 142.64,59.03 143.73,60.11 144.15,60.11 R113.1 ; CPU1.V3 71.97,170.01 71.97,166.83 72.05,166.74 72.05,164.13 72.09,164.09 72.09,162.34 80.21,154.23 80.21,144.36 88.74,135.83 v1(88.74,135.15) 90.27,133.62 92.25,133.62 v2(93.19,132.68)
  L3 w0.127: v2(93.19,132.68) 93.19,132.86 93.47,133.15 106.41,133.15 109.25,130.31 109.25,128.42 113.73,123.94 120.47,123.94 121.84,122.57 121.84,120.67 v2(121.79,120.62)
  L4 w0.127: v2(142.64,58.99) 142.14,59.49 142.14,60.07 141.87,60.35 141.48,60.35 141.13,60 132.13,60 126.74,65.4 126.07,65.4 122.89,68.57 122.89,73.85 122.04,74.7 120.6,74.7 119.03,76.27 119.03,77.9 119.78,78.65 119.78,81.16 122.28,83.66 123.36,83.66 127.49,87.79 127.49,96.48 127.37,96.59 127.37,100.71 127.68,101.02 127.68,118.3 125.36,120.62 v2(121.79,120.62)
AUD_AZACPU_SCLK_R: length 6.6
  TOP w0.102: U2.AM2 145.51,67.31 145.43,67.22 145.39,67.18 145.39,67.01 145.22,66.85 145.22,64.86 145.27,64.82 145.27,63.99 145.77,63.49 v1(145.77,62.85) 145.71,62.85 144.9,62.04 R113.2
AUD_AZACPU_SDI: length 175.8
  TOP w0.102: CPU1.U1 71.38,161.62 78.9,154.1 78.9,143.78 82.99,139.69 83.71,139.69 88.18,135.22 88.18,134.71 v1(89.58,133.31) 91.38,133.31 v2(92.26,132.43) ; R72.1 147,60.65 146.69,60.35 146.22,60.35 145.67,59.8 145.05,59.8 144.56,59.32 143.98,59.32 143.65,58.99 143.65,58.93 v2(143.58,58.86)
  L3 w0.127: v2(120.73,121.72) 120.95,121.94 120.95,122.64 120.16,123.43 113.45,123.43 105.34,131.55 92.39,131.55 92.25,131.69 92.25,132.42 v2(92.26,132.43)
  L4 w0.127: v2(143.58,58.86) 143.58,59 141.97,60.6 141.37,60.6 141.03,60.26 132.24,60.26 125.93,66.56 125.77,66.56 125.29,67.04 125.29,67.55 124.24,68.6 124.24,74.24 123.52,74.95 120.71,74.95 119.28,76.38 119.28,77.79 120.03,78.55 120.03,81.05 121.44,82.46 121.58,82.46 122.52,82.46 127.88,87.82 127.88,96.44 127.63,96.7 127.63,100.61 127.98,100.96 127.98,118.55 124.45,122.08 121.18,122.08 120.81,121.72 v2(120.73,121.72)
AUD_AZACPU_SDI_R: length 6.4
  TOP w0.102: U2.AN2 145.99,67.04 145.63,66.67 145.63,65.97 146.45,65.14 146.45,64.4 147.02,63.83 147.02,63.49 v1(147,63.46) R72.2
AUD_AZACPU_SDO: length 173.8
  TOP w0.102: R106.1 145.95,60.41 145.6,60.06 144.85,60.06 144.62,59.83 143.88,59.83 143.12,59.07 143.12,58.66 v2(142.69,58.23) ; CPU1.V2 72.3,169.06 72.63,168.73 72.63,167.66 72.83,167.46 72.83,166.69 72.41,166.27 72.41,162.35 81.1,153.66 81.1,143.8 90.67,134.23 v1(91.28,134.23) 92.4,134.23 v2(93.97,132.65)
  L3 w0.127: v2(121.25,121.17) 121.46,121.37 121.46,122.49 120.27,123.68 113.56,123.68 105.31,131.94 94.69,131.94 v2(93.97,132.65)
  L4 w0.127: v2(121.25,121.17) 121.25,120.49 121.59,120.15 121.98,120.15 122.17,120.34 125.28,120.34 127.42,118.2 127.42,101.13 127.12,100.82 127.12,96.48 127.23,96.37 127.23,87.9 123.35,84.02 122.28,84.02 119.53,81.26 119.53,78.76 118.77,78.01 118.77,76.17 120.49,74.45 121.94,74.45 122.64,73.75 122.64,68.47 125.96,65.14 126.63,65.14 132.03,59.75 141.04,59.75 142.56,58.23 v2(142.69,58.23)
AUD_AZACPU_SDO_R: length 5.9
  TOP w0.102: U2.AM1 145.59,67.01 145.59,66.93 145.42,66.76 145.42,65.76 145.5,65.69 145.5,64.6 145.88,64.22 v1(145.88,64.17) 146.39,63.66 146.39,62.19 R106.2
AUD_BEEP_C: length 6
  TOP w0.102: C218.2 174.44,64.54 174.69,64.29 v1(174.69,64.25) 174.69,63.11 174.57,62.98 174.57,61.32 175.04,60.84 U9.2
AUD_BEEP_R: length 5
  TOP w0.102: C218.1 R372.1 171.46,65.56 170.97,66.04 170.97,66.31 v1(170.99,66.32) 171.28,66.61 R370.2 172.07,66.62 R371.2
AUD_DMIC_CLK: length 195.2
  TOP w0.127: L3.2 169.8,52.95 C216.1 169.8,50.46 170.03,50.23 170.78,50.23 v1(170.85,50.16) 171.27,50.57 v2(171.27,51.14) ; WEBCM1.4 173.9,208.9 174.06,208.74 v1(174.06,207.38) 174.06,194.54 175.19,193.41 v2(184.73,193.41)
  L3 w0.127: v2(184.73,193.41) 184.26,192.94 184.26,191.72 186.12,189.85 186.12,160.11 201.22,145.01 201.22,135.59 187.41,121.78 187.41,86.35 186.04,84.99 185.31,84.99 180,79.68 180,76.87 174.19,71.05 174.19,69.38 172.81,68.01 172.81,59.89 172.9,59.81 172.9,57.28 173.64,56.54 173.64,54.13 173.22,53.71 173.22,52.16 172.2,51.14 v2(171.27,51.14)
AUD_DMIC_CLK_R: length 4.6
  TOP w0.127: U9.12 175.48,55.64 174.49,54.65 174.47,54.65 v1(174.03,54.22) 173.7,53.88 R369.1
AUD_DMIC_CLK_R_1: length 2.2
  TOP w0.127: L3.1 170.87,53.85 v1(170.88,53.83) 170.93,53.88 R369.2
AUD_DMIC_DATA: length 193.9
  TOP w0.127: v2(173.69,51.99) 173.68,51.98 172.97,51.98 172.85,52.09 C217.1 173.88,52.82 175.16,51.54 R368.2 ; WEBCM1.5 172.65,209.27 172.15,208.77 v1(172.15,207.38) 172.65,206.88 172.65,195.59 175.72,192.52 v2(184.73,192.52)
  L3 w0.127: v2(184.73,192.52) 186.59,190.65 186.59,160 201.48,145.11 201.48,135.49 187.66,121.67 187.66,96.25 188.73,95.18 188.73,87.31 186.15,84.73 185.42,84.73 180.26,79.57 180.26,76.76 174.44,70.95 174.44,69.28 173.07,67.91 173.07,60 173.16,59.91 173.16,57.38 173.89,56.64 173.89,54.02 173.73,53.86 173.73,52.03 v2(173.69,51.99)
AUD_DMIC_DATA_R: length 3.4
  TOP w0.127: R368.1 175.33,54.14 v1(175.46,54.27) 175.46,54.47 176.3,55.32 U9.13
AUD_DVDD: length 7.6
  TOP w0.203: C222.1 174.05,58.84 U9.7
  TOP w0.508: R374.2 170.34,57.99 v1(170.38,58.03) 170.38,57.53 R375.2 171.66,57.9 C223.1 173.11,57.9 C222.1
AUD_GP3: length 4.3
  TOP w0.203: U9.3 174.87,60.44 v1(173.64,61.67) 173.24,61.67 R373.2
AUD_LINK_BCLK: length 28.9
  TOP w0.102: U9.5 174.6,59.64 174.36,59.88 173.82,59.88 C224.1 172.65,58.71 171.23,58.71 171.13,58.81 169.59,58.81 169.52,58.74 168.47,58.74 167.91,59.3 167.91,59.63 167.23,60.31 165.68,60.31 v1(164.92,61.07) 160.52,61.07 160.42,61.17 160.42,61.3 160.32,61.4 160.11,61.4 160.01,61.3 160.01,61.07 159.89,60.95 159.73,60.95 159.61,61.07 159.61,61.3 159.51,61.4 159.3,61.4 159.2,61.3 159.2,61.17 159.1,61.07 157.92,61.07 155.64,63.35 155.64,64.7 v2(155.3,65.05)
  BOTTOM w0.102: R107.1 153.1,66.01 153.73,65.38 154.96,65.38 v2(155.3,65.05)
AUD_LINK_BCLK_R: length 8
  TOP w0.102: v2(149.75,70.34) 150.1,70.69 U2.BA9
  BOTTOM w0.102: v2(149.75,70.34) 149.83,70.34 150.35,69.82 150.35,69.37 150.23,69.25 150.23,68.72 150.47,68.48 152.89,68.48 153.28,68.87 153.86,68.87 v3(153.96,68.77) 153.96,68.43 153.27,67.74 R107.2
AUD_LINK_RST_N: length 44.2
  TOP w0.102: R416.1 175.08,71.3 175.46,70.92 175.46,70 175.24,69.79 175,69.79 v2(174.96,69.74) ; v2(155.22,65.8) 154.84,65.42 154.84,64.84 155.42,64.26 155.42,63.25 157.95,60.72 158.71,60.72 158.93,60.49 164.99,60.49 165.55,59.93 167.29,59.93 167.66,59.56 167.66,59.23 168.38,58.51 169.74,58.51 169.82,58.58 171.01,58.58 171.11,58.48 173.24,58.48 174.08,59.33 v2(174.08,59.42) 174.27,59.24 U9.6
  L3 w0.127: v2(174.08,59.42) 173.32,60.18 173.32,67.8 174.92,69.4 174.92,69.47 174.95,69.49 174.95,69.73 v2(174.96,69.74)
  BOTTOM w0.102: v2(155.22,65.8) 154.9,66.13 154.9,67.39 v3(155.42,67.91) 155.45,67.91 156.14,68.6 R108.1
AUD_LINK_RST_N_2: length 4.4
  TOP w0.254: v1(183.01,41.78) 183.36,41.78 183.7,41.44 Q13.3 183.7,39.88 183.88,39.7 184.82,39.7 185,39.88 Q13.1
AUD_LINK_RST_N_R: length 4.9
  TOP w0.102: Q18.B 177.14,73.07 C269.1 175.46,73.07 R416.2 174.5,72.19 173.3,70.98 v1(173.27,70.98)
AUD_LINK_RST_R_N: length 6.2
  TOP w0.102: v2(155.58,68.81) 155.5,68.73 154.93,68.73 v1(154.63,68.43) 154.49,68.57 154.18,68.57 152.81,69.93 152.63,69.93 152.1,70.46 U2.BD8
  BOTTOM w0.102: v2(155.58,68.81) 155.57,68.83 155.57,68.85 155.25,69.16 R108.2
AUD_LINK_SDIN: length 29.7
  TOP w0.102: R376.1 170.06,54.77 168.97,54.77 168.39,55.35 168.39,56.32 167.95,56.76 v1(167.91,56.76) 167.13,57.54 166.8,57.54 165.22,59.12 165.22,59.48 164.44,60.26 158.84,60.26 158.61,60.49 157.86,60.49 155.19,63.16 155.19,64.17 154.61,64.74 154.61,65.84 155.04,66.26 155.52,66.26 155.79,66.53 155.79,66.91 155.52,67.18 154.8,67.18 153.87,68.11 153.87,68.27 152.62,69.51 152.47,69.51 152.03,69.96 U2.BE7
AUD_LINK_SDIN_1: length 6.7
  TOP w0.102: U9.8 174.27,58.44 173.75,57.93 173.75,55.92 v1(173.02,55.18) 172.99,55.15 R376.2
AUD_LINK_SDO: length 29.5
  TOP w0.102: v2(156.18,63.46) 158.01,61.63 165.18,61.63 R228.1 R226.2 167.72,60.76 167.84,60.64 169.76,60.64 170.43,61.31 170.43,62.41 C225.1 170.92,61.5 170.9,61.45 U9618.D 171.86,61.25 R377.1
  BOTTOM w0.102: v2(156.18,63.46) 156.15,63.49 v3(152.13,63.49) 151.96,63.65 R109.1
AUD_LINK_SDO_1: length 4.7
  TOP w0.102: U9618.G 169.81,61.27 170.03,61.49 C225.2 R378.2 v1(170.03,65.06)
AUD_LINK_SDO_N: length 7.2
  TOP w0.102: U9618.S 168.99,59.31 169.49,59.8 170.18,59.8 170.3,59.68 171.72,59.68 R377.2 173.51,60.36 v1(173.52,60.35) 174.38,60.35 174.69,60.04 U9.4
AUD_LINK_SDO_R: length 24.6
  TOP w0.102: Q5.C 164.08,56.08 164.08,57.22 163.78,57.52 162.84,57.52 R153.2 162.21,58.72 161.83,59.11 161.83,59.14 161.8,59.16 161.8,59.48 161.54,59.75 161.18,59.75 161.16,59.78 158.68,59.78 158.42,60.03 157.64,60.03 154.73,62.95 154.73,63.96 153.87,64.82 v2(153.87,64.95) ; v2(149.92,69.64) 150,69.72 150,69.73 U2.BB7
  BOTTOM w0.102: v2(153.87,64.95) 153.09,64.95 v3(152.67,65.37) 152.47,65.57 152.47,67.23 R109.2 151.77,67.55 150.65,67.55 150.31,67.89 150.31,68.36 150.03,68.64 150.03,69.54 v2(149.92,69.64)
AUD_LINK_SDO_R1: length 134.8
  TOP w0.102: v2(162.29,59.3) 162.5,59.3 163.1,58.7 R153.1 ; MEJ1.2 140.16,128.14 146.26,128.14 150.07,131.96 150.07,131.97 150.18,132.08 150.19,132.08 150.69,132.57 155.14,132.57 159.08,128.63 173.23,128.63 177.95,123.91 v1(180.26,123.91) 182.16,123.91 v2(183.08,124.83)
  L3 w0.127: v2(183.08,124.83) 182.9,124.65 182.9,122.05 184.82,120.14 184.82,91.92 184.2,91.3 180.31,91.3 179.68,90.66 178.17,90.66 176.6,89.09 176.6,85.74 174.31,83.45 174.31,82.38 172.01,80.09 172.01,78.26 171.32,77.57 171.32,76.92 167.36,72.96 164.53,72.96 164.03,72.46 164.03,61.28 162.29,59.54 v2(162.29,59.3)
AUD_LINK_SYNC: length 32.5
  TOP w0.102: v2(153.87,65.92) 154.3,65.49 154.3,64.73 154.96,64.07 154.96,63.06 157.76,60.26 158.52,60.26 158.75,60.03 164.34,60.03 164.99,59.38 164.99,58.27 167.81,55.45 167.81,54.89 v1(168.36,54.34) 168.77,54.34 168.88,54.44 173.07,54.44 173.98,55.35 173.98,57.83 174.25,58.1 174.63,58.1 174.69,58.04 U9.9
  BOTTOM w0.102: R111.1 154.25,66.3 v2(153.87,65.92)
AUD_LINK_SYNC_R: length 6.3
  TOP w0.102: U2.BD9 151.47,70.76 152.09,70.76 152.6,70.25 v2(153.26,70.25)
  BOTTOM w0.102: v2(153.26,70.25) 153.48,70.47 153.99,70.47 154.03,70.43 v3(154.07,70.43) 154.07,70.35 154.02,70.29 154.02,69.44 154.6,68.86 154.6,68.1 R111.2
AUD_REGREF: length 4
  TOP w0.203: U9.10 v2(174.44,57.64)
  BOTTOM w0.508: C221.1 175.46,58.89 v3(175.43,58.86) 175.28,58.86 174.44,58.03 v2(174.44,57.64)
B_BA2: length 129.1
  TOP w0.102: RN7503.1 59.02,88.66 58.79,88.89 v5(58.1,88.89) 58.37,88.62 RN7503.2
  TOP w0.127: GPU1.J27 70.09,106.8 67.83,104.55 67.83,98.69 65.86,96.71 65.86,96.29 64.34,94.78 64.34,94.42 63.53,93.61 63.53,93.27 63.4,93.15 63.4,90.66 62.73,89.99 60.82,89.99 60.18,90.62 59.82,90.62 59.25,91.18 58.92,91.18 58.55,91.55 57.78,91.55 57.5,91.27 56.43,91.27 56.1,90.94 56.1,90.49 56.31,90.28 56.31,89.8 56.04,89.53 56.04,88.74 v1(56.56,88.23) 57.44,88.23 v5(58.1,88.89)
  L3 w0.127: v5(84.38,84.38) 84.37,84.37 84.37,84.35 83.84,83.82 83.84,82.84 82.86,81.86 82.86,81.84 82.54,81.52 79.74,79.67 78.73,79.67 78.63,79.56 v5(78.53,79.56) ; v5(55.65,102.64) 55.63,102.61 55.63,102.1 55.34,101.81 55.34,101.61 55.09,101.36 52.85,101.36 51.92,102.28 v5(50.18,107.63)
  L4 w0.127: v5(50.18,107.63) 50.01,107.46 50.01,99.3 51.37,97.93 52.22,97.93 52.6,97.55 52.6,97.09 52.27,96.76 52.27,96.33 53.14,95.45 53.32,95.45 53.59,95.72 53.77,95.72 53.95,95.54 53.95,95.36 53.68,95.09 53.68,94.91 55.34,93.26 55.34,92.62 57.02,90.94 57.02,90.46 57.93,89.55 57.93,89.06 v5(58.1,88.89) 58.1,88.3 63.29,83.11 63.29,83.06 65.28,81.06 66.79,81.06 67.86,80 74.59,80 75.21,80.62 75.6,80.62 75.87,80.35 76.37,80.35 77.16,79.56 v5(78.53,79.56)
  BOTTOM w0.102: VRAM4.M3 72.08,85.88 72.49,86.28 73.57,86.28 73.8,86.51 74.43,86.51 75.3,85.64 75.3,84.57 77.26,82.61 77.26,82.56 77.86,81.97 77.86,80.24 v5(78.53,79.56) ; v5(55.65,102.64) 56.02,102.26 VRAM7.M3 ; v5(50.18,107.63) 50.18,107.79 54.32,111.94 54.62,111.94 56.59,113.91 56.59,114.3 56.44,114.45 56.44,115.54 56.04,115.95 VRAM8.M3 ; VRAM3.M3 84.45,84.42 84.42,84.42 v5(84.38,84.38)
BATLOW_N: length 15.4
  TOP w0.089: U2.BD13 151.64,72.51 152.1,72.51 152.15,72.46 153.4,72.46
  TOP w0.102: R116.1 164.33,73.33 163.63,72.63 163.63,72.45 162.85,71.66 161.31,71.66 161.01,71.96 160.31,71.96 159.73,71.39 155.37,71.39 154.56,72.2 v1(154.2,72.2) 153.66,72.2 153.4,72.46
BIOS_REQ: length 173.3
  TOP w0.102: SCA1.105 31.01,27.97 30.69,28.29 30.69,29.37 32.75,31.43 35.19,31.43 35.34,31.28 35.72,31.28 35.87,31.43 38.47,31.43 40.32,29.59 40.98,29.59 v2(41.22,29.35) ; U2.W39 139.29,85.7 139.4,85.58 139.4,85.58 139.59,85.39 139.59,85.38 139.64,85.33 139.64,85.16 v2(139.87,84.93) ; v2(141.91,96.62) 141.36,97.17 141.36,98.73 141.48,98.86 R79942.1
  L3 w0.127: v2(141.91,96.62) 138.92,93.63 138.92,92.27 137.23,90.58 137.23,88.96 136.36,88.08 136.36,87.57 135.25,86.47 135.25,85.96 133.23,83.93 132.27,83.93 132.01,83.67 132.01,83.03 129.48,80.5 123.64,80.5 121.35,78.22 119.45,78.22 109.92,68.69 109.16,68.69 106.7,66.23 106.7,66.12 103.94,63.36 103.83,63.36 101.8,61.33 101.8,61.04 100.66,59.91 100.66,58.89 98.59,56.82 98.59,54.29 97.54,53.23 93.11,53.23 93.1,53.25 91.65,53.25 91.64,53.23 91.02,53.23 90.4,52.61 87,52.61 82.19,47.8 81.05,47.8 79.68,46.43 64.43,46.43 63.29,47.57 57.18,47.57 55.6,45.99 50.77,45.99 49.6,44.82 47.03,44.82 41.34,39.13 41.34,33.52 40.75,32.92 40.75,29.82 v2(41.22,29.35)
  BOTTOM w0.102: v2(139.87,84.93) 139.87,85.09 140.48,85.7 140.48,87.07 140.73,87.32 140.73,88.48 140.53,88.68 140.53,90.08 141.12,90.67 141.12,93.13 142.51,94.52 v3(142.51,95.01) 142.51,96.06 141.95,96.62 v2(141.91,96.62)
BIST_DISABLE: length 117.3
  TOP w0.102: v2(105.83,41.62) 105.96,41.74 108.08,41.74 108.08,41.74 108.46,41.74 109.25,42.53 113.97,42.53 115.13,43.69 115.13,44.18 115.46,44.51 115.46,46.42 114.7,47.18 113.32,47.18 112.64,47.87 112.06,47.87 111.38,48.55 U109.112
  L4 w0.127: v2(105.83,41.62) 105.83,42.18 102.85,45.16 75.69,45.16 75.66,45.19 65.36,45.19 65.33,45.16 63.82,45.16 61.13,47.85 52.87,47.85 52.38,48.33 v2(52.35,48.33)
  BOTTOM w0.102: v2(52.35,48.33) 52.35,48.34 52.35,48.38 51.39,49.34 47.35,49.34 46.42,50.27 46.42,51.56 v3(46.05,51.93) 44.42,53.56 42.33,53.56 41.93,53.96 34.74,53.96 33.67,52.89 30.75,52.89 30.45,53.2 30.45,53.24 30.18,53.5 28.36,53.5 27.3,52.44 26.61,52.44 26.23,52.06 24.61,52.06 21.81,49.25 21.81,48.27 20.39,46.85 R531.2 20.14,46.66 R533.1 19.06,46.66 18.17,47.55 R79924.1
BIST_DISABLE_1: length 3.2
  BOTTOM w0.254: Q9628.5 19.12,45.54 18,46.66 R79924.2 17.53,46.66 17.04,46.16 v3(17.04,46.09)
BIST_EN: length 17.5
  TOP w0.254: v2(26.43,50.01) 26.38,50.05 26.38,50.63 26.12,50.89 v2(26.12,50.94)
  BOTTOM w0.254: v2(26.12,50.94) 25.11,50.94 v3(23.69,49.52) 22.88,48.7 22.88,46.04 21.91,45.07 19.82,45.07 Q9628.6 19.77,44.65 19.27,44.16 18.92,44.16 18.47,43.71 Q9628.3 17.67,43.24 17.3,43.61 R524.2 ; Q9629.2 26.75,48.63 26.41,48.97 26.41,49.99 v2(26.43,50.01)
BIST_EN_INV: length 16.1
  TOP w0.102: SCA1.63 30.51,50.24 30.73,50.46 30.73,51.79 30.33,52.18 29.11,52.18 28.85,51.93 v2(28.65,51.93) 27.89,51.17 R517.2
  BOTTOM w0.102: R80233.1 28.78,52.06 v2(28.65,51.93) 28.65,51.33 v3(28.28,50.96) 27.86,50.53 27.86,48.35 27.48,47.98 Q9629.3 26.5,47.98 25.98,48.5 25.98,49.01 25.71,49.28 Q9629.6
BIST_EN_SIO: length 174.5
  TOP w0.102: R1826.1 120.74,60.69 v2(120.69,60.74) 120.36,60.41 U109.25
  L3 w0.127: v2(120.69,60.74) 120.62,60.82 118.64,60.82 116.66,58.84 112.9,58.84 100.68,46.62 89.94,46.62 87.61,44.29 87.61,41.69 85.48,39.56 85.48,37.38 84.73,36.63 78.86,36.63 76.99,34.76 66.56,34.76 65.7,33.9 62.28,33.9 60.05,36.12 58.44,36.12 54.49,32.16 54.49,25.14 54.95,24.69 54.95,22.45 54.66,22.16 54.53,22.16 54.08,21.72 54.08,18.82 54.6,18.3 54.6,15.66 53.8,14.86 49.61,14.86 47.44,12.69 45.89,12.69 45.55,12.34 39.9,12.34 37.17,15.07 36.34,15.07 35.23,13.96 30.17,13.96 29.41,14.72 29.41,17.02 30.42,18.03 30.42,24.36 30.8,24.74 30.8,28.69 30.93,28.82 30.93,39.36 33.22,41.64 33.22,47.74 34.37,48.89 v2(34.37,50.1)
  BOTTOM w0.102: R80233.2 32.45,50.66 33.81,50.66 v2(34.37,50.1) ; v3(120.85,59.93) 120.85,60.59 v2(120.69,60.74)
BIST_ENABLE: length 111.2
  TOP w0.102: U109.113 111.77,48.53 112.21,48.09 112.73,48.09 113.42,47.41 114.8,47.41 115.69,46.52 115.69,44.42 115.36,44.09 115.36,43.59 114.07,42.3 109.34,42.3 108.56,41.51 107.99,41.51 107.99,41.52 106.62,41.52 106.12,41.01 v2(105.84,40.73)
  L4 w0.127: v2(105.84,40.73) 105.84,40.9 105.35,41.39 105.35,42.3 102.74,44.91 75.59,44.91 75.56,44.94 65.47,44.94 64.6,44.07 64.6,41.39 61.94,38.73 57.82,38.73 54.55,42 54.55,45.5 52.47,47.59 52.17,47.59 v2(51.44,48.32)
  BOTTOM w0.102: R79923.1 31.69,50.66 33.22,49.14 35.5,49.14 36.52,50.15 v3(36.52,51.17) 37.13,51.78 38.32,51.78 38.93,51.17 44.31,51.17 46.56,48.92 46.56,48.46 46.87,48.15 47.62,48.15 48.26,48.78 50.98,48.78 v2(51.44,48.32)
BIST_ENABLE_1: length 14.4
  BOTTOM w0.102: Q9629.5 24.05,48.63 23.75,48.33 R523.1 23.69,46.4 23.69,45.69 23.93,45.45 v3(24.01,45.45) 24.99,45.45 25.52,45.98 25.52,46.32 R79806.2 26.5,47.31 27.46,47.31 28.16,48 28.16,50.06 28.76,50.66 R79923.2
BIST_PIN25: length 118.3
  TOP w0.102: U109.24 120.31,60.01 120.64,59.68 122.22,59.68 R80240.1 122.73,60.13 124.02,60.13 v2(124.28,59.88)
  L3 w0.127: v2(106.24,71.92) 104.97,70.65 104.97,69.5 101.03,65.57 101.03,63.62 99.01,61.6 99.01,59.57 95.11,55.68 92.58,55.68 92.01,55.1 89.19,55.1 88.35,54.27 87.48,54.27 86.32,54.27 81.5,49.45 80.37,49.45 78.99,48.08 65.11,48.08 63.81,49.39 48.7,49.39 v2(47.67,50.42)
  L4 w0.127: v2(124.28,59.88) 124.27,59.88 123.72,59.88 122.33,61.27 121.55,61.27 121.1,61.72 121.1,61.96 121.09,61.97 121.09,61.99 120.81,62.27 120.8,62.27 119.37,63.69 119.37,64.18 118.75,64.79 118.49,64.79 118.02,65.26 116.14,65.26 114.11,67.3 113.41,67.3 110.6,70.11 110.6,70.12 109.65,71.07 107.09,71.07 v2(106.24,71.92)
  BOTTOM w0.102: v2(47.67,50.42) 47.67,51.45 45.05,54.07 v3(42.85,54.07) 42.7,54.22 33.63,54.22 Q9650.G
BIST_PIN25_G: length 9
  BOTTOM w0.508: R80230.2 26.36,55.74 26.74,55.36 Q9648.G 27.76,55.36 28.31,55.92 28.31,56.93 28.9,57.52 30.3,57.52 v3(30.8,57.01) 32.07,55.74 Q9650.D
BKLT_ADJ: length 4.6
  BOTTOM w0.165: C12230.1 C12229.1 9.53,18.47 v3(9.98,18.02) 9.98,17.19 R79721.2 9.78,16.88 R79694.2
BKLT_EN: length 8.4
  TOP w0.102: R79720.2 8.24,18.43 R79722.2 ; R79722.2 9.52,18.08 C12226.1 ; R79722.2 R79704.2 8.26,17.07 7.94,17.39 7.44,17.39 v1(7.31,17.26) 7.31,16.7 v2(7.64,16.37)
  BOTTOM w0.102: Q1260.C 6.99,17.01 v2(7.64,16.37)
BKLT_EN1: length 15.6
  TOP w0.102: v2(3.88,16.5) 3.6,16.78 3.6,19.76 4.5,20.66 10.07,20.66 R135.2
  BOTTOM w0.102: Q1260.B 5.4,15.96 v3(5.4,14.97) 5.15,14.72 4.39,14.72 3.88,15.23 v2(3.88,16.5)
BOARD1: length 12.2
  TOP w0.102: U2.U41 137.83,86.68 137.35,87.16 137.35,88.39 137.31,88.43 137.31,88.9 137.51,89.1 137.51,90 135.93,91.57 v1(135.93,92.7) 135.93,92.92 135.49,93.37 135.49,95.08 136.28,95.87 R1663.1 R1661.2
BOARD2: length 16.4
  TOP w0.102: v2(133.34,96.71) 133.19,96.71 132.78,97.12 131.29,97.12 130.94,97.46 R79931.1 R1662.2 ; v1(132.45,94.83) 131.92,94.3 131.92,93.81 131.9,93.79 v2(131.9,93.76) 131.9,93.74 132.53,93.1 132.53,90.91 133.38,90.05 133.6,90.05 135.47,88.19 U2.M44
  L3 w0.127: v2(131.9,93.76) 131.9,95.08 132.3,95.49 132.3,95.92 133.01,96.63 133.19,96.63 133.22,96.66 133.29,96.66 v2(133.34,96.71)
BOARD3: length 8.9
  TOP w0.102: v2(137.49,84.59) 137.49,84.59 137.69,84.59 137.74,84.54 137.78,84.54 137.92,84.4 U2.U36
  BOTTOM w0.102: R1659.2 R1660.1 136.28,89.87 136.24,89.83 136.24,89.47 136.8,88.91 136.8,87.46 v3(136.9,87.36) 137.99,86.27 137.99,85.1 v2(137.49,84.59)
BQ24737_REGN: length 5.6
  TOP w0.305: 75.28,37.17 U55.16
  TOP w0.508: 75.28,37.17 75.76,36.68 75.76,34.99 v1(75.79,34.96) 75.75,34.93 75.75,34.42 PC5237.2 75.77,33.64 76.35,33.64 76.45,33.74 PD4401.A
BUFRST_N: length 2.8
  TOP w0.127: GPU1.D11 83.93,102.25 v5(83.99,102.25)
  BOTTOM w0.127: R79994.1 83.9,101.36 84.6,101.36 v3(84.68,101.43) 84.68,101.74 84.17,102.25 v5(83.99,102.25)
BUZZER_SPKR_R: length 20
  TOP w0.102: R370.1 173.47,66.61 173.98,66.1 173.98,66 v2(174.16,65.82) ; v2(174.27,51.49) 173.22,51.49 v1(172.69,50.96) 172.66,50.94 C243.1
  L3 w0.127: v2(174.16,65.82) 173.58,65.24 173.58,60.59 174.91,59.26 174.91,52.13 v2(174.27,51.49)
CAGND: length 39.7
  TOP w0.508: C12231.2 C12232.2 15.56,20.33 v2(14.93,20.97) ; v2(6.55,13.63) 6.88,13.96 C12227.2 R79707.2 ; v2(13.91,10.27) 15.18,11.54 15.18,13.7 v2(15.44,13.96) ; C12234.2 16.39,16.12 R79708.2 ; v2(16.22,14.69) 16.33,14.59 R79709.2
  L4 w0.508: v2(15.44,13.96) 15.11,13.63 v2(6.55,13.63) ; v2(17.6,18.24) 17.51,18.24 15.46,16.19 v2(15.46,15.53)
  BOTTOM w0.305: U120.15 16.43,13.75 v2(15.44,14.75)
  BOTTOM w0.508: v2(14.93,20.97) 15.44,20.46 R79700.2 ; R79700.2 v3(14.42,20.12) 13.72,19.42 C12228.2 ; R79700.2 C12233.2 16.54,20.03 18.87,20.03 19.14,19.75 v3(19.14,19.29) 18.76,18.91 18.13,18.91 17.6,18.38 v2(17.6,18.24) ; C12236.1 6.75,13.83 v2(6.55,13.63) ; C12235.2 13.72,10.46 v2(13.91,10.27) ; R79702.2 11.58,16.99 v2(11.58,17.89)
  vias: v1(14.8,16.62) v2(14.65,14.74)
CASA#: length 103.5
  TOP w0.102: GPU1.G26 71.18,105.11 v5(70.78,104.71) ; v5(84.42,87.09) 83.83,87.09 83.57,87.35 82.85,87.35 VRAM1.K3 ; VRAM2.K3 69.62,87.48 v5(69.99,87.11) ; VRAM5.K3 57.51,105.32 57.51,103.48 v5(57.45,103.41) ; VRAM6.K3 57.64,119.28 57.48,119.12 57.48,118.44 v5(57.18,118.14)
  TOP w0.127: v2(58.57,96.63) 58.57,96.86 59.16,97.46 R7513.1
  L3 w0.127: v5(57.45,103.41) 57.37,103.49 57.37,109.15 57.54,109.32 v5(57.54,110.86) ; v5(84.42,87.09) 84.24,87.27 83.91,87.27 83.9,87.29 82.82,87.29 82.66,87.13 79.27,87.13 79.13,87.27 77.97,87.27 77.87,87.17 77.41,87.17 77.32,87.26 76.78,87.26 v5(76.75,87.29) 76.68,87.21 74.29,87.21 73.7,86.63 71.77,86.63 71.37,87.03 70.06,87.03 v5(69.99,87.11)
  L4 w0.127: v5(76.75,87.29) 75.54,87.29 73.84,88.99 73.46,88.99 70.63,91.82 70.63,92.11 70.38,92.35 70.04,92.35 70.02,92.33 68.88,92.33 67.98,91.44 67.27,91.44 66.84,91.86 66.34,91.86 66.03,92.17 66.03,94.17 65.55,94.65 65.55,95.06 v5(64.41,96.2) 64.38,96.2 60.9,99.68 60.9,100.37 61.69,101.16 61.69,103.72 61.16,104.25 60.67,104.25 60.29,104.63 60.29,104.94 59.86,105.37 59.45,105.37 59.15,105.68 59.15,107.02 58,108.16 58,110.4 v5(57.54,110.86) 57.42,110.98 57.42,112.38 57.62,112.58 57.62,116.53 57.12,117.03 57.12,118.08 v5(57.18,118.14)
  BOTTOM w0.102: VRAM8.K3 57.18,116.74 v5(57.18,118.14) ; VRAM4.K3 71.46,87.05 70.11,87.05 70.06,87.11 v5(69.99,87.11) ; v5(57.45,103.41) 57.5,103.41 57.92,103 57.92,102.53 VRAM7.K3 ; VRAM3.K3 85.71,87.48 85.7,87.49 84.82,87.49 v5(84.42,87.09)
  BOTTOM w0.127: v5(70.78,104.71) 68.96,104.71 v3(67.99,103.74) 67.2,102.95 67.2,101.53 64.41,98.74 v5(64.41,96.2) 63.09,97.52 59.51,97.52 58.62,96.63 v2(58.57,96.63) 58.57,97.41 R7514.1
CBN: length 3.3
  TOP w0.203: C209.2 180.41,53.88 179.82,54.47 v1(179.75,54.47) 179.75,54.54 179.5,54.78 U9.21
CBP: length 6.4
  TOP w0.203: U9.24 180.7,55.65 v2(181.3,55.05)
  TOP w0.508: C209.1 v2(180.41,51.4)
  BOTTOM w0.508: v2(180.41,51.4) 181.73,52.72 v3(181.73,53.25) 181.73,54.62 v2(181.3,55.05)
CE: length 51.2
  TOP w0.102: R9504.1 v2(52.9,11.8) ; SCA1.118 37.51,25.91 v2(37.79,25.64) 37.79,25.32 36.01,23.54 28.77,23.54 27.76,24.55 21.17,24.55 20.52,23.89 20.52,22.97 20.77,22.72 20.77,21.2 20.26,20.69 R9505.1 R9503.1
  L3 w0.127: v2(37.79,25.64) 37.55,25.4 37.55,21.73 37.54,21.72 37.54,20.43 39.57,18.4 39.57,17.66 v2(40.35,16.88)
  BOTTOM w0.102: v2(52.9,11.8) 52.9,12.18 v3(50.56,14.52) 49.34,15.75 47.16,15.75 47.15,15.74 44.89,15.74 44.14,16.5 40.73,16.5 v2(40.35,16.88)
CE#_1: length 5
  TOP w0.102: R9504.2 55.38,12.56 56.5,12.56 v1(57.09,11.97) 56.46,11.34 U9501.1
CFG: length 6.3
  TOP w0.102: U118.23 v2(159.92,42.25)
  BOTTOM w0.102: R1594.2 v3(160.15,39.58) 160.15,42.02 v2(159.92,42.25)
CHAR_CTL1: length 3.9
  TOP w0.102: R451.1 v2(176.73,104.13)
  BOTTOM w0.102: U9625.6 177.48,103.75 177.11,104.13 v2(176.73,104.13) 176.47,104.13 v3(175.84,103.49)
CHAR_CTL2: length 4
  TOP w0.102: R453.1 176.05,105.52 176.69,104.89 v2(176.73,104.89)
  BOTTOM w0.102: v3(175.84,104.89) v2(176.73,104.89) 177.23,104.89 177.87,104.25 U9625.7
CHAR_CTL3: length 4
  TOP w0.102: R454.1 v2(176.73,106.92)
  BOTTOM w0.102: v2(176.73,106.92) v3(176.73,106.03) 178.01,104.75 U9625.8
CHAR_EN: length 62.5
  TOP w0.102: v2(174.08,102.81) 174.1,102.79 R455.1 175.85,102.79 v1(175.91,102.86) 176.33,102.86 v2(176.73,103.25) ; U2.P43 136.35,87.83 136.35,88.42 136.29,88.48 136.24,88.54 136.24,89.19 134.44,90.99 134.44,91.25 v2(133.8,91.88)
  L3 w0.127: v2(133.8,91.88) 134.18,92.26 134.18,97.17 134.53,97.52 135.35,97.52 140.52,102.69 148.02,102.69 148.77,101.94 149.24,101.94 149.99,102.69 155.28,102.69 157.3,100.67 168.52,100.67 169.3,99.9 173.62,99.9 174.55,100.83 174.55,102.02 174.08,102.49 v2(174.08,102.81)
  BOTTOM w0.102: U9625.5 v2(176.73,103.25)
CHAR_ILIM_HI: length 4.2
  BOTTOM w0.102: U9625.16 182.99,103.25 183.41,102.83 v3(184.04,102.83) 184.12,102.83 184.79,103.5 R80049.1
CHAR_ILIM_LO: length 3.7
  BOTTOM w0.102: U9625.15 183.26,103.75 v3(183.62,104.11) 184.53,105.02 R457.1
CHAR_ILIM_SEL: length 4
  BOTTOM w0.102: R456.1 176.15,101.71 v3(176.85,101.71) 178.12,101.71 178.86,102.45 U9625.4
CHAR_STATUS: length 2.4
  BOTTOM w0.102: U9625.9 179.01,105.55 178.12,106.44 TP72.1
CHAR_USBOC#: length 2.9
  BOTTOM w0.102: R452.1 v3(183.06,105.19) 183.01,105.14 182.31,105.14 181.92,104.75 U9625.13
CHG_AGND: length 42.1
  TOP w0.406: PQ5006.4 68.16,44.96 68.9,45.71 ; PC5245.2 69.41,41.77 69.41,43.29 69.78,43.66 PQ5006.1 70.44,43.66 70.86,43.24 v1(71.12,43.24)
  TOP w0.508: v2(70.83,37.07) 70.83,36.18 70.49,35.83 70.49,34.19 PR5268.2 ; PC5245.2 70.48,41.01 70.91,40.58 v2(70.94,40.58) ; v2(77.26,44.18) PC5234.2 ; v2(77.16,40.12) 77.41,39.86 PC5233.2 ; PR5468.2 v2(66.49,40.25) ; v1(71.12,43.24) 71.8,43.92 v2(71.8,44.18) 71.8,44.26 70.35,45.71 68.9,45.71
  BOTTOM w0.508: PC4432.2 75,38.64 75,41.67 ; v3(76.52,41.67) 77.16,41.03 v2(77.16,40.12) ; v3(76.52,41.67) 77.26,42.4 v2(77.26,44.18) ; v3(76.52,41.67) 75,41.67 ; PC5232.2 71,40.54 70.96,40.58 v2(70.94,40.58) ; PC5232.2 PR5286.2 71,37.24 v2(70.83,37.07) 70.83,36.14 PR5274.2 ; PC5232.2 70.55,39.74 70.17,39.36 68.01,39.36 67.13,40.25 v2(66.49,40.25) ; 75,41.67 74.26,42.4 73.43,42.4 71.8,44.04 v2(71.8,44.18)
CHG_SMB2_CLK: length 122.4
  TOP w0.102: PR8625.2 68.71,37.96 69.69,37.96 v2(70.2,38.47) 70.55,38.47 70.93,38.09 U55.9 ; v2(97.62,67.3) 97.62,67.44 97.99,67.8 97.99,69.52 R306.2
  L3 w0.127: v2(108.91,60.31) 107.89,59.3 105.64,59.3 104.21,57.87 104.21,55.43 98.26,49.48 88.58,49.48 83.69,44.59 82.64,44.59 80.21,42.15 73.45,42.15 72.75,41.46 72.75,40.59 70.63,38.47 v2(70.2,38.47)
  L4 w0.127: v2(108.91,60.31) 108.75,60.31 108.15,60.92 108.15,61.81 105.84,64.12 103.57,64.12 101.16,66.53 98.18,66.53 97.62,67.1 v2(97.62,67.3) 97.37,67.55 95.89,67.55 95.34,67 91.12,67 90.79,66.67 88.15,66.67 86.9,67.93 86.9,78.31 90.11,81.52 90.11,87.62 89.5,88.23 89.5,99.7 90.67,100.87 91.9,100.87 92.7,100.06 v5(93.03,100.06)
  BOTTOM w0.102: v2(108.91,60.31) 109.67,60.31 v3(109.8,60.44) ; v5(93.03,100.06) 93.78,100.06 R80224.2
CHG_SMB2_DATA: length 123.1
  TOP w0.102: v2(97.53,68.06) 97.53,70.08 R307.2 ; PR8626.2 68.78,39.1 v2(69.41,38.47) 69.87,38.92 70.6,38.92 70.94,38.59 U55.8
  L3 w0.127: v2(69.41,38.47) 69.88,38.94 70.56,38.94 72.37,40.74 72.37,41.61 73.29,42.53 80.05,42.53 82.49,44.97 83.53,44.97 88.42,49.86 98.1,49.86 103.83,55.58 103.83,57.68 103.83,58.02 105.48,59.68 105.82,59.68 106.81,59.68 108.21,61.07 v2(108.65,61.07)
  L4 w0.127: v2(108.65,61.07) 108.65,63.11 106.59,65.18 104.77,65.18 102.92,67.03 99.63,67.03 98.99,67.68 98.08,67.68 97.7,68.06 v2(97.53,68.06) 95.86,68.06 95.22,67.42 91,67.42 90.64,67.06 88.31,67.06 87.28,68.09 87.28,78.15 90.34,81.21 90.34,88.28 89.88,88.73 89.88,99.76 90.76,100.64 91.77,100.64 92.98,99.43 v5(93.16,99.43)
  BOTTOM w0.102: R80223.2 92.41,100.1 92.86,99.66 92.93,99.66 v5(93.16,99.43) ; v3(108.65,61.91) v2(108.65,61.07)
CK_24M_SIO: length 87.2
  TOP w0.102: R1807.2 157.99,74.78 158,74.79 158.5,74.79 159.03,75.32 159.65,75.32 160.26,75.93 160.64,75.93 161.76,77.05 166.53,77.05 166.84,76.73 v2(167.49,76.73)
  L4 w0.127: v2(166.95,56.96) 165.11,56.96 164.71,56.56 163.23,56.56 162.92,56.87 153.96,56.87 153.1,56.01 150.32,56.01 148.52,54.2 144.43,54.2 140.41,58.22 126.74,58.22 126,58.96 126,59.24 124.86,60.39 124.2,60.39 123.42,61.17 123.42,61.82 123,62.24 v2(121.61,62.24)
  BOTTOM w0.102: v2(166.95,56.96) 167.3,56.96 169.41,59.07 169.41,60.53 170.48,61.6 170.48,74.66 v3(170.3,74.84) 170.3,75.53 169.55,76.27 169.55,76.38 169.2,76.73 v2(167.49,76.73) ; R301.1 120.02,62.6 120.32,62.6 120.5,62.42 121.43,62.42 v2(121.61,62.24)
CK_100M_CPU_XDP_DN: length 205.2
  TOP w0.102: U2.L1 135.31,67.03 136.09,66.25 v2(136.09,66.15)
  L4 w0.127: v2(73.73,131.71) 74.19,132.17 79.29,132.17 80.71,133.59 91.53,133.59 92.96,135.01 122.73,135.01 124.14,133.6 124.14,123.32 128.57,118.88 128.57,100.72 128.21,100.37 128.21,96.94 128.49,96.66 128.49,87.61 122.76,81.88 121.69,81.88 120.62,80.81 120.62,79.72 121.24,79.09 125.75,79.09 130.96,73.89 130.96,73.19 131.7,72.45 131.7,71.92 131.05,71.28 131.05,68.83 131.4,68.49 131.41,68.49 131.48,68.41 132.05,68.41 132.12,68.49 133.16,68.49 133.73,67.92 134.32,67.92 135.75,66.49 135.87,66.49 136.09,66.28 v2(136.09,66.15)
  BOTTOM w0.102: v3(57.9,139.74) 57.9,139.43 ; 57.9,139.43 52.64,139.43 51.79,138.58 47.78,138.58 44.42,141.94 35.6,141.94 32.01,138.35 32.01,128.27 34.63,125.65 34.96,125.65 35.1,125.51 XDPC1.42 ; 57.9,139.43 70.02,139.43 74.22,135.23 74.22,132.2 v2(73.73,131.71)
CK_100M_CPU_XDP_DP: length 205.2
  TOP w0.102: v2(136.01,66.94) 135.71,66.94 135.52,67.13 135.52,67.18 135.29,67.41 U2.L2
  L4 w0.127: v2(136.01,66.94) 135.68,66.94 134.44,68.19 133.84,68.19 133.27,68.75 132.01,68.75 131.94,68.68 131.59,68.68 131.52,68.75 131.51,68.75 131.32,68.94 131.32,71.17 131.96,71.81 131.96,72.56 131.22,73.3 131.22,74 125.86,79.36 121.35,79.36 120.88,79.83 120.88,80.7 121.8,81.61 122.87,81.61 128.76,87.5 128.76,96.77 128.48,97.05 128.48,100.26 128.83,100.61 128.83,118.99 124.4,123.43 124.4,133.71 122.84,135.28 121.34,135.28 121.2,135.42 120.82,135.42 120.69,135.28 120.31,135.28 120.17,135.42 119.79,135.42 119.65,135.28 119.27,135.28 119.13,135.42 118.75,135.42 118.61,135.28 113.53,135.28 113.4,135.42 113.02,135.42 112.88,135.28 112.5,135.28 112.36,135.42 111.98,135.42 111.84,135.28 111.46,135.28 111.32,135.42 110.94,135.42 110.81,135.28 109.27,135.28 109.13,135.42 108.75,135.42 108.62,135.28 108.24,135.28 108.1,135.42 107.72,135.42 107.58,135.28 107.2,135.28 107.06,135.42 106.68,135.42 106.54,135.28 101.46,135.28 101.33,135.42 100.95,135.42 100.81,135.28 100.43,135.28 100.29,135.42 99.91,135.42 99.77,135.28 99.39,135.28 99.25,135.42 98.87,135.42 98.74,135.28 92.85,135.28 91.42,133.86 90.26,133.86 90.12,133.99 89.74,133.99 89.6,133.86 89.22,133.86 89.08,133.99 88.7,133.99 88.56,133.86 88.18,133.86 88.05,133.99 87.66,133.99 87.53,133.86 87.15,133.86 87.01,133.99 86.63,133.99 86.49,133.86 80.6,133.86 79.18,132.43 73.82,132.43 v2(73.73,132.52)
  BOTTOM w0.102: v3(73.65,133.62) 74,133.62 ; 74,133.62 74,135.14 71.72,137.42 71.56,137.42 71.35,137.64 71.35,137.79 71.13,138.01 70.98,138.01 70.76,138.23 70.76,138.38 70.54,138.6 70.39,138.6 70.17,138.81 70.17,138.97 69.93,139.22 67.14,139.22 67.03,139.1 66.72,139.1 66.61,139.22 66.31,139.22 66.2,139.1 65.89,139.1 65.78,139.22 52.73,139.22 51.88,138.37 47.69,138.37 44.33,141.72 35.69,141.72 35.47,141.51 35.47,141.35 35.26,141.14 35.1,141.14 34.88,140.92 34.88,140.76 34.67,140.55 34.51,140.55 34.29,140.33 34.29,140.17 34.08,139.96 33.92,139.96 32.23,138.26 32.23,128.36 34.72,125.87 34.99,125.87 35.13,126.01 XDPC1.40 ; 74,133.62 74,132.79 v2(73.73,132.52)
CK_GLAN_DN: length 91.7
  TOP w0.102: v2(132.29,68.02) 132.26,67.99 U2.D3 ; 65.94,33.41 65.94,37.05 v2(65.94,37.06) ; 65.94,33.41 65.94,32.03 64.52,30.6 64.52,29.1 64.36,28.95 U9623.16 ; 65.94,33.41 v1(65.58,33.41)
  L3 w0.127: v2(132.29,68.02) 132.14,68.17 131.71,68.17 131.58,68.04 131.19,68.04 131.06,68.17 129.42,68.17 128.97,67.73 127.7,67.73 126.37,66.39 125.99,66.39 125.85,66.26 125.47,66.26 125.33,66.39 124.95,66.39 124.82,66.26 124.44,66.26 124.3,66.39 123.92,66.39 123.78,66.26 123.4,66.26 123.26,66.39 120.89,66.39 120.75,66.26 120.37,66.26 120.23,66.39 119.85,66.39 119.72,66.26 119.34,66.26 119.2,66.39 118.82,66.39 115.24,62.81 115.24,62.62 114.97,62.35 114.77,62.35 114.5,62.08 114.5,61.89 114.23,61.62 114.04,61.62 113.77,61.35 113.77,61.15 113.5,60.89 113.31,60.89 113.04,60.62 111.52,60.62 111.28,60.38 111.28,60.02 99.19,47.93 89.22,47.93 84.32,43.03 83.43,43.03 77.49,37.08 72.7,37.08 71.66,36.04 66.95,36.04 v2(65.94,37.06)
CK_GLAN_DP: length 91.8
  TOP w0.102: U9623.15 64.26,28.55 64.73,29.01 64.73,30.51 66.16,31.94 66.16,35.09 ; U2.F2 132.43,67.49 v2(132.98,68.04) ; 66.16,35.09 66.16,36.51 v2(66.71,37.06) ; 66.16,35.09 v1(66.54,35.09)
  L3 w0.127: v2(66.71,37.06) 66.71,36.67 67.06,36.31 71.54,36.31 72.59,37.35 77.38,37.35 83.32,43.29 84.21,43.29 89.11,48.2 99.08,48.2 111.02,60.13 111.02,60.49 111.41,60.88 112.93,60.88 118.71,66.66 126.26,66.66 127.59,67.99 128.86,67.99 129.31,68.44 132.09,68.44 132.11,68.46 132.48,68.46 132.73,68.21 132.81,68.21 v2(132.98,68.04)
CK_M_DDR0_A_DN: length 73.3
  TOP w0.165: DIMM1.103 147.91,165.65 148.29,166.03 148.29,166.72 v5(148.41,166.84) ; v5(92.01,186.77) CPU1.AV18
  L4 w0.191: v5(148.41,166.84) 148.24,167 148.24,167.39 147.92,167.72 144.91,167.72 144.16,166.97 132.4,166.97 127.49,171.87 126.98,171.87 126.79,171.68 126.49,171.68 126.25,171.92 126.25,172.22 126.44,172.41 126.44,172.92 125.81,173.55 125.3,173.55 125.09,173.34 124.82,173.34 124.55,173.61 124.55,173.88 124.76,174.09 124.76,174.6 124.13,175.23 108.04,175.23 98.14,185.14 94.98,185.14 94.5,185.62 94.12,185.62 93.11,186.63 92.14,186.63 v5(92.01,186.77)
  BOTTOM w0.165: v3(148.05,166) 148.41,166.36 v5(148.41,166.84)
CK_M_DDR0_A_DP: length 73.2
  TOP w0.165: v5(147.67,166.86) 147.72,166.86 148.02,166.56 148.02,166.14 147.8,165.92 146.59,165.92 146.26,166.25 DIMM1.101 ; v2(91.97,185.76) 91.97,186.07 92.15,186.25 CPU1.AW18
  L4 w0.191: v5(147.67,166.86) 147.74,166.86 147.95,167.07 147.95,167.27 147.8,167.42 145.03,167.42 144.28,166.67 132.28,166.67 127.37,171.58 127.1,171.58 126.91,171.39 126.36,171.39 125.95,171.8 125.95,172.34 126.15,172.53 126.15,172.8 125.69,173.26 125.42,173.26 125.21,173.05 124.7,173.05 124.26,173.49 124.26,174 124.47,174.21 124.47,174.48 124.01,174.94 107.92,174.94 98.02,184.85 94.86,184.85 94.38,185.33 94,185.33 93.82,185.5 92.99,186.33 92.16,186.33 91.97,186.14 v2(91.97,185.76)
  BOTTOM w0.165: v3(147.24,167.58) 147.67,167.14 v5(147.67,166.86)
CK_M_DDR0_B_DN: length 101.4
  TOP w0.165: CPU1.AM21 86.01,188.96 v5(86.46,188.51) ; v5(163.47,167.09) 163.28,166.91 163.28,166.29 162.79,165.8 161.68,165.8 161.53,165.65 DIMM2.103
  L3 w0.102: v5(86.46,188.51) 86.68,188.73 86.9,188.73 87.44,188.2 88.6,188.2 88.88,187.91 90.35,187.91 90.64,188.2 92.74,188.2 93.08,187.86 94.91,187.86 94.96,187.82
  L3 w0.191: 94.96,187.82 96.03,186.74 103.73,186.74 119.25,171.23 132.57,171.23 136.79,167.01 138.75,165.05 140.06,165.05 140.26,164.86 140.26,163.97 140.62,163.61 141.24,163.61 141.6,163.97 141.6,164.86 141.79,165.05 142.17,165.05 142.36,164.86 142.36,163.97 142.73,163.61 143.35,163.61 143.71,163.97 143.71,164.86 143.9,165.05 144.28,165.05 144.47,164.86 144.47,163.97 144.83,163.61 145.46,163.61 145.82,163.97 145.82,164.86 146.01,165.05 149.43,165.05 150.39,164.1 156.56,164.1 158.05,165.58 158.96,165.58 159.75,166.37 162.75,166.37 v5(163.47,167.09)
  BOTTOM w0.165: v5(86.46,188.51) 85.64,189.34 v3(85.64,189.52)
CK_M_DDR0_B_DP: length 101.1
  TOP w0.165: v5(162.75,167.12) 163.02,166.85 163.02,166.4 162.68,166.06 161.66,166.06 161.48,166.25 DIMM2.101 ; CPU1.AM20 85.96,188.08 v5(85.49,188.55)
  L3 w0.102: v5(85.49,188.55) 85.5,188.56 85.92,188.56 86.3,188.94 86.99,188.94 87.53,188.4 88.68,188.4 88.96,188.12 90.26,188.12 90.55,188.4 92.83,188.4 93.17,188.07 94.86,188.07 94.91,188.07 95.06,188.07 95.1,188.03 95.17,188.03
  L3 w0.191: 95.17,188.03 96.15,187.04 103.86,187.04 119.37,171.52 132.69,171.52 138.87,165.34 140.19,165.34 140.55,164.98 140.55,164.1 140.74,163.9 141.12,163.9 141.31,164.1 141.31,164.98 141.67,165.34 142.29,165.34 142.66,164.98 142.66,164.1 142.85,163.9 143.23,163.9 143.42,164.1 143.42,164.98 143.78,165.34 144.4,165.34 144.76,164.98 144.76,164.1 144.95,163.9 145.34,163.9 145.53,164.1 145.53,164.98 145.89,165.34 149.55,165.34 150.51,164.39 156.44,164.39 157.93,165.87 158.84,165.87 159.63,166.67 162.63,166.67 162.75,166.79 v5(162.75,167.12)
  BOTTOM w0.165: v5(162.75,167.12) 162.75,167.57 v3(163.09,167.91)
CK_M_DDR1_A_DN: length 74.5
  TOP w0.165: DIMM1.104 152.51,165.35 152.31,165.54 150.36,165.54 150.06,165.85 150.06,166.68 v5(149.95,166.79) ; v5(92.9,185.77) CPU1.AY17
  L4 w0.191: v5(92.9,185.77) 92.9,185.49 93.62,184.77 93.62,184.24 94.37,183.49 95.1,183.49 95.77,184.16 97.79,184.16 107.67,174.28 122.55,174.28 127,169.84 128.06,169.84 129.93,167.96 129.93,167.45 129.55,167.06 129.55,166.95 129.55,166.75 129.77,166.53 130.09,166.53 130.47,166.91 130.98,166.91 131.9,166 144.65,166 144.84,166.19 149.73,166.19 149.95,166.41 v5(149.95,166.79)
  BOTTOM w0.165: v3(149.9,165.92) 149.95,165.97 v5(149.95,166.79)
CK_M_DDR1_A_DP: length 74.7
  TOP w0.165: v5(150.72,166.76) 150.64,166.76 150.32,166.44 150.32,165.96 150.47,165.81 152.13,165.81 152.27,165.95 DIMM1.102 ; CPU1.AW17 92.41,185.31 v5(92.89,184.84)
  L4 w0.191: v5(92.89,184.84) 93.14,184.84 93.33,184.65 93.33,184.12 94.25,183.2 95.22,183.2 95.89,183.87 97.67,183.87 97.96,183.58 107.55,173.99 122.43,173.99 126.88,169.54 127.94,169.54 129.64,167.84 129.64,167.57 129.48,167.41 129.25,167.19 129.25,166.95 129.25,166.63 129.65,166.23 130.21,166.23 130.59,166.62 130.86,166.62 131.77,165.71 144.77,165.71 144.95,165.89 144.96,165.9 149.85,165.9 v5(150.72,166.76)
  BOTTOM w0.165: v3(93.74,185.53) 93.05,184.84 v5(92.89,184.84)
CK_M_DDR1_B_DN: length 98.8
  TOP w0.165: v5(165.73,166.38) 165.73,166.05 166.21,165.57 167.53,165.57 167.75,165.35 DIMM2.104 ; v5(88.32,189.46) 87.85,189 CPU1.AP21
  L3 w0.102: 95.73,188.15 95.6,188.28 93.24,188.28 92.76,188.76 91.97,188.76 91.47,189.26 91.47,189.63 91.2,189.9 88.57,189.9 88.32,189.65 v5(88.32,189.46)
  L3 w0.191: v5(165.73,166.38) 166.16,166.81 166.16,167.21 165.91,167.46 164.57,167.46 164.24,167.79 160.8,167.79 160.38,167.37 158.1,167.37 156.72,165.99 140.64,165.99 139.81,166.82 139.25,166.82 138.54,167.52 138.54,168.08 138.5,168.13 138.27,168.35 138.01,168.35 137.65,168 137.14,168 136.69,168.44 136.69,168.95 137.05,169.31 137.05,169.58 136.78,169.84 136.51,169.84 136.16,169.49 135.64,169.49 135.2,169.93 135.2,170.44 135.56,170.8 135.56,171.07 134.44,172.18 119.62,172.18 104.12,187.68 96.19,187.68 95.73,188.15
  BOTTOM w0.165: v3(87.98,190.41) 87.98,189.8 v5(88.32,189.46)
