# Allegro board 14058-1.0623WZS1658.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CK_M_DDR1_B_DP: length 98.8
  TOP w0.165: CPU1.AP22 87.84,189.87 v2(87.44,189.47) ; v5(166.46,166.38) 166.46,166.37 166.99,165.84 167.6,165.84 167.71,165.95 DIMM2.102
  L3 w0.102: v2(87.44,189.47) 87.85,189.88 88.26,189.88 88.49,190.11 91.28,190.11 91.67,189.72 91.67,189.34 92.05,188.96 92.84,188.96 93.33,188.48 95.81,188.48
  L3 w0.191: 95.81,188.48 96.31,187.98 104.25,187.98 119.74,172.48 134.57,172.48 135.85,171.19 135.85,170.68 135.5,170.32 135.5,170.05 135.77,169.78 136.03,169.78 136.39,170.14 136.9,170.14 137.34,169.7 137.34,169.18 136.99,168.83 136.99,168.56 137.26,168.29 137.53,168.29 137.88,168.65 138.4,168.65 138.84,168.2 138.84,167.64 139.37,167.11 139.93,167.11 140.76,166.28 156.6,166.28 157.98,167.66 160.26,167.66 160.68,168.08 164.36,168.08 164.69,167.75 166.03,167.75 166.46,167.33 v5(166.46,166.38)
  BOTTOM w0.165: v3(167,165.52) 166.46,166.06 v5(166.46,166.38)
CK_PE_100M_16PORT_DN: length 128.3
  TOP w0.102: v5(86.46,118.83) 86.07,119.22 GPU1.AD8 ; U2.W10 139.12,71.2 v2(138.63,70.7)
  BOTTOM w0.102: 125.08,110.25 125.08,116.23 108.35,132.96 105.53,132.96 97.14,124.56 97.14,123.87 92.23,118.97 91.12,118.97 89.59,120.51 87.93,120.51 86.81,119.4 86.82,119.4 86.46,119.04 v5(86.46,118.83) ; 125.08,110.25 125.08,99.59 124.96,99.48 124.96,99.17 125.08,99.06 125.08,98.75 124.96,98.64 124.96,98.34 125.08,98.23 125.08,92.61 126.22,91.46 126.22,88.47 121.63,83.88 120.63,82.24 120.63,80.03 121.78,78.88 125.21,75.44 125.21,74.19 125.05,74.03 125.05,68.56 128.89,64.71 130.75,64.71 131.52,63.94 134.36,63.94 134.4,63.98 136.02,63.98 136.73,64.69 136.73,68.83 137.15,69.25 137.15,69.52 138.33,70.7 v2(138.63,70.7) ; 125.08,110.25 v3(124.76,110.25)
CK_PE_100M_16PORT_DP: length 128.2
  TOP w0.102: GPU1.AE8 86.04,119.98 86.42,119.6 v5(86.43,119.6) ; U2.W11 138.84,71.51 v2(138.65,71.51)
  BOTTOM w0.102: 120.85,81.49 120.85,82.18 121.8,83.74 126.43,88.38 126.43,91.55 125.29,92.7 125.29,116.32 108.44,133.17 105.44,133.17 96.92,124.65 96.92,123.96 94.05,121.09 93.9,121.09 93.67,120.86 93.67,120.71 92.14,119.19 91.21,119.19 89.68,120.72 87.84,120.72 86.71,119.6 v5(86.43,119.6) ; 120.85,81.49 v3(121.15,81.49) ; 120.85,81.49 120.85,80.12 121.93,79.03 125.43,75.53 125.43,74.1 125.27,73.94 125.27,68.64 128.98,64.93 130.84,64.93 131.61,64.16 134.27,64.16 134.31,64.2 135.93,64.2 136.52,64.78 136.52,68.92 136.94,69.34 136.94,69.61 138.18,70.85 138.18,70.86 138.65,71.34 v2(138.65,71.51)
CKEA0: length 103
  TOP w0.102: VRAM1.K9 87.29,87.48 86.9,87.09 85.84,87.09 85.21,86.45 84.95,86.45 84.8,86.6 84.8,86.78 v5(85.1,87.08) ; v5(70.43,86.26) 70.43,86.36 71.1,87.04 72.92,87.04 73.36,87.48 VRAM2.K9
  TOP w0.127: GPU1.F24 73.18,104.72 v5(73.2,104.72) ; v5(77.72,77.86) 77.95,78.09 79,78.09 PR246.1
  L3 w0.102: 71.81,102.18 71.98,102.36 71.98,102.39 72.22,102.62 72.25,102.62 72.26,102.63 72.57,102.63 72.78,102.84 72.78,102.86 72.79,102.87 72.79,103.2 72.78,103.21 72.78,104.02
  L3 w0.127: 73.2,104.51 72.79,104.1 72.79,104.03 72.78,104.02 ; v5(70.43,86.26) 69.92,86.26 69.64,85.98 68.76,85.98 68.74,86 68.6,86.13 68.02,86.13 67.64,85.75 67.64,85.03 67.2,84.59 67.2,84.56 67.05,84.41 67.05,84.38 66.83,84.16 66.83,83.62 66.84,83.61 66.84,82.81 67.03,82.62 67.03,80.86 70.11,77.77 70.35,77.77 71.84,76.29 76.14,76.29 77.71,77.86 v5(77.72,77.86) 77.74,77.84 79.03,77.84 79.55,78.36 83.36,78.36 83.5,78.5 83.5,78.83 83.07,79.26 83.07,79.41 83.26,79.6 83.44,79.6 83.72,79.32 83.95,79.32 84.17,79.54 84.17,80.45 84.27,80.55 85.56,80.55 86.86,81.85 86.86,85.93 86.68,86.11 85.81,86.11 85.69,86.23 85.69,86.4 85.81,86.52 86.68,86.52 86.78,86.62 86.78,86.96 86.65,87.08 v5(85.1,87.08)
  L3 w0.165: 71.81,102.18 71.81,98.29 69.64,96.12 68.31,96.12 65.98,93.79 65.98,86.59 65.44,86.05 65.44,82.75 65.16,82.48 v5(65.16,81.8) ; 73.2,104.51 v5(73.2,104.72)
  BOTTOM w0.102: VRAM3.K9 81.18,87.48 81.54,87.12 83.49,87.12 83.92,86.69 84.7,86.69 v5(85.1,87.08) ; v5(70.43,86.26) 70.28,86.4 69.91,86.4 69.5,86.8 69.49,86.8 69.2,87.09 67.48,87.09 VRAM4.K9
  BOTTOM w0.127: v5(65.16,81.8) 65.16,81.52 v3(66.41,80.28) 66.97,79.72 73.47,79.72 75.77,77.42 77.27,77.42 77.71,77.86 v5(77.72,77.86)
CKEA1: length 103.5
  TOP w0.102: v5(48.12,109.84) 46.79,111.17 46.63,111.37 PR235.1 ; VRAM5.K9 57.51,100.78 57.51,101.08 57.22,101.38 57.22,102.34 57.04,102.52 57.04,102.62 56.82,102.84 56.82,103.02 56.95,103.15 57.13,103.15 v5(57.51,102.77) ; GPU1.K23 73.18,107.2 v5(73.18,107.19) ; v5(56.58,117.54) 56.61,117.54 57.31,116.84 57.31,115.18 57.64,114.85 VRAM6.K9
  TOP w0.127: v5(48.12,109.84) 48.68,109.84 v1(49.36,109.17)
  L3 w0.102: v5(73.18,107.19) 72.74,107.63 71.75,107.63
  L3 w0.127: v5(56.58,117.54) 56.58,117.56 56.46,117.69 56.46,118.06 56.23,118.29 56.23,120.28 55.14,121.37 53.05,121.37 52.9,121.22 51.55,121.22 48.2,117.86 48.2,113.35 47.81,112.96 47.81,110.15 v5(48.12,109.84) 48.12,109.76 48.3,109.59 48.3,105.1 49.31,104.09 49.31,103.44 49.43,103.31 49.92,103.31 50.05,103.19 50.05,103 49.92,102.88 49.32,102.88 49.21,102.77 49.21,102.63 49.32,102.53 49.8,102.53 49.95,102.37 49.95,102.23 49.79,102.06 49.79,101.88 49.98,101.68 50.16,101.68 50.47,101.99 50.61,101.99 50.76,101.85 50.76,101.7 50.49,101.43 50.49,101.25 50.7,101.04 50.88,101.04 51.57,101.73 51.79,101.73 52.62,100.9 55.39,100.9 55.8,101.31 55.8,101.62 56.95,102.77 v5(57.51,102.77)
  L3 w0.165: v5(48.12,109.84) 47.72,109.44 47.72,104.94 48.53,104.13 48.53,101.44 52.25,97.73 54.17,97.73 54.18,97.73 54.56,97.73 54.57,97.73 62.96,97.73 64.39,99.16 64.5,99.16 66.44,101.1 66.44,102.5 67.1,103.15 67.1,104.63 69.59,107.12 71.24,107.12 71.75,107.63
  BOTTOM w0.102: VRAM7.K9 57.64,106.91 57.28,106.54 57.28,104.12 57.02,103.86 57.02,103.27 v5(57.51,102.77) ; VRAM8.K9 57.19,120.63 57.19,118.75 56.59,118.15 56.59,117.55 v5(56.58,117.54)
CLINK_CLK_LAN: length 253.2
  TOP w0.102: v2(146.5,240.96) 145.91,240.38 145.91,240 145.62,239.71 145.21,239.71 144.77,240.14 v1(141.7,240.14) 141.04,240.14 139.92,239.03 R713.1 ; U2.AV2 148.25,67.35 148.25,66.74 148.94,66.05 148.94,65.62 149.94,64.62 v2(150.09,64.62)
  L3 w0.127: v2(146.5,240.96) 150.75,236.71 153.76,236.71 157.32,233.16 165.2,233.16 182.35,216 182.35,161.53 199.57,144.31 199.57,138.95 190.79,130.16 186.85,130.16 181.97,125.29 181.97,121.58 183.93,119.63 183.93,96.28 182.19,94.54 182.19,93.5 180.87,92.19 178.44,92.19 175.58,89.33 175.58,86.16 171.13,81.7 171.13,78.95 171.13,78.63 170.43,77.94 170.43,77.29 166.99,73.85 163.97,73.85 163.14,73.01 163.14,69.62 162.5,68.98 162.5,65.4 159.71,62.61 153.63,62.61 151.71,64.53 150.18,64.53 v2(150.09,64.62)
CLINK_CLK_LAN_1: length 6.1
  TOP w0.102: R713.2 137.53,238.32 v1(136.36,238.32) 135.86,238.32 135.59,238.59 134.71,238.59 134.31,239 NGFF1.42
CLINK_DATA_LAN: length 250.4
  TOP w0.102: v2(147.8,238.7) 147.34,239.15 v1(146.37,239.15) 140.94,239.15 139.78,238 R716.1 ; U2.AV3 148.56,67.78 148.56,67.29 148.5,67.18 148.5,66.78 149.84,65.44 v2(149.84,65.34)
  L3 w0.127: v2(149.84,65.34) 149.95,65.22 150.21,65.22 150.43,65.01 151.77,65.01 153.79,62.99 159.56,62.99 161.99,65.43 161.99,69.08 162.76,69.84 162.76,73.17 163.81,74.23 166.84,74.23 170.05,77.45 170.05,78.1 170.74,78.79 170.74,81.86 175.2,86.32 175.2,89.49 178.28,92.57 180.71,92.57 181.81,93.66 181.81,94.7 183.55,96.44 183.55,119.47 181.59,121.42 181.59,125.44 186.69,130.54 190.63,130.54 199.19,139.1 199.19,144.15 180.53,162.81 180.53,217.28 165.04,232.78 157.16,232.78 153.6,236.33 150.16,236.33 v2(147.8,238.7)
CLINK_DATA_LAN_1: length 6.4
  TOP w0.102: NGFF1.40 133.79,238.5 134.05,238.24 135.45,238.24 136.49,237.2 v1(137.15,237.2) 137.44,237.2 R716.2
CLINK_RST_LAN_N: length 246.1
  TOP w0.102: v2(150.59,65.48) 150.36,65.71 150.17,65.71 150.13,65.75 150.06,65.75 149.84,65.98 149.59,65.98 148.7,66.87 148.7,67.13 148.75,67.22 148.81,67.28 U2.AW2 ; v2(153.79,235.29) 153.2,234.71 153.18,234.71 v1(153.17,234.7) 152.82,234.35 150.51,234.35 146.34,238.52 141.06,238.52 139.53,236.98 R718.1
  L3 w0.127: v2(150.59,65.48) 151.84,65.48 152.84,64.48 155.4,64.48 155.77,64.85 155.77,64.91 158.72,67.87 160.24,67.87 162.38,70 162.38,73.33 163.66,74.61 166.68,74.61 169.67,77.61 169.67,78.25 170.36,78.95 170.36,82.02 174.82,86.48 174.82,89.65 178.12,92.95 180.55,92.95 181.42,93.82 181.42,94.85 183.16,96.59 183.16,119.31 181.21,121.27 181.21,125.6 186.53,130.92 190.47,130.92 198.81,139.26 198.81,144 180.15,162.66 180.15,217.12 165.01,232.27 156.82,232.27 v2(153.79,235.29)
CLINK_RST_LAN_N_1: length 7.9
  TOP w0.102: NGFF1.38 133.78,238 133.9,237.88 135.3,237.88 136.54,236.64 137.25,236.64 138.22,235.67 ; R718.2 138.25,235.7 138.22,235.67 ; 138.22,235.67 v1(138.27,235.62)
CLK: length 51
  TOP w0.102: 64.94,8.77 64.94,7.92 R9501.2 ; 64.94,8.77 64.84,8.77 64.38,8.32 60.45,8.32 59.76,9.01 59.76,9.77 v2(58.62,10.91) ; 64.94,8.77 v1(64.94,8.8) ; v2(36.39,28.92) 36.01,28.54 SCA1.115
  L4 w0.127: v2(36.39,28.92) 35.08,27.61 35.08,19.19 40.25,14.03 47.35,14.03 50.07,16.75 53.53,16.75 58.62,11.66 v2(58.62,10.91)
CLK_1: length 3.7
  TOP w0.102: R9501.1 63.94,7.14 v1(63.52,6.72) 63.21,6.72 62.2,7.73 U9501.6
CLK_24M_SIO_C: length 5.3
  TOP w0.102: v2(118.89,63.99) 118.64,63.74 117.67,63.74 117.38,64.04 U109.34 117.38,66.45 v1(117.16,66.66)
  BOTTOM w0.102: v2(118.89,63.99) 119.08,63.8 R301.2
CLKA0: length 71.1
  TOP w0.127: VRAM2.J7 71.76,88.15 71.37,88.15 71.27,88.25 71.27,88.46 70.82,88.9 70.22,88.9 v5(70.01,88.69) ; v5(84.34,88.92) 84.34,88.86 84.67,88.54 84.9,88.54 85.43,88.01 85.64,88.01 VRAM1.J7 ; v5(76.63,88.91) 76.81,88.73 77.07,88.73 77.54,89.2 R244.1 77.54,89.34 77.99,89.79 77.99,89.92 R245.1 ; v5(73.21,102.22) 72.81,102.62 GPU1.D24
  L3 w0.152: v5(84.34,88.92) 84.21,88.79 82.11,88.79 81.81,88.48 80.33,88.48 80.22,88.59 79.58,88.59 79.38,88.78 76.76,88.78 v5(76.63,88.91) 76.35,88.63 75.81,88.63 75.18,88 73.96,88 73.37,87.41 72.1,87.41 71.82,87.69 71.82,87.9 71.44,88.28 71.22,88.28 70.81,88.69 v5(70.01,88.69)
  L4 w0.102: v5(73.21,102.22) 73,102.22 72.9,102.12 72.9,101.81 73,101.71 73.36,101.71 73.77,102.12 74.32,102.12 74.85,101.59 75.02,101.59 75.08,101.64 75.2,101.64
  L4 w0.152: 75.2,101.64 76.9,101.64 77.08,101.81 77.08,102.25 77.41,102.58 78.15,102.58 78.48,102.25 78.48,100.44 78.15,100.11 77.38,100.11 77.16,99.89 76.05,99.89 75.89,99.74 75.89,99.3 76.05,99.15 76.42,99.15 76.73,98.84 76.73,98.08 76.5,97.85 76.5,97.37 76.73,97.14 76.73,95.18 76.88,95.03 77.18,95.03 77.51,94.7 77.51,94.12 77.18,93.79 75,93.79 74.85,93.64 74.85,93.31 75,93.15 77.54,93.15 77.87,92.82 77.87,92.24 77.54,91.91 75.15,91.91 75,91.76 75,91.45 75.15,91.3 78.17,91.3 78.48,90.99 78.48,89.85 78.63,89.7 78.63,88.48 78.35,88.2 77.66,88.2 77.23,88.63 77.23,89.24 76.98,89.5 75.37,89.5 75.21,89.34 75.21,88.92 75.53,88.61 76.32,88.61 v5(76.63,88.91)
  BOTTOM w0.127: v5(76.63,88.91) v3(76.63,89.5) ; v5(70.01,88.69) 70.01,88.45 69.94,88.38 69.94,88.13 69.96,88.12 69.96,87.96 69.79,87.79 69.56,87.79 69.08,88.28 VRAM4.J7 ; v5(84.34,88.92) 84.02,88.6 83.49,88.6 83.24,88.36 83.24,88.13 83.12,88.01 82.99,88.01 VRAM3.J7
CLKA0#: length 73
  TOP w0.127: v5(84.32,88.28) 84.79,88.28 85.32,87.75 85.65,87.75 VRAM1.K7 ; VRAM2.K7 71.89,87.7 71.7,87.9 71.27,87.9 71.13,88.04 71.12,88.04 71.01,88.15 71.01,88.35 70.72,88.65 70.49,88.65 70.43,88.58 70.43,88.25 v5(70.38,88.2) ; v5(76.63,88.2) 76.91,88.48 77.45,88.48 R244.2 78.03,88.89 78.03,89.48 78.24,89.69 78.24,90.68 R241.1 ; GPU1.D25 71.99,102.62 v5(72.39,102.22)
  L3 w0.152: v5(84.32,88.28) 84.12,88.48 82.24,88.48 81.93,88.17 80.21,88.17 80.1,88.28 79.45,88.28 79.25,88.48 76.91,88.48 v5(76.63,88.2) 76.5,88.33 75.94,88.33 75.3,87.69 74.08,87.69 73.5,87.11 71.98,87.11 71.52,87.57 71.52,87.77 71.32,87.97 71.1,87.97 70.68,88.39 70.56,88.39 v5(70.38,88.2)
  L4 w0.102: 75.2,101.33 75.19,101.33 75.14,101.38 74.77,101.38 74.24,101.92 73.86,101.92 73.44,101.5 72.92,101.5 72.7,101.72 72.7,101.91 v5(72.39,102.22)
  L4 w0.152: 75.2,101.33 77.03,101.33 77.39,101.69 77.39,102.12 77.54,102.27 78.02,102.27 78.17,102.12 78.17,100.57 78.02,100.42 77.25,100.42 77.03,100.2 75.92,100.2 75.59,99.86 75.59,99.17 75.92,98.84 76.29,98.84 76.42,98.72 76.42,98.21 76.19,97.98 76.19,97.24 76.42,97.01 76.42,95.06 76.75,94.73 77.06,94.73 77.21,94.58 77.21,94.25 77.06,94.09 74.87,94.09 74.54,93.76 74.54,93.18 74.87,92.85 77.41,92.85 77.56,92.7 77.56,92.37 77.41,92.21 75.02,92.21 74.69,91.88 74.69,91.32 75.02,90.99 78.05,90.99 78.17,90.87 78.17,89.72 78.33,89.57 78.33,88.61 78.23,88.51 77.79,88.51 77.54,88.76 77.54,89.37 77.11,89.8 75.24,89.8 74.91,89.47 74.91,88.8 75.41,88.3 76.52,88.3 v5(76.63,88.2)
  BOTTOM w0.127: VRAM3.K7 82.95,87.48 83.5,88.03 83.5,88.25 83.59,88.34 84.26,88.34 v5(84.32,88.28) ; VRAM4.K7 68.69,87.68 68.71,87.7 68.71,87.82 68.84,87.95 69.05,87.95 69.46,87.54 69.89,87.54 70.38,88.02 v5(70.38,88.2) ; v5(76.63,88.2) v3(76.12,87.9)
CLKA0_AND: length 2.3
  TOP w0.127: R245.2 R241.2 76.6,91.44 76.6,92.4 C163.1
CLKA1: length 76.2
  TOP w0.102: GPU1.N22 74.42,110.41 74.5,110.48 v5(74.84,110.48)
  TOP w0.127: v5(58.76,104) 58.92,104 59.05,103.87 59.05,103.59 58.92,103.47 58.86,103.47 58.73,103.34 58.73,103.07 58.39,102.73 58.39,102.3 VRAM5.J7 ; VRAM6.J7 58.17,116.55 58.17,116.68 58.54,117.05 58.54,117.55 v5(58.9,117.92) ; R194.1 59.63,111.05 59.63,110.68 59.43,110.48 R195.1 59.07,110.59 v5(59.07,111.52) 59.07,112.05 v1(59.17,112.15)
  L3 w0.152: v5(58.76,104) 58.99,104 59.17,104.18 59.17,104.43 58.79,104.81 58.79,107.5 58.44,107.86 58.44,108.9 58.87,109.33 58.87,111.32 v5(59.07,111.52) 58.91,111.68 58.91,112.62 59.25,112.97 59.25,114.03 58.92,114.36 57.78,114.36 57.57,114.56 57.57,116.27 57.73,116.42 57.96,116.42 58.64,117.11 58.64,117.66 v5(58.9,117.92)
  L4 w0.102: 72.75,112.01 72.81,111.95 72.81,111.9 73.27,111.44 74.01,111.44 74.44,111.01 74.95,111.01 75.08,110.88 75.08,110.72 v5(74.84,110.48)
  L4 w0.152: 72.75,112.01 72.31,112.46 72.31,114.09 71.91,114.49 71.09,114.49 70.76,114.16 70.76,112.53 71.04,112.25 71.04,112.02 70.83,111.82 70.17,111.82 70.02,111.97 70.02,114.32 69.69,114.65 67.89,114.65 67.56,114.32 67.56,112.88 67.39,112.71 66.78,112.71 66.62,112.88 66.62,113.66 66.27,114.01 65.63,114.01 65.29,113.66 65.29,112.51 65.14,112.36 64.83,112.36 64.68,112.51 64.68,113.59 64.34,113.93 63.81,113.93 63.46,113.59 63.46,112.51 63.31,112.36 63.01,112.36 62.85,112.51 62.85,113.45 62.52,113.78 61.94,113.78 61.61,113.45 61.61,111.37 61.94,111.03 62.38,111.03 62.53,110.88 62.53,110.48 62.38,110.32 61.13,110.32 60.98,110.48 60.98,113.42 60.65,113.75 60.04,113.75 59.71,113.42 59.71,109.56 59.56,109.41 59.15,109.41 59,109.56 59,110.7 58.73,110.98 58.73,111.15 59.07,111.49 v5(59.07,111.52)
  BOTTOM w0.127: VRAM8.J7 58.17,119.21 58.17,119 58.64,118.53 58.64,118.18 v5(58.9,117.92) ; VRAM7.J7 58.34,105.35 58.34,105.17 58.57,104.94 58.67,104.84 58.67,104.63 58.79,104.51 59.02,104.51 59.15,104.38 59.15,104.13 59.02,104 v5(58.76,104)
CLKA1#: length 76.9
  TOP w0.102: v5(74.84,109.69) 74.43,109.28 GPU1.M22
  TOP w0.127: v5(58.42,111.52) 58.3,111.39 R195.2 58.31,110.48 58.82,109.97 59.7,109.97 R80001.1 ; VRAM6.K7 57.91,116.55 57.91,116.78 58.28,117.16 58.28,117.8 v5(58.17,117.91) ; VRAM5.K7 57.85,102.25 57.87,102.26 57.97,102.26 58.08,102.37 58.08,102.55 57.96,102.68 57.96,102.91 58.08,103.03 58.34,103.03 58.48,103.17 58.48,103.43 v5(58.29,103.62)
  L3 w0.152: v5(58.29,103.62) 58.31,103.64 58.31,104.28 58.49,104.46 58.49,107.38 58.13,107.73 58.13,109.03 58.57,109.46 58.57,111.37 v5(58.42,111.52) 58.6,111.7 58.6,112.75 58.95,113.09 58.95,113.91 58.79,114.06 57.65,114.06 57.27,114.44 57.27,116.39 57.6,116.72 57.83,116.72 58.34,117.23 58.34,117.75 v5(58.17,117.91)
  L4 w0.102: 72.54,111.8 72.58,111.75 72.67,111.75 73.19,111.24 73.92,111.24 74.41,110.75 74.41,110.32 74.84,109.9 v5(74.84,109.69)
  L4 w0.152: v5(58.42,111.52) 58.42,110.85 58.69,110.58 58.69,109.44 59.02,109.1 59.68,109.1 60.01,109.44 60.01,113.3 60.17,113.45 60.52,113.45 60.67,113.3 60.67,110.35 61,110.02 62.5,110.02 62.83,110.35 62.83,111.01 62.5,111.34 62.07,111.34 61.92,111.49 61.92,113.32 62.07,113.47 62.4,113.47 62.55,113.32 62.55,112.38 62.88,112.05 63.44,112.05 63.77,112.38 63.77,113.46 63.93,113.63 64.21,113.63 64.38,113.46 64.38,112.38 64.71,112.05 65.27,112.05 65.6,112.38 65.6,113.54 65.76,113.7 66.15,113.7 66.31,113.54 66.31,112.75 66.66,112.41 67.52,112.41 67.86,112.75 67.86,114.2 68.01,114.35 69.56,114.35 69.72,114.2 69.72,111.85 70.05,111.52 70.96,111.52 71.34,111.9 71.34,112.38 71.06,112.66 71.06,114.03 71.21,114.18 71.78,114.18 72,113.97 72,112.33 72.54,111.8
  BOTTOM w0.127: v5(58.17,117.91) 58.39,118.12 58.39,118.42 57.91,118.9 57.91,119.21 VRAM8.K7 ; v3(75.63,109.97) 75.35,109.69 v5(74.84,109.69) ; v5(58.29,103.62) 58.32,103.65 58.32,103.88 58.32,103.88 58.32,104.16 58.41,104.25 58.41,104.74 58.39,104.76 58.16,104.99 58.1,104.99 VRAM7.K7
CLKA1_AND: length 3.3
  TOP w0.127: R80001.2 R194.2 61.7,112.23 v1(62.02,112.23) 62.05,112.2 C6704.1
CLKOUT_PCIE1N: length 186.4
  TOP w0.102: 111.98,232.7 111.98,147.66 127.56,132.08 127.56,128.86 v2(127.16,128.46) ; 111.98,232.7 111.98,235.55 116.19,239.75 117.61,239.75 R711.2 ; 111.98,232.7 v1(111.63,232.7) ; U2.L7 135.32,70.02 v2(135.41,70.02)
  L4 w0.127: v2(127.16,128.46) 127.51,128.11 127.51,122.35 130.27,119.6 130.27,90.77 131.25,89.79 131.25,88.87 130.36,87.98 130.36,84.66 130.75,84.26 130.75,82.53 130.61,82.4 130.61,82.01 130.75,81.88 130.75,75.55 134.13,72.17 134.8,72.17 136.07,70.9 136.07,70.28 135.82,70.02 v2(135.41,70.02)
CLKOUT_PCIE1P: length 186.5
  TOP w0.102: 116.83,239.54 v1(116.83,239.18) ; 116.83,239.54 117.61,239.54 R712.2 ; 116.83,239.54 116.28,239.54 112.2,235.46 112.2,147.75 127.78,132.17 127.78,128.66 v2(127.98,128.46) ; v2(135.43,69.25) 135.32,69.25 U2.L5
  L4 w0.127: v2(127.98,128.46) 127.78,128.26 127.78,122.46 130.54,119.71 130.54,90.88 131.51,89.9 131.51,88.76 130.63,87.87 130.63,84.77 131.02,84.37 131.02,75.66 134.24,72.44 134.91,72.44 136.34,71.01 136.34,70.17 v2(135.43,69.25)
CLKOUT_PCIE4N: length 135.1
  TOP w0.102: v2(131.77,69.13) 131.46,68.83 U2.D5
  L4 w0.127: v2(131.77,69.13) 132.22,69.13 132.38,69.3 133.33,69.3 134.1,68.53 137.75,68.53 139.49,66.79 142.5,66.79 142.79,67.08 143.23,67.08 143.91,66.4 143.91,66.03 145.6,64.34 145.75,64.18 146.76,64.18 148.04,62.9 154.14,62.9 155.18,63.94 156.55,63.94 157.4,63.09 160.24,63.09 161.85,64.71 161.85,67.92 164.38,70.45 164.38,71.11 165.74,72.46 168.33,72.46 171.66,75.79 171.66,82.49 176.61,87.44 176.61,92.68 179.34,95.41 180.92,95.41 182.39,96.89 182.39,103.54 182.19,103.75 182.19,109.58 176.94,114.82 176.94,123.22 178.8,125.07 178.8,125.99 184.74,131.94 184.74,138.35 184.22,138.87 183.8,138.87 v2(183.55,139.13)
  BOTTOM w0.102: U14.6 188.2,142.34 188.12,142.27 185.12,142.27 184.79,141.93 ; v2(183.55,139.13) 183.62,139.05 183.91,139.05 184,139.14 184,141.15 184.79,141.93 ; 184.79,141.93 v3(184.57,142.15)
CLKOUT_PCIE4P: length 135.1
  TOP w0.102: U2.E6 132.23,69.34 v2(132.23,69.91)
  L4 w0.127: v2(132.23,69.91) 132.57,69.56 133.44,69.56 134.21,68.79 137.86,68.79 138.81,67.85 139.6,67.05 142.39,67.05 142.68,67.34 143.34,67.34 144.17,66.51 144.17,66.14 145.86,64.45 146.87,64.45 148.15,63.17 154.03,63.17 155.07,64.21 156.66,64.21 157.51,63.36 160.13,63.36 161.59,64.82 161.59,68.03 164.11,70.56 164.11,71.22 165.63,72.73 168.22,72.73 171.39,75.9 171.39,82.6 176.35,87.55 176.35,92.79 179.23,95.68 180.81,95.68 182.12,97 182.12,103.43 181.92,103.63 181.92,109.47 181.65,109.74 181.46,109.74 181.19,110.01 181.19,110.2 180.92,110.47 180.72,110.47 180.45,110.74 180.45,110.93 176.68,114.71 176.68,123.33 178.53,125.18 178.53,126.1 178.69,126.26 178.96,126.53 178.96,126.72 179.22,126.99 179.42,126.99 179.69,127.26 179.69,127.46 179.96,127.72 180.15,127.72 180.42,127.99 180.42,128.19 180.69,128.46 180.88,128.46 184.47,132.05 184.47,134.16 184.34,134.3 184.34,134.68 184.47,134.82 184.47,135.2 184.34,135.33 184.34,135.72 184.47,135.85 184.47,136.23 184.34,136.37 184.34,136.75 184.47,136.89 184.47,138.24 184.11,138.6 183.82,138.6 183.69,138.47 183.69,138.43 183.68,138.42 183.67,138.42 v2(183.62,138.37)
  BOTTOM w0.102: 184.16,138.99 184.22,139.05 184.22,141.06 185.21,142.05 188.07,142.05 188.18,141.94 U14.5 ; 184.16,138.99 184,138.84 183.9,138.84 183.62,138.55 v2(183.62,138.37) ; 184.16,138.99 v3(184.41,138.73)
CORE_PLLVDD: length 6.3
  TOP w0.356: v5(88.19,108.89) 88.15,108.85 88.15,108.85 GPU1.L6
  BOTTOM w0.635: L29.2 C6710.1 91.19,109.43 C6708.1 C484.1 v3(89.17,109.63) 89.17,109.58 88.48,108.89 88.19,108.89 v5(88.19,108.89)
CPU_2_PCH_TRIGGER: length 8.3
  TOP w0.102: U2.AK1 144.41,67.01 144.41,64.73 142.83,63.16 141.04,63.16 140.84,62.95 v1(140.8,62.95) 140.69,62.84 140.6,62.84 139.87,62.11 R66.1
CPU_2_PCH_TRIGGER_R: length 260.2
  TOP w0.102: CPU1.B3 57.88,170.12 57.88,168.7 57.86,168.68 57.86,167.85 58.46,167.25 v2(58.49,167.25) ; R66.2 139.87,60.71 139.87,60.61 138.48,59.22 131.73,59.22 131.29,59.66 129.75,59.66 126.1,63.31 126.1,65.18 124.14,67.14 120.28,67.14 118.48,68.94 118.48,74.27 114.78,77.98 v2(114.78,78.22)
  L4 w0.127: v2(58.49,167.25) 58.49,166.68 59.24,165.93 59.24,146.47 58.27,145.5 58.27,138.65 54.21,134.59 52.59,134.59 46.21,128.21 43.94,128.21 42.32,126.58 42.32,123.87 40.46,122 40.46,119.86 39.25,118.66 37.74,118.66 37.32,119.07 36.53,119.07 35.63,118.16 35.63,117.8 31.55,113.72 31.55,112.36 31.5,112.31 31.5,110.33 31.37,110.2 31.37,107.84 31.1,107.56 31.1,103.15 30.56,102.61 30.56,86.85 26.14,82.43 26.14,72.51 37.75,60.91 69.64,60.91 71.28,62.55 v2(71.28,69.3)
  BOTTOM w0.102: v2(114.78,78.22) 112.87,78.22 112.57,77.91 109.39,77.91 108.8,77.33 102.94,77.33 102.61,77 93.85,77 91.08,74.23 74.89,74.23 v3(71.6,70.94) 71.28,70.63 v2(71.28,69.3)
CPU_24MHZ_R_DN: length 45.4
  TOP w0.102: CPU1.J9 64.07,175.81 v5(64.53,175.35)
  BOTTOM w0.102: v3(83.79,147.43) 84.09,147.43 ; 84.09,147.43 84.09,146.05 R15.2 ; 84.09,147.43 84.09,149.37 83.98,149.48 83.98,149.79 84.09,149.9 84.09,150.21 83.98,150.32 83.98,150.62 84.09,150.73 84.09,151.04 83.98,151.15 83.98,151.46 84.09,151.57 84.09,155.81 76.05,163.85 76.05,173.63 75.58,174.1 72.59,174.1 71.44,175.25 66.62,175.25 66.07,175.79 64.98,175.79 v5(64.53,175.35)
CPU_24MHZ_R_DP: length 45.4
  TOP w0.102: CPU1.K9 v5(64.52,176.28)
  BOTTOM w0.102: 84.31,153.48 84.31,146.06 R13.2 ; 84.31,153.48 84.31,155.9 76.27,163.94 76.27,173.72 75.67,174.32 72.68,174.32 71.53,175.46 66.71,175.46 66.16,176.01 64.8,176.01 v5(64.52,176.28) ; 84.31,153.48 v3(84.63,153.48)
CPU_FAN_CTRL_SIO: length 202.1
  TOP w0.165: v2(114.96,53.7) 117.42,53.7 118.31,52.81 U109.6
  L3 w0.165: v2(68.06,76.21) 65.95,76.21 62.81,79.34 62.81,80.79 58.36,85.23 56.98,85.23 52.23,89.98 50.54,89.98 50.26,89.71 33.67,89.71 24.45,98.92 20.53,98.92 18.78,100.67 18.78,101.9 v2(18.71,101.97)
  L4 w0.165: v2(9.72,171.69) 9.72,171.22 12.22,168.72 12.22,159.16 18.34,153.04 18.34,137.73 19.25,136.83 19.25,129.44 19.71,128.98 19.71,126.51 18.46,125.27 18.46,102.78 18.71,102.54 v2(18.71,101.97) ; v2(114.96,53.7) 114.29,53.7 108.75,59.24 107.78,59.24 106.76,60.26 105.03,60.26 100.68,64.61 97.14,64.61 97.02,64.49 94.98,64.49 94.5,64.97 92.49,64.97 91.87,64.36 86.31,64.36 84.8,65.87 84.8,67.16 83.83,68.13 83.83,69.48 78.24,75.06 69.21,75.06 v2(68.06,76.21)
  BOTTOM w0.165: v2(9.72,171.69) 10.05,172.02 v3(10.05,172.73) 9.98,172.81 9.52,172.81 8.96,172.25 R360.1
CPU_FAN_TACH_SIO: length 203.2
  TOP w0.165: U109.5 117.83,52.41 117.58,52.65 v2(116.54,52.65)
  L3 w0.165: v2(69.08,76.26) 68.93,76.26 68.5,76.69 66.05,76.69 63.23,79.52 63.23,80.96 57.29,86.9 56.03,86.9 52.53,90.4 49.78,90.4 49.5,90.12 33.94,90.12 24.72,99.34 20.7,99.34 19.19,100.84 19.19,102.74 v2(18.95,102.98)
  L4 w0.165: v2(18.95,102.98) 18.88,103.05 18.88,125.09 20.13,126.34 20.13,130.63 19.67,131.09 19.67,137 18.76,137.91 18.76,153.21 12.68,159.29 12.68,168.86 10.21,171.33 10.21,171.89 9.92,172.18 9.54,172.18 v2(8.76,172.96) ; v2(69.08,76.26) 69.86,75.48 78.42,75.48 84.25,69.65 84.25,68.34 87.19,65.39 94.67,65.39 95.15,64.91 96.85,64.91 96.97,65.03 100.86,65.03 104.31,61.58 105.48,61.58 106.38,60.68 106.93,60.68 107.95,59.66 108.92,59.66 113.48,55.1 114.25,55.1 116.54,52.81 v2(116.54,52.65)
  BOTTOM w0.165: R363.2 6.48,172.26 6.93,172.71 v3(7.18,172.71) 7.31,172.83 8.63,172.83 v2(8.76,172.96)
CPU_THERMTRIP_N: length 56.1
  TOP w0.102: CPU1.D11 v5(59.04,177.2) ; v2(58.39,147.92) 58.85,147.45 58.85,146.81 58.58,146.54 55.57,146.54 53.97,148.14 47.69,148.14 41.86,142.32 41.86,142.19 41.6,141.93 41.47,141.93 40.84,141.29 v1(40.84,140.96) R38.2
  L4 w0.127: v2(58.39,147.92) 58.6,148.13 58.6,165.86 57.67,166.8 57.67,173.91 57.48,174.1 57.48,175.63 v5(59.04,177.2)
CPU_VAIDALERT_N: length 42.8
  TOP w0.102: v2(59.75,207.25) 60.39,207.25 60.9,206.74 60.9,205.98 61.32,205.56 CPU1.E39 ; v2(38.65,233.49) 38.6,233.54 R23.1
  BOTTOM w0.102: v2(38.65,233.49) 38.85,233.29 v3(41.22,233.29) 43.01,233.29 43.85,232.45 43.85,229.85 49.98,223.71 49.98,221.43 53.18,218.23 53.18,211.42 55.42,209.18 57.82,209.18 58.63,208.37 58.88,208.37 59.75,207.51 v2(59.75,207.25)
CPU_VIDSCK_N: length 39.9
  TOP w0.102: R25.2 42.04,233.79 42.84,233.79 v2(42.87,233.82) ; v2(60.87,204.97) 61.3,204.54 CPU1.E38
  BOTTOM w0.102: v2(42.87,233.82) 43.48,233.82 44.33,232.97 44.33,230.05 50.49,223.89 50.49,221.6 53.66,218.43 53.66,211.62 55.62,209.66 58.02,209.66 60.87,206.82 v3(60.87,206.36) v2(60.87,204.97)
CPU_VIDSOUT_N: length 35.5
  TOP w0.102: CPU1.E40 61.32,206.81 60.31,207.83 58.05,207.83 v2(57.86,207.64) ; v2(42.87,230.39) 42.59,230.11 R28.2
  BOTTOM w0.102: v2(42.87,230.39) 42.87,230.14 49.5,223.51 49.5,221.23 52.6,218.13 52.6,211.24 v3(53.42,210.41) 55.14,208.7 56.8,208.7 v2(57.86,207.64)
CPU_VSS_AB11: length 2.7
  TOP w0.102: v2(140.99,72.15) 140.96,72.15 140.95,72.13 140.66,72.13 140.48,71.96 U2.AB11
  BOTTOM w0.102: R247.1 141.29,72.87 140.56,72.87 v3(140.53,72.85) 140.53,72.6 v2(140.99,72.15)
CPU_VSS_ABS: length 2.5
  TOP w0.102: U2.AB10 140.05,71.54 v2(139.95,71.54)
  BOTTOM w0.102: v3(139.06,72.3) 139.18,72.3 v2(139.95,71.54) R246.1
CPVEE: length 4
  TOP w0.203: v1(179.35,53.16) 179.35,53.68 179.1,53.93 U9.20
  TOP w0.508: C210.1 179.48,53.03 v1(179.35,53.16)
CR_CLKREQ_N: length 3.2
  BOTTOM w0.102: R458.1 186.57,139.18 187.14,139.18 v3(187.52,139.56) 188.3,140.33 188.3,140.52 188.52,140.74 U14.2
CSA0#_0: length 74.6
  TOP w0.102: VRAM2.L2 67.48,86.27 v5(67.48,83.89) ; VRAM1.L2 81.56,86.32 81.56,85.86 81.2,85.49 80.37,85.49 79.58,84.7 78.79,84.7 77.32,83.23 77.32,83.09 77.68,82.72 77.68,82.56 77.56,82.44 77.39,82.44 77.22,82.61 76.85,82.61 76.14,81.9 75.78,81.9 75.56,81.68 75.56,80.66 75.91,80.3 76.24,80.3 76.49,80.05 76.49,79.97 76.59,79.87 77.89,79.87 78,79.77 78,79.39 v1(77.72,79.11) 77.72,78.62 77.51,78.42 76.78,78.42 76.63,78.27 76.11,78.27 75.99,78.4 75.99,78.45 v5(75.74,78.7)
  TOP w0.127: v5(72.39,103.04) 72.78,103.43 GPU1.E24
  L3 w0.127: v5(67.48,83.89) 68.17,83.2 68.17,81.49 70.73,78.93 74.44,78.93 74.59,78.78 75.66,78.78 v5(75.74,78.7)
  L3 w0.165: v5(64.71,82.71) 64.82,82.82 64.82,83.83 64.99,84 64.99,86.3 65.6,86.9 65.6,93.97 68.7,97.06 69.72,97.06 70.83,98.18 71.16,98.18 71.42,98.43 71.42,98.77 71.44,98.79 71.44,102.22 72.26,103.04 v5(72.39,103.04)
  BOTTOM w0.127: v5(64.71,82.71) 65.06,82.36 65.2,82.36 65.58,81.97 65.58,81.59 66.25,80.92 66.5,80.92 67.33,80.1 67.54,80.1 67.67,80.22 67.67,80.76 67.77,80.86 67.97,80.86 68.07,80.76 68.07,80.2 68.18,80.1 68.38,80.1 68.48,80.2 68.48,80.76 68.58,80.86 68.79,80.86 68.89,80.76 68.89,80.2 68.99,80.1 69.19,80.1 69.29,80.2 69.29,80.76 69.39,80.86 69.6,80.86 69.7,80.76 69.7,80.2 69.8,80.1 70,80.1 70.11,80.2 70.11,80.76 70.21,80.86 70.41,80.86 70.51,80.76 70.51,80.2 70.61,80.1 73.6,80.1 74.32,79.37 74.45,79.37 75.05,78.78 75.66,78.78 v5(75.74,78.7)
CSA0#_1: length 71.7
  TOP w0.127: v5(65.14,92.09) 65.89,92.84 65.89,93.98 69.56,97.64 69.56,100.81 70.16,101.41 70.77,101.41 GPU1.C26
  L3 w0.165: v5(65.14,92.09) 65.14,92.08 65.14,90.64 64.98,90.47 63.73,90.47 63.57,90.31 63.57,89.98 63.73,89.81 64.98,89.81 65.14,89.65 65.14,89.32 64.98,89.15 63.73,89.15 63.57,88.99 63.57,88.66 63.73,88.49 64.98,88.49 65.14,88.33 65.14,87.18 64.43,86.47 v5(64.43,84.57)
  BOTTOM w0.102: VRAM3.L2 87.05,86.35 87.05,82.54 85.15,80.64 81.54,80.64 80.94,80.05 79.09,80.05 78.97,80.16 78.97,81.3 79.36,81.69 79.36,82.94 78.73,83.58 77.25,83.58 77.08,83.41 76.94,83.41 76.8,83.56 76.8,83.7 77,83.9 77,84.04 76.85,84.19 76.71,84.19 76.51,83.99 76.37,83.99 76.22,84.13 76.22,84.28 76.41,84.46 76.41,84.61 76.26,84.75 76.12,84.75 75.98,84.61 75.75,84.61 75.65,84.71 75.65,85.63 74.27,87.01 73.35,87.01 73.02,86.68 VRAM4.L2
  BOTTOM w0.127: 79.09,80.05 79.09,79.39 78.68,78.98 v3(77.46,78.98) 77.26,78.98 77.01,79.23 76.99,79.23 76.99,79.39 76.88,79.5 76.88,79.68 76.18,80.38 75.84,80.38 75.6,80.62 75.49,80.62 75,81.11 74.06,81.11 73.94,81 71.18,81 70.71,81.47 66.35,81.47 66.04,81.78 66.04,82.16 65.87,82.34 65.87,82.88 64.53,84.21 64.43,84.32 v5(64.43,84.57)
CSA1#_0: length 76.4
  TOP w0.102: VRAM6.L2 56.46,120.66 54.86,120.66 v5(54.85,120.67) ; GPU1.K24 72.4,107.22 v5(72.38,107.22) ; v5(48.68,112.46) 48.68,112.51 49.07,112.89 49.7,112.89 49.83,112.76 v1(50.49,112.76) 50.51,112.74 51.68,112.74 52.08,112.34 55.31,112.34 55.44,112.21 55.44,111.95 55.31,111.82 54.67,111.82 54.55,111.69 54.55,111.42 54.67,111.29 55.27,111.29 56.12,110.43 56.12,110.15 56.45,109.82 56.45,109.64 56.33,109.51 56.17,109.51 56.05,109.38 56.05,109.23 56.17,109.1 56.44,109.1 56.55,108.99 56.55,108.82 56.44,108.7 56.13,108.7 56.02,108.6 56.02,108.4 56.13,108.3 56.39,108.3 56.69,108 56.69,107.37 56.51,107.2 56.51,106.58 VRAM5.L2
  L3 w0.127: v5(54.85,120.67) 52.55,120.67 50.79,118.91 50.77,118.91 48.93,117.07 48.93,112.73 48.68,112.48 v5(48.68,112.46)
  L3 w0.165: v5(72.38,107.22) 71.77,107.22 71.4,106.86 69.7,106.86 68.56,105.72 68.56,105.46 67.46,104.36 67.46,102.98 66.87,102.39 66.87,101.05 64.31,98.49 64.27,98.49 62.9,97.12 58.36,97.12 57.87,96.63 53.38,96.63 52.97,97.05 51.59,97.05 v5(50.38,98.26)
  BOTTOM w0.127: v5(48.68,112.46) 48.68,112.26 47.34,110.91 47.34,109.89 48.91,108.31 48.91,107.25 49.75,106.41 49.75,100.36 50.38,99.72 v5(50.38,98.26)
CSA1#_1: length 76.6
  TOP w0.102: GPU1.M23 73.58,109.28 v5(73.17,109.69)
  L3 w0.127: 71.94,108.46 72.56,108.46 72.81,108.71 72.81,109.33 v5(73.17,109.69)
  L3 w0.165: 71.94,108.46 71.9,108.49 71.38,108.49 70.28,107.39 69.27,107.39 66.64,104.76 66.64,103.36 66.07,102.78 66.07,101.23 65.83,100.99 64.36,99.53 64.1,99.53 63.85,99.27 61.98,99.27 61.81,99.11 61.81,98.47 61.65,98.31 61.31,98.31 61.15,98.47 61.15,99.11 60.98,99.27 60.65,99.27 60.49,99.11 60.49,98.47 60.32,98.31 59.99,98.31 59.83,98.47 59.83,99.11 59.66,99.27 59.33,99.27 59.17,99.11 59.17,98.47 59,98.31 58.67,98.31 58.51,98.47 58.51,99.11 58.34,99.27 58.01,99.27 57.85,99.11 57.85,98.47 57.68,98.31 57.35,98.31 57.19,98.47 57.19,99.11 57.02,99.27 56.36,99.27 55.76,98.67 55.76,98.4 55.54,98.18 54.74,98.18 54.08,98.84 v5(51.75,98.84)
  BOTTOM w0.102: VRAM8.L2 56.84,115.25 57.17,114.92 57.17,114.02 v3(54.23,111.08) 53.48,110.34 53.48,109.84 52.15,108.51 52.01,108.51 51.92,108.6 51.78,108.6 51.64,108.45 51.64,108.31 51.72,108.23 51.72,108.08 51.24,107.6 51.24,107.18 50.42,106.36 50.42,100.94 51.42,99.93 51.42,99.17 v5(51.75,98.84) 52.08,99.17 52.08,99.78 50.81,101.05 50.81,105.9 50.94,106.03 51.12,106.03 51.22,105.93 51.22,103.22 51.33,103.12 51.6,103.12 51.7,103.02 51.7,102.82 51.6,102.71 51.45,102.71 51.35,102.61 51.35,102.28 51.45,102.18 51.63,102.18 51.73,102.08 51.73,101.88 51.63,101.77 51.45,101.77 51.35,101.67 51.35,101.16 51.47,101.03 51.82,101.03 51.93,101.13 51.93,101.41 52.03,101.51 52.23,101.51 52.33,101.41 52.33,101.13 52.43,101.03 56.42,101.03 VRAM7.L2
CSN1: length 56
  TOP w0.305: v2(37.79,236.97) 38.55,237.73 PR4433.1 ; PG2.2 v2(32.2,194.42)
  L4 w0.305: v2(37.79,236.97) 37.79,236.99 37.53,236.74 36.84,236.74 34.49,234.38 34.49,196.71 v2(32.2,194.42)
  BOTTOM w0.203: 38.49,240.28 40.11,241.9 PU4401.38
  BOTTOM w0.305: 38.49,240.28 PC4427.2 PR4446.1 38.49,238.3 38.52,238.26 v3(38.52,237.45) 38.04,236.97 v2(37.79,236.97)
CSN1A: length 43.4
  TOP w0.254: v2(78.02,247.51) PG8.2
  L3 w0.254: v2(52.14,239.64) 52.39,239.89 53.41,239.89 55.7,242.18 74.65,242.18 77.78,245.31 77.78,247.27 v2(78.02,247.51)
  BOTTOM w0.203: 46.38,240.95 46.37,240.96 46.37,241.72 PU4401.26
  BOTTOM w0.254: 46.38,240.95 48.14,239.19 PC4422.2 PR4430.1 ; v2(52.14,239.64) 51.76,239.25 PR4422.1 51.31,239.57 51,239.89 50.11,239.89 49.41,239.19 PR4430.1 ; PR4430.1 v3(49.22,237.93)
CSN2: length 43.6
  TOP w0.305: PG4.2 v2(32.33,210.43) ; v2(32.84,239.51) 32.96,239.64 PR4445.1 PR4432.1
  L4 w0.305: v2(35.31,240.55) 35.31,240.06 33.95,238.7 33.95,235.57 33.22,234.84 33.22,211.31 v2(32.33,210.43)
  BOTTOM w0.203: 37.62,241.12 37.62,241.25 38.47,242.1 38.47,242.23 39.19,242.95 PU4401.40
  BOTTOM w0.305: 37.62,241.12 37.09,240.59 PC4426.2 35.35,240.59 v2(35.31,240.55) v3(33.85,240.55) 33.5,240.55 32.84,239.89 v2(32.84,239.51)
CSN2A: length 64.8
  TOP w0.254: PG10.2 v2(103.07,246.77)
  BOTTOM w0.203: PU4401.24 45.4,243.88 46.85,242.43 46.88,242.43 47.73,241.58 47.84,241.58 PC4421.2
  BOTTOM w0.254: 57.98,241.16 82.14,241.16 87.1,246.11 96.37,246.11 97.27,247.01 102.82,247.01 v2(103.07,246.77) ; 57.98,241.16 54.33,241.16 53.51,241.98 53.07,241.98 52.75,242.3 50.74,242.3 50.42,241.98 PR4421.1 49.98,241.22 PR4428.1 PC4421.2 ; 57.98,241.16 v3(57.98,240.91)
CSN3: length 24.5
  TOP w0.305: PR4431.1 30.1,242.49 30.3,242.3 30.3,242.3 v1(30.36,242.25) 30.6,242.49 v2(31.18,242.49) 32.07,242.49 PR4468.2 ; PG6.2 v2(31.95,223.76)
  L4 w0.305: v2(31.18,242.49) 31.44,242.49 31.95,241.98 v2(31.95,223.76)
CSP1: length 49.3
  TOP w0.305: PR4437.2 36.52,238.65 35.95,238.08 PR4443.1 35.95,236.6 35.66,236.32 v1(35.55,236.32) 35.52,236.28 v2(34.56,236.28) ; PG1.2 v2(31.31,194.42)
  L4 w0.305: v2(34.56,236.28) 34.83,236.28 35,236.11 35,235.76 33.85,234.61 33.85,196.96 v2(31.31,194.42)
CSP1A: length 34.7
  TOP w0.254: v2(77.16,247.51) PG7.2 ; v2(52.14,240.52) 52.19,240.57 v1(53.18,240.57) 53.18,240.7 53.16,240.73 PR4434.2
  L3 w0.254: v2(77.16,247.51) 77.4,247.27 77.4,245.46 74.49,242.56 55.54,242.56 53.25,240.27 52.39,240.27 v2(52.14,240.52)
  BOTTOM w0.254: PR4429.1 v2(52.14,240.52)
CSP2: length 35.8
  TOP w0.305: PG3.2 v2(31.44,210.43) ; v2(33.6,239.38) 33.6,239.89 34.11,240.4 PR4442.1 34.42,240.14 PR4436.2 34.46,239.22 34.46,238.39 34.21,238.14 v1(34.21,237.96)
  L4 w0.305: v2(31.44,210.43) 32.58,211.57 32.58,235.06 33.34,235.83 33.34,239.13 v2(33.6,239.38)
CSP2A: length 57
  TOP w0.254: v2(103.07,247.64) PG9.2
  BOTTOM w0.254: v3(55.7,241.79) 55.7,241.54 ; 55.7,241.54 81.98,241.54 86.94,246.49 96.21,246.49 97.11,247.39 102.82,247.39 v2(103.07,247.64) ; 55.7,241.54 54.49,241.54 53.66,242.37 53.23,242.37 52.59,243 PR4423.2 52.33,243.06 PR4427.1
CSP3: length 25.9
  TOP w0.305: PG5.2 v2(31.06,223.76) ; PR4441.1 32.01,243.57 v1(30.93,243.57) PR4435.2 29.85,244.14 v2(30.17,244.46)
  L4 w0.305: v2(31.06,223.76) 31.06,240.91 30.42,241.54 30.42,244.21 v2(30.17,244.46)
DACA_VREF: length 2.4
  TOP w0.432: v5(91.39,119.6) 91.37,119.6 91.34,119.63 91.32,119.63 90.98,119.97 GPU1.AE2
  BOTTOM w0.508: v3(92.19,120.45) C12382.1 91.26,119.74 v5(91.39,119.6)
DC_19V:
  vias: v1(81.63,40.42) v3(81.3,41.24) v4(80.49,37.43) v4(81.5,37.31) v4(81.58,38.64) v4(82.57,39.46) v4(82.57,38.39) v4(82.56,37.31) v4(83.6,40.38) v4(83.59,39.36) v4(83.59,38.33) v4(83.58,37.3) v4(84.14,41.24) v4(84.63,40.34) v4(84.6,39.32) v4(84.6,38.3) v4(84.6,37.28)
DCBATOUT: length 220
  TOP w0.508: R509.1 80.08,61.34 R507.1 80.8,60.07 80.84,60.11 v2(80.94,60.11) ; v2(34.46,100.06) 34.92,100.06 36.14,101.28 PR8617.1 ; R79915.1 6.36,168.83 ; v2(43.86,150.51) 43.76,150.51 43.53,150.74 R1988.1 42.42,149.72 R1989.1 ; 65.82,47.32 v2(65.82,44.18)
  L3 w0.508: v2(43.86,150.51) 43.66,150.51 43.38,150.23 35.78,150.23 30.62,145.07 30.62,136.77 31.23,136.16 31.23,134.56 29.82,133.15 22.44,133.15 22.37,133.08 v2(20.26,133.08) ; v2(50.26,40.58) 55.87,40.58 57.39,39.05 62.28,39.05 65.82,42.6 v2(65.82,44.18)
  L3 w1.27: v4(153.18,19.37) 151.2,17.39 149.12,17.39 148.48,16.75 144.91,16.75 142.06,13.89 142.06,11.98 140.88,10.8 139.53,10.8 v4(139.01,10.27)
  L4 w0.508: v2(118.03,58.06) 118.05,58.06 118.69,58.7 118.69,59.25 118.3,59.64 116.71,59.64 114.32,62.03 114.32,63.79 112.63,65.48 112.63,67.45 110.15,69.93 110.15,69.94 109.47,70.62 106.6,70.62 104.74,72.48 v2(104.74,74.66)
  L4 w1.27: v4(139.01,10.27) 137.03,8.29 133.16,8.29 132.67,8.78 130.91,8.78 130.43,8.29 119.66,8.29 119.17,8.78 119.14,8.78 v4(109.01,18.91)
  BOTTOM w0.203: 31.69,77.2 30.97,76.48 PU35.11
  BOTTOM w0.508: 15.18,141.85 19.88,141.85 20.64,141.08 20.64,134.99 20.95,134.68 20.95,133.57 20.46,133.08 v2(20.26,133.08) ; R9601.1 R9602.1 49.62,41.39 50.16,40.85 50.16,40.68 v2(50.26,40.58) ; R288.1 119.07,58.06 v2(118.03,58.06) ; R79727.1 16.77,50.34 v2(16.71,50.28) ; 31.69,77.2 31.86,77.37 PR152.1 32.45,77.44 32.45,80.38 PC70.2 ; R79738.1 v2(14.8,34.91)
  BOTTOM w1.27: v4(32.07,87.87) 32.4,87.54 32.4,80.58 PC70.2 ; 107.38,20.69 100.78,27.29 91.2,27.29 90.8,26.88 89.38,26.88 86.73,29.53 86.73,40.52 86.94,40.73 v4(86.94,42.28)
  vias: v1(5.91,166.1) v1(11.66,185.03) v1(19.75,87.11) v1(23.31,257.8) v1(31.57,92.19) v1(33.67,59.17) v1(56.71,263.05) v1(81.98,52.56) v1(97.22,74.54) v1(130.68,258.48) v3(14.78,149.01) v4(2.36,247.88) v4(2.36,246.75) v4(2.36,244.46) v4(2.48,245.6) v4(3.12,14.08) v4(3.3,248.01) v4(3.29,246.87) v4(3.29,244.59) v4(3.42,245.73) v4(3.41,163.04) v4(3.4,161.91) v4(3.41,160.76) v4(4.29,248.02) v4(4.26,13.96) v4(4.39,246.87) v4(4.39,244.59) v4(4.39,163.05) v4(4.39,160.77) v4(4.51,245.73) v4(4.49,161.91) v4(8.36,104.37) v4(8.35,103.24) v4(9.34,104.38) v4(9.44,103.24) v4(10.36,104.38) v4(10.36,103.24) v4(11.35,104.38) v4(11.37,103.24) v4(11.94,152) v4(11.93,150.86) v4(12.32,147.55) v4(12.31,146.42) v4(12.32,144.25) v4(12.31,143.12) v4(12.26,104.38) v4(12.29,103.24) v4(12.52,140.19) v4(12.52,139.18) v4(12.92,152.01) v4(13.02,150.86) v4(13.3,147.56) v4(13.3,144.26) v4(13.4,146.42) v4(13.4,143.12) v4(13.79,140.19) v4(13.79,139.05) v4(14.8,140.07) v4(14.8,138.92) v4(18.1,61.33) v4(18.23,60.18) v4(33.22,95.08) v4(33.22,94.09) v4(33.22,93.15) v4(37.84,109.1) v4(38.3,110.98) v4(38.3,109.97) v4(40.46,57.39) v4(41.39,57.31) v4(42.41,57.34) v4(43.43,57.34) v4(44.44,57.34) v4(66.49,54.37) v4(67.51,54.37) v4(68.65,54.37) v4(105.86,78.95) v4(106.37,77.96) v4(107,78.85) v4(107.51,77.96) v4(108.15,78.95) v4(108.65,92.7) v4(108.65,77.96) v4(108.73,91.27) v4(108.78,89.78) v4(109.54,79.74) v4(109.54,78.6) v4(110.18,92.7) v4(110.25,91.27) v4(110.31,89.78) v4(111.55,92.72) v4(111.63,91.3) v4(111.68,89.8) v4(122.75,99.43) v4(122.75,98.41) v4(122.75,97.4) v4(122.75,96.38) v4(123.77,99.43) v4(123.77,98.41) v4(123.77,97.4) v4(123.77,96.38) v4(123.89,262.24) v4(123.89,261.1) v4(123.89,259.96) v4(123.89,258.81) v4(125.04,262.24) v4(125.04,261.1) v4(125.04,259.96) v4(125.04,258.81) v4(132.53,107.68) v4(132.53,106.54) v4(132.53,105.52) v4(132.56,104.38) v4(133.47,104.61) v4(133.55,107.68) v4(133.55,106.54) v4(133.55,105.52) v4(135.83,261.1) v4(135.83,259.19) v4(135.96,257.8) v4(154.63,108.44) v4(154.63,107.3) v4(155.9,108.44) v4(155.9,107.3) v4(157.17,108.32) v4(157.17,107.3) v4(158.44,108.32) v4(158.44,107.3)
DCBATOUT_1D35V_VGA: length 0.6
  TOP w0.305: 43.26,106.78 PU8602.22
  vias: v1(40.07,113.14)
DCIN_EN: length 9.1
  TOP w0.102: U118.13 157.59,46.68 156.91,47.36 156.91,47.85 156.57,48.2 154.68,48.2 153.41,49.46 153.41,49.77 v1(153.1,50.08) 152.68,50.08 152.02,49.43 R2087.2
DDC5V_HDMI: length 29.4
  TOP w0.254: v2(153.99,23.23) 155.16,22.06 C12217.1 157.67,21.39 D5201.3 ; v2(149.9,23.3) 149.9,23.26 149.3,22.66 145.99,22.66 R5214.1 144.91,23.29 143.07,21.45 R5209.1 ; 143.07,26.78 144.21,26.78 144.79,26.21 R5213.1 146.06,26.91 149.4,26.91 v2(149.9,26.4)
  L3 w0.254: v2(149.9,26.4) 149.93,26.4 149.93,23.32 149.91,23.3 v2(149.9,23.3)
  L4 w0.254: v2(153.99,23.23) 153.9,23.32 149.93,23.32 149.93,23.3 v2(149.9,23.3)
  BOTTOM w0.254: v3(150.6,23.89) 150.49,23.89 v2(149.9,23.3)
DDC5V_HDMI_R: length 10.6
  TOP w0.254: D5201.2 159.58,20.29 v1(159.58,28.18) 159.58,28.5 R5217.2
DDC_WP: length 132
  TOP w0.102: R5212.2 139.53,18.59 139.01,18.07 139.01,15.53 136.16,12.69 136.16,11.82 135.34,11 132.76,11 129.96,13.79 129.96,23.06 v1(131.49,24.59) 131.49,25.8 130.27,27.02 v2(130.27,27.06) ; v2(43.7,48.91) 43.45,48.91 42.87,48.32 SCA1.39
  L4 w0.127: v2(43.7,48.91) 44.14,48.47 44.14,48.09 44.45,47.78 44.84,47.78 45.18,48.11 45.18,48.56 46.31,49.69 48.87,49.69 49.68,50.51 61.6,50.51 64.71,47.4 99.1,47.4 99.75,48.06 100.82,48.06 101.51,47.37 103.77,47.37 109.67,41.47 109.67,40.07 117.86,31.88 119.44,31.88 122.75,28.56 128.77,28.56 v2(130.27,27.06)
DDC_WP_1: length 7.7
  TOP w0.102: R5212.1 140.15,20.31 v1(140.4,20.56) 141.29,21.45 R5209.2 141.61,24.56 142.56,25.51 143.07,25.51
DDCBUF: length 7.9
  TOP w0.102: R1598.2 152.02,47.81 152.98,48.77 v1(153.25,48.77) 153.53,48.77 R2089.1 155.07,47.23 156.66,47.23 157.61,46.28 U118.14
DDPB_CTRL_CLK: length 43.7
  TOP w0.102: U2.BA5 150.16,69.14 150.75,69.73 v2(150.89,69.73) ; U118.38 163.98,46.68 164.37,47.08 165.81,47.08 166.59,47.87 167.79,47.87 168.54,48.62 168.54,49.2 v1(168.65,49.3) 168.54,49.41 168.54,50.13 168.27,50.41 168.27,50.93 167.79,51.41 167.79,52.61 167.76,52.63 167.76,53.29 166.85,54.2 161.99,54.2 161.77,54.42 161.77,58.85 161.6,59.01 161.6,59.04 v2(161.35,59.3)
  L3 w0.127: v2(150.89,69.73) 151.21,69.41 151.21,67.87 149.39,66.05 149.39,64.65 149.9,64.15 151.53,64.15 153.69,61.99 158.65,61.99 v2(161.35,59.3)
DDPB_CTRL_CLK_CONN: length 21.9
  TOP w0.102: v2(166.06,39.43) 165.99,39.5 v1(165.99,41.01) R2083.2 165.99,43.04 165.23,43.8 164.36,43.8 163.88,44.28 U118.32 ; HDMI1.15 153.78,39.02 U29.10 U29.1 155.88,39.12 v2(156.03,38.98)
  L4 w0.127: v2(156.03,38.98) 156.48,39.43 v2(166.06,39.43)
DDPB_CTRL_DATA: length 40.3
  TOP w0.102: U118.39 164.05,47.08 164.64,47.67 v1(165.6,47.67) 166.11,48.17 167.77,48.17 168.04,48.44 168.04,50.84 167.56,51.32 167.56,52.51 167.53,52.54 167.53,53.19 166.76,53.97 161.89,53.97 161.54,54.32 161.54,58.34 v2(160.58,59.3) ; v2(150.76,68.05) 150.92,68.21 U2.BC4
  L3 w0.127: v2(150.76,68.05) 149.14,66.42 149.14,64.54 149.79,63.89 151.42,63.89 153.58,61.73 153.86,61.73 154.5,61.1 158.78,61.1 v2(160.58,59.3)
DDPB_CTRL_DATA_CONN: length 27.7
  TOP w0.102: v2(167,39.43) 167.37,39.43 v1(169.08,41.15) 169.68,41.74 R2084.2 168.36,43.85 166.03,43.85 165.83,44.06 164.51,44.06 163.88,44.68 U118.33 ; v2(156.05,39.86) 155.78,39.6 U29.2 U29.9 153.8,39.52 HDMI1.16
  L4 w0.127: v2(167,39.43) 166.53,39.9 156.09,39.9 v2(156.05,39.86)
DDPC_AUX_DN_C: length 2.9
  TOP w0.102: NGFF1.20 133.66,233.5 133.82,233.65 134.7,233.65 TP235.1
DDPC_AUX_DP_C: length 2.9
  TOP w0.102: NGFF1.22 133.73,234 133.86,233.87 134.89,233.87 TP234.1
DDPC_CTRL_CLK: length 2.4
  TOP w0.102: U2.BB3 150.08,67.69 v2(149.67,68.09)
  BOTTOM w0.102: TP169.1 149.29,67.37 149.67,67.75 v2(149.67,68.09)
DDPC_CTRL_DATA: length 3.3
  TOP w0.102: U2.BD6 150.81,69.15 v2(150.66,69)
  BOTTOM w0.102: v2(150.66,69) 150.68,69.01 R79944.1 152.53,69.01 152.97,69.45 v3(152.97,69.48)
DDPD_CTRL_CLK: length 6.2
  TOP w0.102: TP167.1 153.84,64.04 153.1,64.78 153.1,67.88 152.09,68.89 U2.BE5
DDPD_CTRL_DATA: length 15.2
  TOP w0.102: U2.BE6 152.02,69.39 152.3,69.11 152.45,69.11 153.21,68.35 153.21,68.16 153.31,68.06 153.31,64.9 154.5,63.7 154.5,62.85 155.65,61.71 155.65,60.96 v1(155.63,60.95) 156.77,59.8 158.33,59.8 158.59,59.54 158.59,59.2 R229.1
DDR0_ALERT#: length 14.6
  TOP w0.102: v2(89.25,191.32) 89.25,191.32 89.25,191.28 89.67,190.85 CPU1.AT23
  BOTTOM w0.102: v2(89.25,191.32) 89.64,191.72 89.64,192.34 90.83,193.53 95.88,193.53 95.95,193.61 97.12,193.61 97.32,193.41 v3(99.38,193.41) 101.1,193.41 R1.1
DDR1_ALERT#: length 9
  TOP w0.102: CPU1.AY25 94.43,193.76 v5(94.43,193.97)
  BOTTOM w0.102: v5(94.43,193.97) v3(97.48,193.97) 101.53,193.97 R2.1
DDR3_DRAMRST_N: length 162.5
  TOP w0.102: U2.BC14 150.3,73.21 v2(150.25,73.25)
  L3 w0.127: v2(164.92,129.78) 166.19,129.78 173.08,136.68 173.08,159.93 173.39,160.23 173.39,186.36 v2(171.3,188.45)
  L4 w0.127: v2(164.92,129.78) 163.52,128.38 155.81,128.38 152.79,125.36 152.79,123.97 151.75,122.92 151.75,122.2 149.08,119.53 149.08,107.45 155.07,101.45 155.07,101.15 161.22,95.01 161.22,86.45 161.95,85.73 161.95,85.34 161.83,85.22 161.83,84.55 162.07,84.31 162.07,83.92 161.22,83.07 161.22,81.34 156.14,76.26 153.2,76.26 152.84,75.9 152.84,75.66 150.43,73.25 v2(150.25,73.25)
  BOTTOM w0.102: v2(150.25,73.25) 150.77,73.25 C143.1 ; v2(171.3,188.45) 170.85,188.01 R925.1 169.04,188.01 168.6,188.45 168.6,188.9 R92.1 167.96,189.09 167.71,188.84 v3(159.2,188.84) R81.1
DDR3_DRAMRST_N_A_1: length 5.6
  TOP w0.102: v5(155.05,189.88) 154.98,189.95 DIMM1.30
  BOTTOM w0.102: R81.2 C112.1 153.93,190.47 154.5,191.04 v3(154.5,191.09) 155.05,190.53 v5(155.05,189.88)
DDR3_DRAMRST_N_B_1: length 4.6
  TOP w0.102: v5(170.18,190.13) 170,189.95 DIMM2.30
  BOTTOM w0.102: v3(170.18,191.19) v5(170.18,190.13) 170.15,190.11 C136.1 R92.2
DDR_SHDN: length 6.3
  BOTTOM w0.102: R1954.2 166.19,207.76 166.31,207.89 v3(166.82,207.89) 167.07,207.89 167.33,207.63 R1957.2 ; R1954.2 165.6,206.22 U171.6 ; R1954.2 166.12,206.87 U171.5
DDR_VREF_PWR: length 2.3
  BOTTOM w0.203: PU40.2 171.65,216.02 ; 169.61,217.92 169.43,217.73 PU40.20
  vias: v3(176.93,218.58)
DDR_VTT_CNTL: length 77.5
  TOP w0.102: v2(111.07,234.81) 108.52,234.81 107.82,235.51 107.82,236.22 R31.2 ; CPU1.AC36 77.8,202.71 v2(78.25,203.16)
  BOTTOM w0.102: v2(78.25,203.16) 78.53,203.16 78.94,203.57 79.72,203.57 81.73,205.57 81.73,212.08 86.45,216.8 91.72,216.8 95.99,221.07 96.68,221.07 96.96,221.35 118.43,221.35 120.5,223.42 120.5,226.32 118.79,228.04 116.39,228.04 v3(114.43,229.99) 111.07,233.36 v2(111.07,234.81)
DDR_VTT_CNTL_GATE: length 5.1
  TOP w0.102: Q1228.2 110.43,243.13 R1734.2 ; Q1228.3 109.78,243.18 109.92,243.32 R1734.2 ; R1734.2 v1(110.62,244.61)
DDSP_B_HPD: length 35.7
  TOP w0.102: U2.AW4 148.91,68.05 v2(148.91,68.04) ; v2(158.14,59.35) 158.18,59.3 158.18,58.87 159.29,57.77 160.95,57.77 161.31,57.42 161.31,54.23 161.8,53.74 162.18,53.74 163.99,53.74 164.58,53.15 v1(164.58,52.13) 164.58,50.52 163.63,49.56 162.42,49.56 161.92,49.06 U118.3
  L3 w0.127: v2(148.91,68.04) 148.96,67.98 148.96,67.18 148.61,66.82 148.61,65.92 148.26,65.58 147.92,65.58 147.65,65.32 147.65,64.95 147.85,64.75 147.85,64.09 149.17,62.77 151.34,62.77 153.04,61.07 153.04,60.69 153.32,60.41 153.82,60.41 153.87,60.46 154.06,60.46 154.18,60.34 156.92,60.34 157.88,59.38 158.11,59.38 v2(158.14,59.35)
DDSP_B_HPD_CONN: length 13.4
  TOP w0.102: v2(156.28,41.64) 155.28,40.64 U29.4 U29.7 153.1,40.64 152.72,41.02 HDMI1.19 ; U118.28 v2(161.92,42.15)
  L4 w0.127: v2(156.28,41.64) 161.41,41.64 v2(161.92,42.15)
  BOTTOM w0.102: v3(161.92,41.34) v2(161.92,42.15)
DDSP_B_TX_DN_0: length 307.2
  TOP w0.102: C12213.1 166.52,52.46 166.52,52.74 v2(166.22,53.04) ; CPU1.D21 59.13,187.17 57.95,187.17 56.02,185.24 51.24,185.24 51.13,185.35 50.82,185.35 50.71,185.24 50.41,185.24 50.3,185.35 49.99,185.35 49.88,185.24 49.57,185.24 49.12,185.7 49.12,186.47 v2(49.4,186.75)
  L4 w0.127: v2(49.4,186.75) 48.89,186.24 48.89,185.17 45.42,181.7 45.42,173.85 47.26,172 47.26,155.67 37.67,146.08 37.67,141.68 34.64,138.65 34.64,133.57 31.12,130.05 31.12,126.65 26.1,121.63 26.1,108.84 25.72,108.46 25.72,104.38 24.95,103.61 24.95,89.79 19.82,84.66 19.82,70.23 35.72,54.33 38.38,54.33 38.89,53.82 65.03,53.82 66.72,52.13 79.67,52.13 80.79,51.01 97.96,51.01 98.42,51.47 104.35,51.47 110.91,44.91 119.51,44.91 121.09,43.33 129,43.33 130.54,44.87 144.3,44.87 145.03,45.59 154.29,45.59 155.13,46.43 155.13,46.43 155.81,47.11 158.38,47.11 158.73,47.47 161.2,47.47 166.22,52.49 v2(166.22,53.04)
  BOTTOM w0.102: v3(166.16,53.64) v2(166.22,53.04)
DDSP_B_TX_DN_1: length 300.6
  TOP w0.102: v2(162.41,53.04) 162.71,52.74 162.71,52.46 C12211.1 ; CPU1.E22 59.86,188.26 57.32,188.26 55.06,186 51.72,186 51.53,186.19 51.53,186.51 v2(51.79,186.76)
  L4 w0.127: v2(162.41,53.04) 162.69,52.77 162.69,52.36 160.47,50.15 157.76,50.15 155.26,47.66 154.73,47.13 138.21,47.13 136.96,45.87 130.45,45.87 128.68,44.11 121.43,44.11 119.84,45.69 111.23,45.69 104.68,52.25 80.96,52.25 80.3,52.91 67.04,52.91 65.5,54.44 65.35,54.6 39.55,54.6 38.97,55.18 35.96,55.18 20.59,70.55 20.59,84.28 25.72,89.41 25.72,103.11 26.5,103.88 26.5,108 26.88,108.38 26.88,116.65 28.22,117.99 28.22,122.63 31.9,126.3 31.9,129.73 35.41,133.25 35.41,138.31 38.45,141.34 38.45,145.76 48.08,155.39 48.08,172.29 46.2,174.17 46.2,181.38 50.53,185.72 50.64,185.72 51.21,186.29 51.31,186.29 v2(51.79,186.76)
  BOTTOM w0.102: v3(162.03,52.59) v2(162.41,53.04)
DDSP_B_TX_DN_2: length 296.2
  TOP w0.102: v2(158.6,53.04) 158.9,52.74 158.9,52.46 C12209.1 ; CPU1.A23 56.75,188.41 55.99,187.65 52.56,187.65 51.63,188.59 51.63,188.86 v2(51.99,189.22)
  L4 w0.127: v2(158.6,53.04) 158.88,52.77 158.88,52.37 154.41,47.9 137.68,47.9 136.47,46.7 130.18,46.7 128.36,44.88 121.77,44.88 120.17,46.48 111.54,46.48 105,53.02 81.59,53.02 80.93,53.68 70.88,53.68 69.19,55.37 39.87,55.37 39.29,55.95 36.28,55.95 21.52,70.72 21.52,84.05 26.5,89.03 26.5,102.69 27.27,103.46 27.27,107.44 27.65,107.83 27.65,116.32 29,117.67 29,121.25 32.67,124.92 32.67,129.41 36.19,132.93 36.19,135.62 39.22,138.65 39.22,144.55 48.85,154.18 48.85,172.61 48.45,173 48.45,173.2 48.18,173.47 47.99,173.47 46.97,174.49 46.97,181.06 47.4,181.49 47.6,181.49 47.87,181.76 47.87,181.96 48.14,182.23 48.33,182.23 48.6,182.49 48.6,182.69 48.87,182.96 49.06,182.96 49.33,183.23 49.33,183.42 50.85,184.94 52.06,184.94 52.92,185.8 53.41,186.3 53.41,187.18 52.64,187.95 52.14,187.95 51.63,188.45 51.63,188.86 v2(51.99,189.22)
  BOTTOM w0.102: v3(158.27,53.55) v2(158.6,53.04)
DDSP_B_TX_DN_3: length 292.5
  TOP w0.102: CPU1.D23 59.44,188.63 58.98,189.09 58.52,189.09 58.44,189.17 56.25,189.17 55.4,188.33 54.17,188.33 54.01,188.49 54.01,188.98 v2(54.29,189.27) ; C12215.1 154.63,52.43 155.16,52.96 156.19,52.96 156.7,52.45 157.3,52.45 157.6,52.75 v2(157.6,52.77)
  L4 w0.127: v2(54.29,189.27) 53.98,188.96 53.98,188.26 54.69,187.55 54.69,186.57 49.62,181.5 49.62,153.83 40,144.21 40,138.33 36.96,135.3 36.96,132.61 33.46,129.1 33.46,123.67 33.3,123.52 32.71,122.92 32.71,119.49 28.43,115.21 28.43,107.5 28.05,107.11 28.05,103.02 27.27,102.24 27.27,88.13 22.46,83.31 22.46,70.88 36.6,56.73 39.68,56.73 40.26,56.15 73.6,56.15 74.1,55.65 84.66,55.65 85.56,54.75 91.1,54.75 92.05,53.8 106.22,53.8 108.13,51.89 108.13,51.11 111.23,48.02 112.35,48.02 113.1,47.27 120.5,47.27 122,45.77 128.15,45.77 129.86,47.47 130.08,47.47 134.21,47.47 135.42,48.68 152.95,48.68 156.85,52.58 157.41,52.58 v2(157.6,52.77)
  BOTTOM w0.102: v3(157.04,53.01) v2(157.6,52.77)
