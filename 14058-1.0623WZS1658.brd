# Allegro board 14058-1.0623WZS1658.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
DFN8G2-G1309-UH40
  rect 0.305x0.737 smd: 1(0.75,1.018) 2(0.25,1.018) 3(-0.25,1.018) 4(-0.75,1.018) 5(-0.75,-1.018) 6(-0.25,-1.018) 7(0.25,-1.018) 8(0.75,-1.018)
  rect 1.295x0.889 smd: 9(0,0)
DFN10G3-G265175H32
  rect 0.305x0.914 smd: 1(1,1.549) 2(0.5,1.549) 3(0,1.549) 4(-0.5,1.549) 5(-1,1.549) 6(-1,-1.549) 7(-0.5,-1.549) 8(0,-1.549) 9(0.5,-1.549) 10(1,-1.549)
  rect 2.642x1.753 smd: 11(0,0)
DFN10G2510H26
  rect 0.305x0.787 smd: 1(1,0.494) 5(-1,0.494) 6(-1,-0.494) 10(1,-0.494)
  rect 0.254x0.787 smd: 2(0.521,0.494) 4(-0.521,0.494) 7(-0.521,-0.494) 9(0.521,-0.494)
  rect 0.025x0.025 smd: 3(0,0.494)
  rect 0.406x1.753 smd: 8(0,-0.494)
DM-BSH-03001-FDA-01
  round 0.254 hole 1.016 unplated: (-10.065,0) (10.065,0)
  rect 0.279x2.769 smd: 1(-7.25,-5.526) 2(-7.25,0.198) 3(-6.75,-5.526) 4(-6.75,0.198) 5(-6.25,-5.526) 6(-6.25,0.198) 7(-5.751,-5.526) 8(-5.751,0.198) 9(-5.25,-5.526) 10(-5.25,0.198) 11(-4.75,-5.526) 12(-4.75,0.198) 13(-4.249,-5.526) 14(-4.249,0.198) 15(-3.75,-5.526) 16(-3.75,0.198) 17(-3.25,-5.526) 18(-3.25,0.198) 19(-2.75,-5.526) 20(-2.75,0.198) 21(-2.25,-5.526) 22(-2.25,0.198) 23(-1.75,-5.526) 24(-1.75,0.198) 25(-1.25,-5.526) 26(-1.25,0.198) 27(-0.751,-5.526) 28(-0.751,0.198) 29(-0.25,-5.526) 30(-0.25,0.198) 31(0.25,-5.526) 32(0.25,0.198) 33(0.751,-5.526) 34(0.751,0.198) 35(1.25,-5.526) 36(1.25,0.198) 37(1.75,-5.526) 38(1.75,0.198) 39(2.25,-5.526) 40(2.25,0.198) 41(2.75,-5.526) 42(2.75,0.198) 43(3.25,-5.526) 44(3.25,0.198) 45(3.75,-5.526) 46(3.75,0.198) 47(4.249,-5.526) 48(4.249,0.198) 49(4.75,-5.526) 50(4.75,0.198) 51(5.25,-5.526) 52(5.25,0.198) 53(5.751,-5.526) 54(5.751,0.198) 55(6.25,-5.526) 56(6.25,0.198) 57(6.75,-5.526) 58(6.75,0.198) 59(7.25,-5.526) 60(7.25,0.198)
DO214AAAK-1121H97
  rect 2.311x2.032 smd: A(0,2.322) K(0,-2.322)
ECAP-100D6D3H237
  rect 1.397x1.397 hole 0.991: 1(0,-1.27)
  round 1.397 hole 0.991: 2(0,1.27)
ECAP-100D6D3H375
  rect 1.397x1.397 hole 0.991: 1(0,-1.27)
  round 1.397 hole 0.991: 2(0,1.27)
ECAP-100D6D3H473
  rect 1.397x1.397 hole 0.991: 1(0,-1.27)
  round 1.397 hole 0.991: 2(0,1.27)
FUSE-1608H22
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
G6179-1000000-U
  rect 0.635x2.108 smd: 1(1.905,3.47) 2(0.635,3.47) 3(-0.635,3.47) 4(-1.905,3.47) 5(-1.905,-3.47) 6(-0.635,-3.47) 7(0.635,-3.47) 8(1.905,-3.47)
GAP-CLOSE-PWR-3
  rect 0.66x0.762 smd: 1(-0.305,0) 2(0.305,0)
GEN8D5X8R5X4D5-8-F-A
  round 0.254 hole 5.004x4.521 unplated: (0,0)
  round 0.864 hole 0.508: 1(3.136,1.664) 2(1.918,2.882) 3(-1.918,2.882) 4(-3.136,1.664) 5(-3.136,-1.664) 6(-1.918,-2.882) 7(1.918,-2.882) 8(3.136,-1.664)
GEN315R138-8-F-A-1
  round 0.254 hole 3.505 unplated: (0,0)
  round 0.864 hole 0.508: 1(2.667,1.54) 2(1.54,2.667) 3(-1.54,2.667) 4(-2.667,1.54) 5(-2.667,-1.54) 6(-1.54,-2.667) 7(1.54,-2.667) 8(2.667,-1.54)
GEN315R138-8-F-A-2-S
  round 0.254 hole 3.505 unplated: (0,0)
  round 0.864 hole 0.508: 1(2.667,1.54) 2(1.54,2.667) 3(-1.54,2.667) 4(-2.667,1.54) 5(-2.667,-1.54) 6(-1.54,-2.667) 7(1.54,-2.667) 8(2.667,-1.54)
GEN315R178-8-F-A-1
  round 0.254 hole 4.521 unplated: (0,0)
  round 0.864 hole 0.508: 1(2.882,1.664) 2(1.664,2.882) 3(-1.664,2.882) 4(-2.882,1.664) 5(-2.882,-1.664) 6(-1.664,-2.882) 7(1.664,-2.882) 8(2.882,-1.664)
HF1804H
  round 1.651 hole 1.016: 1(-3.81,0) 2(-1.27,0) 3(1.27,0) 4(3.81,0)
HL5507F
  round 0.254 hole 1.016 unplated: (5,0)
  round 1.321 hole 0.914: 1(-6,-1) 2(-6,1) 3(-4,-1) 4(-4,1) 5(-2,-1) 6(-2,1) 7(0,-1) 8(0,1) 9(2,-1) 10(2,1) 11(4,-1) 12(4,1) 13(6,-1) 14(6,1)
HOLE315R158
  round 8.001 hole 4.013: 1(0,0)
JAC331-0140A8B-9H
  oval 1.321x2.235 hole 0.61x1.524: 1(-4.95,2.1) 4(5,2.1) P(3.25,-3.15) Q(-3.9,-2.1)
  oval 2.235x1.422 hole 1.524x0.711: 5(0,3.17)
L402H22
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
L402H24
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
L603H38
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
L8080-6020H158
  rect 6.502x3.15 smd: 1(0,2.944) 2(0,-2.944)
L20125H42
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
L112100-2030H158
  rect 3.505x3.15 smd: 1(0,4.769) 2(0,-4.769)
L115100-2H158
  rect 3.759x3.251 smd: 1(0,5.022) 2(0,-5.022)
L115100-2030H158
  rect 3.251x2.896 smd: 1(0,4.944) 2(0,-4.944)
L125100-4P-1H28
  rect 0.762x0.432 smd: 1(0.625,0.341) 2(-0.625,0.341) 3(-0.625,-0.341) 4(0.625,-0.341)
L125100-4P-1H36
  rect 0.762x0.432 smd: 1(0.625,0.341) 2(-0.625,0.341) 3(-0.625,-0.341) 4(0.625,-0.341)
L125100-4P-1H37
  rect 0.762x0.432 smd: 1(0.625,0.341) 2(-0.625,0.341) 3(-0.625,-0.341) 4(0.625,-0.341)
L686647H119
  rect 2.159x3.429 smd: 1(-3.111,0) 2(3.111,0)
LED1608AKH30
  custom 0.216x0.216 smd: A(0,0.762) K(0,-0.762)
LFQFN24G4-G2D9H40
  rect 0.305x0.508 smd: 1(1.25,1.905) 2(0.75,1.905) 3(0.25,1.905) 4(-0.25,1.905) 5(-0.75,1.905) 6(-1.25,1.905) 13(-1.25,-1.905) 14(-0.75,-1.905) 15(-0.25,-1.905) 16(0.25,-1.905) 17(0.75,-1.905) 18(1.25,-1.905)
  rect 0.508x0.305 smd: 7(-1.905,1.25) 8(-1.905,0.75) 9(-1.905,0.25) 10(-1.905,-0.25) 11(-1.905,-0.75) 12(-1.905,-1.25) 19(1.905,-1.25) 20(1.905,-0.75) 21(1.905,-0.25) 22(1.905,0.25) 23(1.905,0.75) 24(1.905,1.25)
  rect 2.896x2.896 smd: 25(0,0)
LFQFN52J6-G4D8H40
  rect 0.203x0.533 smd: 1(2.4,2.911) 13(-2.4,2.911) 27(-2.4,-2.911) 39(2.4,-2.911)
  rect 0.203x0.584 smd: 2(2,2.911) 3(1.6,2.911) 4(1.2,2.911) 5(0.8,2.911) 6(0.4,2.911) 7(0,2.911) 8(-0.4,2.911) 9(-0.8,2.911) 10(-1.2,2.911) 11(-1.6,2.911) 12(-2,2.911) 28(-2,-2.911) 29(-1.6,-2.911) 30(-1.2,-2.911) 31(-0.8,-2.911) 32(-0.4,-2.911) 33(0,-2.911) 34(0.4,-2.911) 35(0.8,-2.911) 36(1.2,-2.911) 37(1.6,-2.911) 38(2,-2.911)
  rect 0.533x0.203 smd: 14(-2.911,2.4) 26(-2.911,-2.4) 40(2.911,-2.4) 52(2.911,2.4)
  rect 0.584x0.203 smd: 15(-2.911,2) 16(-2.911,1.6) 17(-2.911,1.2) 18(-2.911,0.8) 19(-2.911,0.4) 20(-2.911,0) 21(-2.911,-0.4) 22(-2.911,-0.8) 23(-2.911,-1.2) 24(-2.911,-1.6) 25(-2.911,-2) 41(2.911,-2) 42(2.911,-1.6) 43(2.911,-1.2) 44(2.911,-0.8) 45(2.911,-0.4) 46(2.911,0) 47(2.911,0.4) 48(2.911,0.8) 49(2.911,1.2) 50(2.911,1.6) 51(2.911,2)
  rect 4.801x4.801 smd: 53(0,0)
LGA16G3-1H40
  rect 0.305x0.559 smd: 1(1,1.221) 2(0.5,1.221) 3(0,1.221) 4(-0.5,1.221) 5(-1,1.221) 9(-1,-1.221) 10(-0.5,-1.221) 11(0,-1.221) 12(0.5,-1.221) 13(1,-1.221)
  rect 0.559x0.305 smd: 6(-1.221,0.5) 7(-1.221,0) 8(-1.221,-0.5) 14(1.221,-0.5) 15(1.221,0) 16(1.221,0.5)
LQFP128H63
  rect 0.203x1.524 smd: 1(6.2,7.747) 2(5.8,7.747) 3(5.4,7.747) 4(5,7.747) 5(4.6,7.747) 6(4.2,7.747) 7(3.8,7.747) 8(3.4,7.747) 9(3,7.747) 10(2.6,7.747) 11(2.2,7.747) 12(1.8,7.747) 13(1.4,7.747) 14(0.999,7.747) 15(0.599,7.747) 16(0.199,7.747) 17(-0.199,7.747) 18(-0.599,7.747) 19(-0.999,7.747) 20(-1.4,7.747) 21(-1.8,7.747) 22(-2.2,7.747) 23(-2.6,7.747) 24(-3,7.747) 25(-3.4,7.747) 26(-3.8,7.747) 27(-4.2,7.747) 28(-4.6,7.747) 29(-5,7.747) 30(-5.4,7.747) 31(-5.8,7.747) 32(-6.2,7.747) 65(-6.2,-7.747) 66(-5.8,-7.747) 67(-5.4,-7.747) 68(-5,-7.747) 69(-4.6,-7.747) 70(-4.2,-7.747) 71(-3.8,-7.747) 72(-3.4,-7.747) 73(-3,-7.747) 74(-2.6,-7.747) 75(-2.2,-7.747) 76(-1.8,-7.747) 77(-1.4,-7.747) 78(-0.999,-7.747) 79(-0.599,-7.747) 80(-0.199,-7.747) 81(0.199,-7.747) 82(0.599,-7.747) 83(0.999,-7.747) 84(1.4,-7.747) 85(1.8,-7.747) 86(2.2,-7.747) 87(2.6,-7.747) 88(3,-7.747) 89(3.4,-7.747) 90(3.8,-7.747) 91(4.2,-7.747) 92(4.6,-7.747) 93(5,-7.747) 94(5.4,-7.747) 95(5.8,-7.747) 96(6.2,-7.747)
  rect 1.524x0.203 smd: 33(-7.747,6.2) 34(-7.747,5.8) 35(-7.747,5.4) 36(-7.747,5) 37(-7.747,4.6) 38(-7.747,4.2) 39(-7.747,3.8) 40(-7.747,3.4) 41(-7.747,3) 42(-7.747,2.6) 43(-7.747,2.2) 44(-7.747,1.8) 45(-7.747,1.4) 46(-7.747,0.999) 47(-7.747,0.599) 48(-7.747,0.199) 49(-7.747,-0.199) 50(-7.747,-0.599) 51(-7.747,-0.999) 52(-7.747,-1.4) 53(-7.747,-1.8) 54(-7.747,-2.2) 55(-7.747,-2.6) 56(-7.747,-3) 57(-7.747,-3.4) 58(-7.747,-3.8) 59(-7.747,-4.2) 60(-7.747,-4.6) 61(-7.747,-5) 62(-7.747,-5.4) 63(-7.747,-5.8) 64(-7.747,-6.2) 97(7.747,-6.2) 98(7.747,-5.8) 99(7.747,-5.4) 100(7.747,-5) 101(7.747,-4.6) 102(7.747,-4.2) 103(7.747,-3.8) 104(7.747,-3.4) 105(7.747,-3) 106(7.747,-2.6) 107(7.747,-2.2) 108(7.747,-1.8) 109(7.747,-1.4) 110(7.747,-0.999) 111(7.747,-0.599) 112(7.747,-0.199) 113(7.747,0.199) 114(7.747,0.599) 115(7.747,0.999) 116(7.747,1.4) 117(7.747,1.8) 118(7.747,2.2) 119(7.747,2.6) 120(7.747,3) 121(7.747,3.4) 122(7.747,3.8) 123(7.747,4.2) 124(7.747,4.6) 125(7.747,5) 126(7.747,5.4) 127(7.747,5.8) 128(7.747,6.2)
MSOP10H44
  rect 0.305x1.524 smd: 1(-0.999,-2.07) 2(-0.5,-2.07) 3(0,-2.07) 4(0.5,-2.07) 5(0.999,-2.07) 6(0.999,2.07) 7(0.5,2.07) 8(0,2.07) 9(-0.5,2.07) 10(-0.999,2.07)
NTC-402H22-U
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
NTC-402H24-U
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
OSC-3225-4P-3H36
  rect 1.397x0.914 smd: 1(-1.171,-0.825) 2(1.171,-0.825) 3(1.171,0.825) 4(-1.171,0.825)
OSC-3225-4P-4H30
  rect 1.397x1.067 smd: 1(-1.171,-0.756) 2(1.171,-0.756) 3(1.171,0.756) 4(-1.171,0.756)
OSC-3225-4P-4H36
  rect 1.397x1.067 smd: 1(-1.171,-0.756) 2(1.171,-0.756) 3(1.171,0.756) 4(-1.171,0.756)
POLYSW-2114H30
  rect 1.6x0.965 smd: 1(0,0.94) 2(0,-0.94)
PPAK-8P-3232H36
  rect 0.406x0.914 smd: 1(-0.975,-2.396) 2(-0.325,-2.396) 3(0.325,-2.396) 4(0.975,-2.396)
  rect 3.353x2.692 smd: 5(0,0)
  rect 0.025x0.025 smd: 6(0.65,0.838) 7(0,0.838) 8(-0.65,0.838)
PPAK-8P-5262H40
  rect 0.762x1.448 smd: 1(-1.905,-3.684) 2(-0.635,-3.684) 3(0.635,-3.684) 4(1.905,-3.684)
  rect 5.512x5.309 smd: 5(0,0)
  rect 0.025x0.025 smd: 6(0.635,2.146) 7(-0.635,2.146) 8(-1.905,2.146)
QFN16-G1D8-UH32
  rect 0.305x0.914 smd: 1(0.75,1.551) 2(0.25,1.551) 3(-0.25,1.551) 4(-0.75,1.551) 9(-0.75,-1.551) 10(-0.25,-1.551) 11(0.25,-1.551) 12(0.75,-1.551)
  rect 0.914x0.305 smd: 5(-1.551,0.75) 6(-1.551,0.25) 7(-1.551,-0.25) 8(-1.551,-0.75) 13(1.551,-0.75) 14(1.551,-0.25) 15(1.551,0.25) 16(1.551,0.75)
  rect 1.778x1.778 smd: 17(0,0)
QFN16G3-G1D85-UH40
  rect 0.305x0.508 smd: 1(0.75,1.397) 2(0.25,1.397) 3(-0.25,1.397) 4(-0.75,1.397) 9(-0.75,-1.397) 10(-0.25,-1.397) 11(0.25,-1.397) 12(0.75,-1.397)
  rect 0.508x0.305 smd: 5(-1.397,0.75) 6(-1.397,0.25) 7(-1.397,-0.25) 8(-1.397,-0.75) 13(1.397,-0.75) 14(1.397,-0.25) 15(1.397,0.25) 16(1.397,0.75)
  rect 1.702x1.702 smd: 17(0,0)
QFN20-G1D75H32
  rect 0.203x0.914 smd: 1(0.8,1.551) 2(0.4,1.551) 3(0,1.551) 4(-0.4,1.551) 5(-0.8,1.551) 11(-0.8,-1.551) 12(-0.4,-1.551) 13(0,-1.551) 14(0.4,-1.551) 15(0.8,-1.551)
  rect 0.914x0.203 smd: 6(-1.551,0.8) 7(-1.551,0.4) 8(-1.551,0) 9(-1.551,-0.4) 10(-1.551,-0.8) 16(1.551,-0.8) 17(1.551,-0.4) 18(1.551,0) 19(1.551,0.4) 20(1.551,0.8)
  rect 1.753x1.753 smd: 21(0,0)
QFN20-G2D1H32
  rect 0.305x1.092 smd: 1(0.999,1.956) 5(-0.999,1.956) 11(-0.999,-1.956) 15(0.999,-1.956)
  rect 0.305x1.143 smd: 2(0.5,1.93) 3(0,1.93) 4(-0.5,1.93) 12(-0.5,-1.93) 13(0,-1.93) 14(0.5,-1.93)
  rect 1.092x0.305 smd: 6(-1.956,0.999) 10(-1.956,-0.999) 16(1.956,-0.999) 20(1.956,0.999)
  rect 1.143x0.305 smd: 7(-1.93,0.5) 8(-1.93,0) 9(-1.93,-0.5) 17(1.93,-0.5) 18(1.93,0) 19(1.93,0.5)
  rect 2.108x2.108 smd: 21(0,0)
QFN20G3D5-G2D15H40
  rect 0.305x0.914 smd: 1(1,1.801) 5(-1,1.801) 11(-1,-1.801) 15(1,-1.801)
  rect 0.305x0.965 smd: 2(0.5,1.775) 3(0,1.775) 4(-0.5,1.775) 12(-0.5,-1.775) 13(0,-1.775) 14(0.5,-1.775)
  rect 0.914x0.305 smd: 6(-1.801,1) 10(-1.801,-1) 16(1.801,-1) 20(1.801,1)
  rect 0.965x0.305 smd: 7(-1.775,0.5) 8(-1.775,0) 9(-1.775,-0.5) 17(1.775,-0.5) 18(1.775,0) 19(1.775,0.5)
  rect 2.159x2.159 smd: 21(0,0)
QFN23G4-G2PH34
  rect 0.305x0.914 smd: 1(1.25,2.051) 2(0.75,2.051) 3(0.25,2.051) 4(-0.25,2.051) 5(-0.75,2.051) 6(-1.25,2.051)
  rect 0.914x0.305 smd: 7(-2.051,1.25)
  rect 0.025x0.025 smd: 8(-2.076,0.75) 9(-2.076,0.25) 10(-2.076,-0.75) 11(-2.076,-1.25)
  rect 0.305x0.864 smd: 12(-1.25,-2.076) 13(-0.75,-2.076) 14(-0.25,-2.076) 15(0.25,-2.076) 16(0.75,-2.076) 17(1.25,-2.076)
  rect 0.864x0.305 smd: 18(2.076,-1.25) 19(2.076,-0.75) 20(2.076,-0.25) 21(2.076,0.25) 22(2.076,0.75) 23(2.076,1.25)
  custom 0.36x0.36 smd: 24(0,0.67)
  custom 0.251x0.251 smd: 25(0,-0.926)
QFN32-G3D55H40
  rect 0.305x0.838 smd: 1(1.75,2.591) 8(-1.75,2.591) 17(-1.75,-2.591) 24(1.75,-2.591)
  rect 0.305x0.94 smd: 2(1.25,2.54) 3(0.751,2.54) 4(0.25,2.54) 5(-0.25,2.54) 6(-0.751,2.54) 7(-1.25,2.54) 18(-1.25,-2.54) 19(-0.751,-2.54) 20(-0.25,-2.54) 21(0.25,-2.54) 22(0.751,-2.54) 23(1.25,-2.54)
  rect 0.838x0.305 smd: 9(-2.591,1.75) 16(-2.591,-1.75) 25(2.591,-1.75) 32(2.591,1.75)
  rect 0.94x0.305 smd: 10(-2.54,1.25) 11(-2.54,0.751) 12(-2.54,0.25) 13(-2.54,-0.25) 14(-2.54,-0.751) 15(-2.54,-1.25) 26(2.54,-1.25) 27(2.54,-0.751) 28(2.54,-0.25) 29(2.54,0.25) 30(2.54,0.751) 31(2.54,1.25)
  rect 3.531x3.531 smd: 33(0,0)
QFN32J4-G2D9-U1H36
  rect 0.203x0.864 smd: 1(1.4,2.085) 2(1,2.085) 3(0.6,2.085) 4(0.2,2.085) 5(-0.2,2.085) 6(-0.6,2.085) 7(-1,2.085) 8(-1.4,2.085) 17(-1.4,-2.085) 18(-1,-2.085) 19(-0.6,-2.085) 20(-0.2,-2.085) 21(0.2,-2.085) 22(0.6,-2.085) 23(1,-2.085) 24(1.4,-2.085)
  rect 0.864x0.203 smd: 9(-2.085,1.4) 10(-2.085,1) 11(-2.085,0.6) 12(-2.085,0.2) 13(-2.085,-0.2) 14(-2.085,-0.6) 15(-2.085,-1) 16(-2.085,-1.4) 25(2.085,-1.4) 26(2.085,-1) 27(2.085,-0.6) 28(2.085,-0.2) 29(2.085,0.2) 30(2.085,0.6) 31(2.085,1) 32(2.085,1.4)
  rect 2.692x2.692 smd: 33(0,0)
QFN40J5-G3D65H32
  rect 0.203x0.94 smd: 1(1.8,2.538) 10(-1.8,2.538) 21(-1.8,-2.538) 30(1.8,-2.538)
  rect 0.203x0.965 smd: 2(1.4,2.526) 3(1,2.526) 4(0.6,2.526) 5(0.2,2.526) 6(-0.2,2.526) 7(-0.6,2.526) 8(-1,2.526) 9(-1.4,2.526) 22(-1.4,-2.526) 23(-1,-2.526) 24(-0.6,-2.526) 25(-0.2,-2.526) 26(0.2,-2.526) 27(0.6,-2.526) 28(1,-2.526) 29(1.4,-2.526)
  rect 0.94x0.203 smd: 11(-2.538,1.8) 20(-2.538,-1.8) 31(2.538,-1.8) 40(2.538,1.8)
  rect 0.965x0.203 smd: 12(-2.526,1.4) 13(-2.526,1) 14(-2.526,0.6) 15(-2.526,0.2) 16(-2.526,-0.2) 17(-2.526,-0.6) 18(-2.526,-1) 19(-2.526,-1.4) 32(2.526,-1.4) 33(2.526,-1) 34(2.526,-0.6) 35(2.526,-0.2) 36(2.526,0.2) 37(2.526,0.6) 38(2.526,1) 39(2.526,1.4)
  rect 3.658x3.658 smd: 41(0,0)
QFN48J6-G465H40
  rect 0.203x0.965 smd: 1(2.2,3.025) 2(1.8,3.025) 3(1.4,3.025) 4(1,3.025) 5(0.6,3.025) 6(0.2,3.025) 7(-0.2,3.025) 8(-0.6,3.025) 9(-1,3.025) 10(-1.4,3.025) 11(-1.8,3.025) 12(-2.2,3.025) 25(-2.2,-3.025) 26(-1.8,-3.025) 27(-1.4,-3.025) 28(-1,-3.025) 29(-0.6,-3.025) 30(-0.2,-3.025) 31(0.2,-3.025) 32(0.6,-3.025) 33(1,-3.025) 34(1.4,-3.025) 35(1.8,-3.025) 36(2.2,-3.025)
  rect 0.965x0.203 smd: 13(-3.025,2.2) 14(-3.025,1.8) 15(-3.025,1.4) 16(-3.025,1) 17(-3.025,0.6) 18(-3.025,0.2) 19(-3.025,-0.2) 20(-3.025,-0.6) 21(-3.025,-1) 22(-3.025,-1.4) 23(-3.025,-1.8) 24(-3.025,-2.2) 37(3.025,-2.2) 38(3.025,-1.8) 39(3.025,-1.4) 40(3.025,-1) 41(3.025,-0.6) 42(3.025,-0.2) 43(3.025,0.2) 44(3.025,0.6) 45(3.025,1) 46(3.025,1.4) 47(3.025,1.8) 48(3.025,2.2)
  rect 4.648x4.648 smd: 49(0,0)
R402
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R402H14
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R402H16
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R603H22
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
R805H24
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
R1206H26
  rect 1.651x1.27 smd: 1(0,1.397) 2(0,-1.397)
R1206H28
  rect 1.651x1.27 smd: 1(0,1.397) 2(0,-1.397)
R3720H40
  rect 4.013x1.041 smd: 1(0,0.867) 2(0,-0.867)
SC70-5H44
  rect 0.406x1.219 smd: 1(0.65,0.826) 2(0,0.826) 3(-0.65,0.826) 4(-0.65,-0.826) 5(0.65,-0.826)
SE341619H241
  rect 1.549x3.531 smd: 1(0,2.461) 2(0,-2.461)
SE361414H241
  rect 1.372x3.607 smd: 1(0,2.499) 2(0,-2.499)
SKT-HDMI22-150077
  rect 0.305x2.007 smd: 1(4.21,3.37) 2(3.71,3.37) 3(3.21,3.37) 4(2.71,3.37) 5(2.21,3.37) 6(1.71,3.37) 7(1.21,3.37) 8(0.71,3.37) 9(0.21,3.37) 10(-0.29,3.37) 11(-0.79,3.37) 12(-1.29,3.37) 13(-1.79,3.37) 14(-2.29,3.37) 15(-2.79,3.37) 16(-3.29,3.37) 17(-3.79,3.37) 18(-4.29,3.37) 19(-4.79,3.37)
  oval 4.928x1.524 hole 4.216x0.813: 20(0,-2.53)
  oval 1.524x4.674 hole 0.813x3.962: 21(-7.25,0) 22(7.25,0)
SKT-USB6-146072
  round 1.346 hole 0.94: 1(-3.5,2.71) 2(-1,2.71) 3(1,2.71) 4(3.5,2.71)
  round 2.718 hole 2.311: 5(-6.57,0) 6(6.57,0)
SKT-USB11-138165-1
  round 1.067 hole 0.711: 1(3.5,3.5) 2(1,3.5) 3(-1,3.5) 4(-3.5,3.5) 5(-4,2) 6(-2,2) 7(0,2) 8(2,2) 9(4,2)
  oval 1.422x3.023 hole 0.711x2.311: 10(-6.4,0) 11(6.4,0)
SKTBGA1151Z753620H369
  round 0.254 hole 3.81 unplated: (-35.21,0) (25.81,18) (25.81,-18)
  round 0.508 smd: A4(-16.187,18.288) A5(-15.273,18.288) AT40(18.931,-14.63) AU1(-18.931,-14.63) AU39(18.016,-15.545) AU40(18.931,-15.545) AV1(-18.931,-15.545) AV2(-18.016,-15.545) AV38(17.102,-16.459) AV39(18.016,-16.459) AW2(-18.016,-16.459) AW3(-17.102,-16.459) AW37(16.187,-17.374) AW38(17.102,-17.374) AY3(-17.102,-17.374) AY4(-16.187,-17.374) B3(-17.102,17.374) B4(-16.187,17.374) B37(16.187,16.459) B38(17.102,16.459) B39(18.016,16.459) C2(-18.016,16.459) C3(-17.102,16.459) C39(18.016,15.545) C40(18.931,15.545) D1(-18.931,15.545) D2(-18.016,15.545) D40(18.931,14.63) E40(18.931,13.716)
  round 0.432 smd: A6(-14.359,18.288) A7(-13.444,18.288) A25(3.015,18.288) A26(3.929,18.288) A27(4.844,18.288) A28(5.758,18.288) A29(6.673,18.288) A30(7.587,18.288) AA5(-15.273,0) AA6(-14.359,0) AA7(-13.444,0) AA8(-12.53,0) AA33(12.53,-0.914) AA34(13.444,-0.914) AA35(14.359,-0.914) AA36(15.273,-0.914) AA37(16.187,-0.914) AA38(17.102,-0.914) AB5(-15.273,-0.914) AB6(-14.359,-0.914) AB7(-13.444,-0.914) AB8(-12.53,-0.914) AB33(12.53,-1.829) AB34(13.444,-1.829) AB35(14.359,-1.829) AB36(15.273,-1.829) AB37(16.187,-1.829) AC5(-15.273,-1.829) AC6(-14.359,-1.829) AC7(-13.444,-1.829) AC8(-12.53,-1.829) AC33(12.53,-2.743) AC34(13.444,-2.743) AC35(14.359,-2.743) AC36(15.273,-2.743) AC37(16.187,-2.743) AD3(-17.102,-2.743) AD4(-16.187,-2.743) AD5(-15.273,-2.743) AD6(-14.359,-2.743) AD7(-13.444,-2.743) AD8(-12.53,-2.743) AD33(12.53,-3.658) AD34(13.444,-3.658) AD35(14.359,-3.658) AD36(15.273,-3.658) AD37(16.187,-3.658) AE3(-17.102,-3.658) AE4(-16.187,-3.658) AE5(-15.273,-3.658) AE6(-14.359,-3.658) AE7(-13.444,-3.658) AE8(-12.53,-3.658) AE33(12.53,-4.572) AE34(13.444,-4.572) AE35(14.359,-4.572) AE36(15.273,-4.572) AE37(16.187,-4.572) AE38(17.102,-4.572) AF4(-16.187,-4.572) AF5(-15.273,-4.572) AF6(-14.359,-4.572) AF7(-13.444,-4.572) AF8(-12.53,-4.572) AF33(12.53,-5.486) AF34(13.444,-5.486) AF35(14.359,-5.486) AF36(15.273,-5.486) AF37(16.187,-5.486) AF38(17.102,-5.486) AG4(-16.187,-5.486) AG5(-15.273,-5.486) AG6(-14.359,-5.486) AG7(-13.444,-5.486) AG8(-12.53,-5.486) AG33(12.53,-6.401) AG34(13.444,-6.401) AG35(14.359,-6.401) AG36(15.273,-6.401) AG37(16.187,-6.401) AG38(17.102,-6.401) AH3(-17.102,-6.401) AH4(-16.187,-6.401) AH5(-15.273,-6.401) AH6(-14.359,-6.401) AH7(-13.444,-6.401) AH8(-12.53,-6.401) AH33(12.53,-7.315) AH34(13.444,-7.315) AH35(14.359,-7.315) AH36(15.273,-7.315) AH37(16.187,-7.315) AH38(17.102,-7.315) AJ3(-17.102,-7.315) AJ4(-16.187,-7.315) AJ5(-15.273,-7.315) AJ6(-14.359,-7.315) AJ7(-13.444,-7.315) AJ8(-12.53,-7.315) AJ9(-11.615,-7.315) AJ11(-7.587,-8.23) AJ12(-6.673,-8.23) AJ13(-5.758,-8.23) AJ14(-4.844,-8.23) AJ15(-3.929,-8.23) AJ16(-3.015,-8.23) AJ17(-2.101,-8.23) AJ18(-1.186,-8.23) AJ19(-0.272,-8.23) AJ20(0.643,-8.23) AJ21(1.557,-8.23) AJ22(2.471,-8.23) AJ23(3.386,-8.23) AJ24(4.3,-8.23) AJ25(5.215,-8.23) AJ26(6.129,-8.23) AJ27(7.043,-8.23) AJ28(7.958,-8.23) AJ29(8.872,-8.23) AJ30(9.787,-8.23) AJ31(10.701,-8.23) AJ32(11.615,-8.23) AJ33(12.53,-8.23) AJ34(13.444,-8.23) AJ35(14.359,-8.23) AJ36(15.273,-8.23) AJ37(16.187,-8.23) AJ38(17.102,-8.23) AK3(-17.102,-8.23) AK4(-16.187,-8.23) AK5(-15.273,-8.23) AK6(-14.359,-8.23) AK7(-13.444,-8.23) AK8(-12.53,-8.23) AK9(-11.615,-8.23) AK10(-10.701,-8.23) AK11(-7.587,-9.144) AK12(-6.673,-9.144) AK13(-5.758,-9.144) AK14(-4.844,-9.144) AK15(-3.929,-9.144) AK16(-3.015,-9.144) AK17(-2.101,-9.144) AK18(-1.186,-9.144) AK19(-0.272,-9.144) AK20(0.643,-9.144) AK21(1.557,-9.144) AK22(2.471,-9.144) AK23(3.386,-9.144) AK24(4.3,-9.144) AK25(5.215,-9.144) AK26(6.129,-9.144) AK27(7.043,-9.144) AK28(7.958,-9.144) AK29(8.872,-9.144) AK30(9.787,-9.144) AK31(10.701,-9.144) AK32(11.615,-9.144) AK33(12.53,-9.144) AK34(13.444,-9.144) AK35(14.359,-9.144) AK36(15.273,-9.144) AK37(16.187,-9.144) AK38(17.102,-9.144) AL3(-17.102,-9.144) AL4(-16.187,-9.144) AL5(-15.273,-9.144) AL6(-14.359,-9.144) AL7(-13.444,-9.144) AL8(-12.53,-9.144) AL9(-11.615,-9.144) AL10(-10.701,-9.144) AL11(-7.587,-10.058) AL12(-6.673,-10.058) AL13(-5.758,-10.058) AL14(-4.844,-10.058) AL15(-3.929,-10.058) AL16(-3.015,-10.058) AL17(-2.101,-10.058) AL18(-1.186,-10.058) AL19(-0.272,-10.058) AL20(0.643,-10.058) AL21(1.557,-10.058) AL22(2.471,-10.058) AL23(3.386,-10.058) AL24(4.3,-10.058) AL25(5.215,-10.058) AL26(6.129,-10.058) AL27(7.043,-10.058) AL28(7.958,-10.058) AL29(8.872,-10.058) AL30(9.787,-10.058) AL31(10.701,-10.058) AL32(11.615,-10.058) AL33(12.53,-10.058) AL34(13.444,-10.058) AL35(14.359,-10.058) AL36(15.273,-10.058) AL37(16.187,-10.058) AL38(17.102,-10.058) AM3(-17.102,-10.058) AM4(-16.187,-10.058) AM5(-15.273,-10.058) AM6(-14.359,-10.058) AM7(-13.444,-10.058) AM8(-12.53,-10.058) AM9(-11.615,-10.058) AM10(-10.701,-10.058) AM11(-7.587,-10.973) AM12(-6.673,-10.973) AM13(-5.758,-10.973) AM14(-4.844,-10.973) AM15(-3.929,-10.973) AM16(-3.015,-10.973) AM17(-2.101,-10.973) AM18(-1.186,-10.973) AM19(-0.272,-10.973) AM20(0.643,-10.973) AM21(1.557,-10.973) AM22(2.471,-10.973) AM23(3.386,-10.973) AM24(4.3,-10.973) AM25(5.215,-10.973) AM26(6.129,-10.973) AM27(7.043,-10.973) AM28(7.958,-10.973) AM29(8.872,-10.973) AM30(9.787,-10.973) AM31(10.701,-10.973) AM32(11.615,-10.973) AM33(12.53,-10.973) AM34(13.444,-10.973) AM35(14.359,-10.973) AM36(15.273,-10.973) AM37(16.187,-10.973) AM38(17.102,-10.973) AN3(-17.102,-10.973) AN4(-16.187,-10.973) AN5(-15.273,-10.973) AN6(-14.359,-10.973) AN7(-13.444,-10.973) AN8(-12.53,-10.973) AN9(-11.615,-10.973) AN10(-10.701,-10.973) AN11(-7.587,-11.887) AN12(-6.673,-11.887) AN13(-5.758,-11.887) AN14(-4.844,-11.887) AN15(-3.929,-11.887) AN16(-3.015,-11.887) AN17(-2.101,-11.887) AN18(-1.186,-11.887) AN19(-0.272,-11.887) AN20(0.643,-11.887) AN21(1.557,-11.887) AN22(2.471,-11.887) AN23(3.386,-11.887) AN24(4.3,-11.887) AN25(5.215,-11.887) AN26(6.129,-11.887) AN27(7.043,-11.887) AN28(7.958,-11.887) AN29(8.872,-11.887) AN30(9.787,-11.887) AN31(10.701,-11.887) AN32(11.615,-11.887) AN33(12.53,-11.887) AN34(13.444,-11.887) AN35(14.359,-11.887) AN36(15.273,-11.887) AN37(16.187,-11.887) AN38(17.102,-11.887) AP3(-17.102,-11.887) AP4(-16.187,-11.887) AP5(-15.273,-11.887) AP6(-14.359,-11.887) AP7(-13.444,-11.887) AP8(-12.53,-11.887) AP9(-11.615,-11.887) AP10(-10.701,-11.887) AP11(-7.587,-12.802) AP12(-6.673,-12.802) AP13(-5.758,-12.802) AP14(-4.844,-12.802) AP15(-3.929,-12.802) AP16(-3.015,-12.802) AP17(-2.101,-12.802) AP18(-1.186,-12.802) AP19(-0.272,-12.802) AP20(0.643,-12.802) AP21(1.557,-12.802) AP22(2.471,-12.802) AP23(3.386,-12.802) AP24(4.3,-12.802) AP25(5.215,-12.802) AP26(6.129,-12.802) AP27(7.043,-12.802) AP28(7.958,-12.802) AP29(8.872,-12.802) AP30(9.787,-12.802) AP31(10.701,-12.802) AP32(11.615,-12.802) AP33(12.53,-12.802) AP34(13.444,-12.802) AP35(14.359,-12.802) AP36(15.273,-12.802) AP37(16.187,-12.802) AP38(17.102,-12.802) AR3(-17.102,-12.802) AR4(-16.187,-12.802) AR5(-15.273,-12.802) AR6(-14.359,-12.802) AR7(-13.444,-12.802) AR8(-12.53,-12.802) AR9(-11.615,-12.802) AR10(-10.701,-12.802) AR11(-7.587,-13.716) AR12(-6.673,-13.716) AR13(-5.758,-13.716) AR14(-4.844,-13.716) AR15(-3.929,-13.716) AR16(-3.015,-13.716) AR17(-2.101,-13.716) AR18(-1.186,-13.716) AR19(-0.272,-13.716) AR20(0.643,-13.716) AR21(1.557,-13.716) AR22(2.471,-13.716) AR23(3.386,-13.716) AR24(4.3,-13.716) AR25(5.215,-13.716) AR26(6.129,-13.716) AR27(7.043,-13.716) AR28(7.958,-13.716) AR29(8.872,-13.716) AR30(9.787,-13.716) AR31(10.701,-13.716) AR32(11.615,-13.716) AR33(12.53,-13.716) AR34(13.444,-13.716) AR35(14.359,-13.716) AR36(15.273,-13.716) AR37(16.187,-13.716) AR38(17.102,-13.716) AT3(-17.102,-13.716) AT4(-16.187,-13.716) AT5(-15.273,-13.716) AT6(-14.359,-13.716) AT7(-13.444,-13.716) AT8(-12.53,-13.716) AT9(-11.615,-13.716) AT10(-10.701,-13.716) AT11(-7.587,-14.63) AT12(-6.673,-14.63) AT13(-5.758,-14.63) AT14(-4.844,-14.63) AT15(-3.929,-14.63) AT16(-3.015,-14.63) AT17(-2.101,-14.63) AT18(-1.186,-14.63) AT19(-0.272,-14.63) AT20(0.643,-14.63) AT21(1.557,-14.63) AT22(2.471,-14.63) AT23(3.386,-14.63) AT24(4.3,-14.63) AT25(5.215,-14.63) AT26(6.129,-14.63) AT27(7.043,-14.63) AT28(7.958,-14.63) AT29(8.872,-14.63) AT30(9.787,-14.63) AT31(10.701,-14.63) AT32(11.615,-14.63) AT33(12.53,-14.63) AT34(13.444,-14.63) AT35(14.359,-14.63) AT36(15.273,-14.63) AT37(16.187,-14.63) AT38(17.102,-14.63) AU3(-17.102,-14.63) AU4(-16.187,-14.63) AU5(-15.273,-14.63) AU6(-14.359,-14.63) AU7(-13.444,-14.63) AU8(-12.53,-14.63) AU9(-11.615,-14.63) AU10(-10.701,-14.63) AU11(-7.587,-15.545) AU12(-6.673,-15.545) AU13(-5.758,-15.545) AU14(-4.844,-15.545) AU15(-3.929,-15.545) AU16(-3.015,-15.545) AU17(-2.101,-15.545) AU18(-1.186,-15.545) AU19(-0.272,-15.545) AU20(0.643,-15.545) AU21(1.557,-15.545) AU24(4.3,-15.545) AU25(5.215,-15.545) AU26(6.129,-15.545) AU27(7.043,-15.545) AU28(7.958,-15.545) AU29(8.872,-15.545) AU30(9.787,-15.545) AU31(10.701,-15.545) AU32(11.615,-15.545) AU33(12.53,-15.545) AU34(13.444,-15.545) AU35(14.359,-15.545) AU36(15.273,-15.545) AU37(16.187,-15.545) AU38(17.102,-15.545) AV3(-17.102,-15.545) AV4(-16.187,-15.545) AV5(-15.273,-15.545) AV6(-14.359,-15.545) AV7(-13.444,-15.545) AV8(-12.53,-15.545) AV9(-11.615,-15.545) AV10(-10.701,-15.545) AV11(-7.587,-16.459) AV12(-6.673,-16.459) AV13(-5.758,-16.459) AV14(-4.844,-16.459) AV24(4.3,-16.459) AV25(5.215,-16.459) AV28(7.958,-16.459) AV29(8.872,-16.459) AV37(16.187,-16.459) AW4(-16.187,-16.459) AW9(-11.615,-16.459) AW10(-10.701,-16.459) AW11(-7.587,-17.374) AW12(-6.673,-17.374) AW13(-5.758,-17.374) AW14(-4.844,-17.374) AY10(-10.701,-17.374) B5(-15.273,17.374) B6(-14.359,17.374) B7(-13.444,17.374) B25(3.015,17.374) B26(3.929,17.374) B27(4.844,17.374) B28(5.758,17.374) B29(6.673,17.374) B30(7.587,17.374) B31(10.701,16.459) B32(11.615,16.459) B33(12.53,16.459) B34(13.444,16.459) B35(14.359,16.459) B36(15.273,16.459) C4(-16.187,16.459) C5(-15.273,16.459) C6(-14.359,16.459) C7(-13.444,16.459) C8(-12.53,16.459) C9(-11.615,16.459) C12(-8.872,16.459) C13(-7.958,16.459) C14(-7.043,16.459) C15(-6.129,16.459) C16(-5.215,16.459) C17(-4.3,16.459) C25(3.015,16.459) C26(3.929,16.459) C27(4.844,16.459) C28(5.758,16.459) C29(6.673,16.459) C30(7.587,16.459) C31(10.701,15.545) C32(11.615,15.545) C33(12.53,15.545) C34(13.444,15.545) C35(14.359,15.545) C36(15.273,15.545) C37(16.187,15.545) C38(17.102,15.545) D3(-17.102,15.545) D4(-16.187,15.545) D5(-15.273,15.545) D6(-14.359,15.545) D7(-13.444,15.545) D8(-12.53,15.545) D9(-11.615,15.545) D10(-10.701,15.545) D11(-9.787,15.545) D12(-8.872,15.545) D13(-7.958,15.545) D14(-7.043,15.545) D15(-6.129,15.545) D16(-5.215,15.545) D17(-4.3,15.545) D18(-3.386,15.545) D24(2.101,15.545) D25(3.015,15.545) D26(3.929,15.545) D27(4.844,15.545) D28(5.758,15.545) D29(6.673,15.545) D30(7.587,15.545) D31(10.701,14.63) D32(11.615,14.63) D33(12.53,14.63) D34(13.444,14.63) D35(14.359,14.63) D36(15.273,14.63) D37(16.187,14.63) D38(17.102,14.63) D39(18.016,14.63) E3(-17.102,14.63) E4(-16.187,14.63) E5(-15.273,14.63) E6(-14.359,14.63) E7(-13.444,14.63) E8(-12.53,14.63) E9(-11.615,14.63) E10(-10.701,14.63) E11(-9.787,14.63) E12(-8.872,14.63) E13(-7.958,14.63) E14(-7.043,14.63) E15(-6.129,14.63) E16(-5.215,14.63) E17(-4.3,14.63) E18(-3.386,14.63) E19(-2.471,14.63) E21(-0.643,14.63) E23(1.186,14.63) E24(2.101,14.63) E25(3.015,14.63) E26(3.929,14.63) E27(4.844,14.63) E28(5.758,14.63) E29(6.673,14.63) E30(7.587,14.63) E31(10.701,13.716) E32(11.615,13.716) E33(12.53,13.716) E34(13.444,13.716) E35(14.359,13.716) E36(15.273,13.716) E37(16.187,13.716) E38(17.102,13.716) E39(18.016,13.716) F4(-16.187,13.716) F5(-15.273,13.716) F6(-14.359,13.716) F7(-13.444,13.716) F8(-12.53,13.716) F9(-11.615,13.716) F10(-10.701,13.716) F11(-9.787,13.716) F12(-8.872,13.716) F13(-7.958,13.716) F14(-7.043,13.716) F15(-6.129,13.716) F16(-5.215,13.716) F17(-4.3,13.716) F18(-3.386,13.716) F19(-2.471,13.716) F20(-1.557,13.716) F21(-0.643,13.716) F22(0.272,13.716) F23(1.186,13.716) F24(2.101,13.716) F25(3.015,13.716) F26(3.929,13.716) F27(4.844,13.716) F28(5.758,13.716) F29(6.673,13.716) F30(7.587,13.716) F31(10.701,12.802) F32(11.615,12.802) F33(12.53,12.802) F34(13.444,12.802) F35(14.359,12.802) F36(15.273,12.802) F37(16.187,12.802) F38(17.102,12.802) F39(18.016,12.802) F40(18.931,12.802) G3(-17.102,12.802) G4(-16.187,12.802) G5(-15.273,12.802) G6(-14.359,12.802) G7(-13.444,12.802) G8(-12.53,12.802) G9(-11.615,12.802) G10(-10.701,12.802) G11(-9.787,12.802) G12(-8.872,12.802) G13(-7.958,12.802) G14(-7.043,12.802) G15(-6.129,12.802) G16(-5.215,12.802) G17(-4.3,12.802) G18(-3.386,12.802) G19(-2.471,12.802) G20(-1.557,12.802) G21(-0.643,12.802) G22(0.272,12.802) G23(1.186,12.802) G24(2.101,12.802) G25(3.015,12.802) G26(3.929,12.802) G27(4.844,12.802) G28(5.758,12.802) G29(6.673,12.802) G30(7.587,12.802) G31(10.701,11.887) G32(11.615,11.887) G33(12.53,11.887) G34(13.444,11.887) G35(14.359,11.887) G36(15.273,11.887) G37(16.187,11.887) G38(17.102,11.887) G39(18.016,11.887) G40(18.931,11.887) H4(-16.187,11.887) H5(-15.273,11.887) H6(-14.359,11.887) H7(-13.444,11.887) H8(-12.53,11.887) H9(-11.615,11.887) H10(-10.701,11.887) H11(-9.787,11.887) H12(-8.872,11.887) H13(-7.958,11.887) H14(-7.043,11.887) H15(-6.129,11.887) H16(-5.215,11.887) H17(-4.3,11.887) H18(-3.386,11.887) H19(-2.471,11.887) H20(-1.557,11.887) H21(-0.643,11.887) H22(0.272,11.887) H23(1.186,11.887) H24(2.101,11.887) H25(3.015,11.887) H26(3.929,11.887) H27(4.844,11.887) H28(5.758,11.887) H29(6.673,11.887) H30(7.587,11.887) H31(10.701,10.973) H32(11.615,10.973) H33(12.53,10.973) H34(13.444,10.973) H35(14.359,10.973) H36(15.273,10.973) H37(16.187,10.973) H38(17.102,10.973) H39(18.016,10.973) H40(18.931,10.973) J3(-17.102,10.973) J4(-16.187,10.973) J5(-15.273,10.973) J6(-14.359,10.973) J7(-13.444,10.973) J8(-12.53,10.973) J9(-11.615,10.973) J10(-10.701,10.973) J11(-9.787,10.973) J12(-8.872,10.973) J13(-7.958,10.973) J14(-7.043,10.973) J15(-6.129,10.973) J16(-5.215,10.973) J17(-4.3,10.973) J18(-3.386,10.973) J19(-2.471,10.973) J20(-1.557,10.973) J21(-0.643,10.973) J22(0.272,10.973) J23(1.186,10.973) J24(2.101,10.973) J25(3.015,10.973) J26(3.929,10.973) J27(4.844,10.973) J28(5.758,10.973) J29(6.673,10.973) J30(7.587,10.973) J31(10.701,10.058) J32(11.615,10.058) J33(12.53,10.058) J34(13.444,10.058) J35(14.359,10.058) J36(15.273,10.058) J37(16.187,10.058) J38(17.102,10.058) J39(18.016,10.058) J40(18.931,10.058) K4(-16.187,10.058) K5(-15.273,10.058) K6(-14.359,10.058) K7(-13.444,10.058) K8(-12.53,10.058) K9(-11.615,10.058) K10(-10.701,10.058) K11(-9.787,10.058) K12(-8.872,10.058) K13(-7.958,10.058) K14(-7.043,10.058) K15(-6.129,10.058) K16(-5.215,10.058) K17(-4.3,10.058) K18(-3.386,10.058) K19(-2.471,10.058) K20(-1.557,10.058) K21(-0.643,10.058) K22(0.272,10.058) K23(1.186,10.058) K24(2.101,10.058) K25(3.015,10.058) K26(3.929,10.058) K27(4.844,10.058) K28(5.758,10.058) K29(6.673,10.058) K30(7.587,10.058) K31(10.701,9.144) K32(11.615,9.144) K33(12.53,9.144) K34(13.444,9.144) K35(14.359,9.144) K36(15.273,9.144) K37(16.187,9.144) K38(17.102,9.144) K39(18.016,9.144) K40(18.931,9.144) L3(-17.102,9.144) L4(-16.187,9.144) L5(-15.273,9.144) L6(-14.359,9.144) L7(-13.444,9.144) L8(-12.53,9.144) L9(-11.615,9.144) L10(-10.701,9.144) L11(-9.787,9.144) L12(-8.872,9.144) L13(-7.958,9.144) L14(-7.043,9.144) L15(-6.129,9.144) L16(-5.215,9.144) L17(-4.3,9.144) L18(-3.386,9.144) L19(-2.471,9.144) L20(-1.557,9.144) L21(-0.643,9.144) L22(0.272,9.144) L23(1.186,9.144) L24(2.101,9.144) L25(3.015,9.144) L26(3.929,9.144) L27(4.844,9.144) L28(5.758,9.144) L29(6.673,9.144) L30(7.587,9.144) L31(10.701,8.23) L32(11.615,8.23) L33(12.53,8.23) L34(13.444,8.23) L35(14.359,8.23) L36(15.273,8.23) L37(16.187,8.23) L38(17.102,8.23) L39(18.016,8.23) L40(18.931,8.23) M4(-16.187,8.23) M5(-15.273,8.23) M6(-14.359,8.23) M7(-13.444,8.23) M8(-12.53,8.23) M9(-11.615,8.23) M10(-10.701,8.23) M11(-9.787,8.23) M12(-8.872,8.23) M13(-7.958,8.23) M14(-7.043,8.23) M15(-6.129,8.23) M16(-5.215,8.23) M17(-4.3,8.23) M18(-3.386,8.23) M19(-2.471,8.23) M20(-1.557,8.23) M21(-0.643,8.23) M22(0.272,8.23) M23(1.186,8.23) M24(2.101,8.23) M25(3.015,8.23) M26(3.929,8.23) M27(4.844,8.23) M28(5.758,8.23) M29(6.673,8.23) M30(7.587,8.23) M32(11.615,7.315) M33(12.53,7.315) M34(13.444,7.315) M35(14.359,7.315) M36(15.273,7.315) M37(16.187,7.315) M38(17.102,7.315) M39(18.016,7.315) M40(18.931,7.315) N3(-17.102,7.315) N4(-16.187,7.315) N5(-15.273,7.315) N6(-14.359,7.315) N7(-13.444,7.315) N8(-12.53,7.315) N33(12.53,6.401) N34(13.444,6.401) N35(14.359,6.401) N36(15.273,6.401) N37(16.187,6.401) N38(17.102,6.401) N39(18.016,6.401) N40(18.931,6.401) P4(-16.187,6.401) P5(-15.273,6.401) P6(-14.359,6.401) P7(-13.444,6.401) P8(-12.53,6.401) P33(12.53,5.486) P34(13.444,5.486) P35(14.359,5.486) P36(15.273,5.486) P37(16.187,5.486) P38(17.102,5.486) P39(18.016,5.486) P40(18.931,5.486) R3(-17.102,5.486) R4(-16.187,5.486) R5(-15.273,5.486) R6(-14.359,5.486) R7(-13.444,5.486) R8(-12.53,5.486) R33(12.53,4.572) R34(13.444,4.572) R35(14.359,4.572) R36(15.273,4.572) R37(16.187,4.572) R38(17.102,4.572) R39(18.016,4.572) R40(18.931,4.572) T4(-16.187,4.572) T5(-15.273,4.572) T6(-14.359,4.572) T7(-13.444,4.572) T8(-12.53,4.572) T33(12.53,3.658) T34(13.444,3.658) T35(14.359,3.658) T36(15.273,3.658) T37(16.187,3.658) T38(17.102,3.658) T39(18.016,3.658) T40(18.931,3.658) U4(-16.187,3.658) U5(-15.273,3.658) U6(-14.359,3.658) U7(-13.444,3.658) U8(-12.53,3.658) U33(12.53,2.743) U34(13.444,2.743) U35(14.359,2.743) U36(15.273,2.743) U37(16.187,2.743) U38(17.102,2.743) U39(18.016,2.743) U40(18.931,2.743) V4(-16.187,2.743) V5(-15.273,2.743) V6(-14.359,2.743) V7(-13.444,2.743) V8(-12.53,2.743) V33(12.53,1.829) V34(13.444,1.829) V35(14.359,1.829) V36(15.273,1.829) V37(16.187,1.829) V38(17.102,1.829) V39(18.016,1.829) V40(18.931,1.829) W4(-16.187,1.829) W5(-15.273,1.829) W6(-14.359,1.829) W7(-13.444,1.829) W8(-12.53,1.829) W33(12.53,0.914) W34(13.444,0.914) W35(14.359,0.914) W36(15.273,0.914) W37(16.187,0.914) W38(17.102,0.914) Y5(-15.273,0.914) Y6(-14.359,0.914) Y7(-13.444,0.914) Y8(-12.53,0.914) Y33(12.53,0) Y34(13.444,0) Y35(14.359,0) Y36(15.273,0) Y37(16.187,0) Y38(17.102,0)
  oval 0.356x0.457 smd: A11(-9.787,18.288) A12(-8.872,18.288) A13(-7.958,18.288) A14(-7.043,18.288) A15(-6.129,18.288) A16(-5.215,18.288) A17(-4.3,18.288) A18(-3.386,18.288) A23(1.186,18.288) A24(2.101,18.288) AU22(2.471,-15.545) AU23(3.386,-15.545) AV15(-3.929,-16.459) AV16(-3.015,-16.459) AV17(-2.101,-16.459) AV18(-1.186,-16.459) AV19(-0.272,-16.459) AV20(0.643,-16.459) AV21(1.557,-16.459) AV22(2.471,-16.459) AV23(3.386,-16.459) AV26(6.129,-16.459) AV27(7.043,-16.459) AV30(9.787,-16.459) AV31(10.701,-16.459) AV32(11.615,-16.459) AV33(12.53,-16.459) AV34(13.444,-16.459) AV35(14.359,-16.459) AV36(15.273,-16.459) AW5(-15.273,-16.459) AW6(-14.359,-16.459) AW7(-13.444,-16.459) AW8(-12.53,-16.459) AW15(-3.929,-17.374) AW16(-3.015,-17.374) AW17(-2.101,-17.374) AW18(-1.186,-17.374) AW23(3.386,-17.374) AW24(4.3,-17.374) AW25(5.215,-17.374) AW26(6.129,-17.374) AW27(7.043,-17.374) AW28(7.958,-17.374) AW29(8.872,-17.374) AW30(9.787,-17.374) AW31(10.701,-17.374) AW32(11.615,-17.374) AW33(12.53,-17.374) AW34(13.444,-17.374) AW35(14.359,-17.374) AW36(15.273,-17.374) AY5(-15.273,-17.374) AY6(-14.359,-17.374) AY7(-13.444,-17.374) AY8(-12.53,-17.374) AY9(-11.615,-17.374) AY11(-7.587,-18.288) AY12(-6.673,-18.288) AY13(-5.758,-18.288) AY14(-4.844,-18.288) AY15(-3.929,-18.288) AY16(-3.015,-18.288) AY17(-2.101,-18.288) AY18(-1.186,-18.288) AY23(3.386,-18.288) AY24(4.3,-18.288) AY25(5.215,-18.288) AY26(6.129,-18.288) AY27(7.043,-18.288) AY28(7.958,-18.288) AY29(8.872,-18.288) AY30(9.787,-18.288) AY31(10.701,-18.288) B8(-12.53,17.374) B9(-11.615,17.374) B10(-10.701,17.374) B11(-9.787,17.374) B12(-8.872,17.374) B13(-7.958,17.374) B14(-7.043,17.374) B15(-6.129,17.374) B16(-5.215,17.374) B17(-4.3,17.374) B18(-3.386,17.374) B23(1.186,17.374) B24(2.101,17.374) C10(-10.701,16.459) C11(-9.787,16.459) C18(-3.386,16.459) C19(-2.471,16.459) C20(-1.557,16.459) C21(-0.643,16.459) C22(0.272,16.459) C23(1.186,16.459) C24(2.101,16.459) D19(-2.471,15.545) D20(-1.557,15.545) D21(-0.643,15.545) D22(0.272,15.545) D23(1.186,15.545) E20(-1.557,14.63) E22(0.272,14.63)
  oval 0.457x0.356 smd: AA3(-17.102,0) AA4(-16.187,0) AB3(-17.102,-0.914) AB4(-16.187,-0.914) AB38(17.102,-1.829) AB39(18.016,-1.829) AB40(18.931,-1.829) AC1(-18.931,-1.829) AC2(-18.016,-1.829) AC3(-17.102,-1.829) AC4(-16.187,-1.829) AC38(17.102,-2.743) AC39(18.016,-2.743) AC40(18.931,-2.743) AD1(-18.931,-2.743) AD2(-18.016,-2.743) AD38(17.102,-3.658) AD39(18.016,-3.658) AD40(18.931,-3.658) AE1(-18.931,-3.658) AE2(-18.016,-3.658) AE39(18.016,-4.572) AE40(18.931,-4.572) AF1(-18.931,-4.572) AF2(-18.016,-4.572) AF3(-17.102,-4.572) AF39(18.016,-5.486) AF40(18.931,-5.486) AG1(-18.931,-5.486) AG2(-18.016,-5.486) AG3(-17.102,-5.486) AG39(18.016,-6.401) AG40(18.931,-6.401) AH1(-18.931,-6.401) AH2(-18.016,-6.401) AH39(18.016,-7.315) AH40(18.931,-7.315) AJ1(-18.931,-7.315) AJ2(-18.016,-7.315) AJ39(18.016,-8.23) AJ40(18.931,-8.23) AK1(-18.931,-8.23) AK2(-18.016,-8.23) AK39(18.016,-9.144) AK40(18.931,-9.144) AL1(-18.931,-9.144) AL2(-18.016,-9.144) AL39(18.016,-10.058) AL40(18.931,-10.058) AM1(-18.931,-10.058) AM2(-18.016,-10.058) AM39(18.016,-10.973) AM40(18.931,-10.973) AN1(-18.931,-10.973) AN2(-18.016,-10.973) AN39(18.016,-11.887) AN40(18.931,-11.887) AP1(-18.931,-11.887) AP2(-18.016,-11.887) AP39(18.016,-12.802) AP40(18.931,-12.802) AR1(-18.931,-12.802) AR2(-18.016,-12.802) AR39(18.016,-13.716) AR40(18.931,-13.716) AT1(-18.931,-13.716) AT2(-18.016,-13.716) AT39(18.016,-14.63) AU2(-18.016,-14.63) E1(-18.931,14.63) E2(-18.016,14.63) F1(-18.931,13.716) F2(-18.016,13.716) F3(-17.102,13.716) G1(-18.931,12.802) G2(-18.016,12.802) H1(-18.931,11.887) H2(-18.016,11.887) H3(-17.102,11.887) J1(-18.931,10.973) J2(-18.016,10.973) K1(-18.931,10.058) K2(-18.016,10.058) K3(-17.102,10.058) L1(-18.931,9.144) L2(-18.016,9.144) M1(-18.931,8.23) M2(-18.016,8.23) M3(-17.102,8.23) N1(-18.931,7.315) N2(-18.016,7.315) P1(-18.931,6.401) P2(-18.016,6.401) P3(-17.102,6.401) R1(-18.931,5.486) R2(-18.016,5.486) T1(-18.931,4.572) T2(-18.016,4.572) T3(-17.102,4.572) U1(-18.931,3.658) U2(-18.016,3.658) U3(-17.102,3.658) V1(-18.931,2.743) V2(-18.016,2.743) V3(-17.102,2.743) W1(-18.931,1.829) W2(-18.016,1.829) W3(-17.102,1.829) Y3(-17.102,0.914) Y4(-16.187,0.914)
SLP2510P8-1H22
  rect 0.305x0.762 smd: 1(-1,-0.5) 5(1,-0.5) 6(1,0.5) 10(-1,0.5)
  rect 0.203x0.762 smd: 2(-0.5,-0.5) 4(0.5,-0.5) 7(0.5,0.5) 9(-0.5,0.5)
  rect 0.406x0.762 smd: 3(0,-0.5) 8(0,0.5)
SMD49-6914-0403H56
  rect 1.168x0.559 smd: 1(-3.38,-0.427) 2(3.38,-0.427) 3(3.38,0.427) 4(-3.38,0.427)
SMD-ARES4H18
  rect 0.356x0.66 smd: 1(-0.325,-0.599) 2(0.325,-0.599) 3(0.325,0.599) 4(-0.325,0.599)
SOD323AKH38
  rect 0.559x1.016 smd: A(0,1.143) K(0,-1.143)
SOD323AKH40
  rect 0.559x1.016 smd: A(0,1.143) K(0,-1.143)
SOD523AKH28
  rect 0.559x1.016 smd: A(0,0.762) K(0,-0.762)
SOD882-10D6-1H20
  custom 0.114x0.114 smd: 1(0,0.445) 2(0,-0.445)
SOIC8-1H86
  rect 0.635x1.651 smd: 1(-1.905,-3.493) 2(-0.635,-3.493) 3(0.635,-3.493) 4(1.905,-3.493) 5(1.905,3.493) 6(0.635,3.493) 7(-0.635,3.493) 8(-1.905,3.493)
SOIC8-G2D3H70
  rect 0.635x1.651 smd: 1(-1.905,-2.553) 2(-0.635,-2.553) 3(0.635,-2.553) 4(1.905,-2.553) 5(1.905,2.553) 6(0.635,2.553) 7(-0.635,2.553) 8(-1.905,2.553)
  rect 2.311x2.311 smd: 9(0,0)
SOIC8-G3530H63
  rect 0.635x1.651 smd: 1(-1.905,-2.555) 2(-0.635,-2.555) 3(0.635,-2.555) 4(1.905,-2.555) 5(1.905,2.555) 6(0.635,2.555) 7(-0.635,2.555) 8(-1.905,2.555)
  rect 3.505x2.997 smd: 9(0,0)
SOIC8H69
  rect 0.635x1.651 smd: 1(-1.905,-2.54) 2(-0.635,-2.54) 3(0.635,-2.54) 4(1.905,-2.54) 5(1.905,2.54) 6(0.635,2.54) 7(-0.635,2.54) 8(-1.905,2.54)
SON14J3020-G2610H34
  rect 0.025x0.025 smd: 1(1.2,1.105) 6(-0.8,1.105) 9(-0.8,-1.105) 14(1.2,-1.105)
  custom 0.151x0.151 smd: 2(0.8,1.105) 7(-1.2,1.105) 8(-1.2,-1.105) 13(0.8,-1.105)
  rect 0.203x0.813 smd: 3(0.4,1.105) 4(0,1.105) 5(-0.4,1.105) 10(-0.4,-1.105) 11(0,-1.105) 12(0.4,-1.105)
  rect 2.591x0.889 smd: 15(0,0)
SOT23-2D4-312H46
  custom 0.191x0.191 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT23-2D4-312H48
  custom 0.191x0.191 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT23CBE2D4H44
  custom 0.191x0.191 smd: B(-0.984,-0.953) C(0,0.953) E(0.984,-0.953)
SOT23CBE2D4H46
  custom 0.191x0.191 smd: B(-0.984,-0.953) C(0,0.953) E(0.984,-0.953)
SOT23DGS2D4H44
  custom 0.191x0.191 smd: D(0,0.953) G(-0.984,-0.953) S(0.984,-0.953)
SOT23DGS2D4H48
  custom 0.191x0.191 smd: D(0,0.953) G(-0.984,-0.953) S(0.984,-0.953)
SOT23DGS2D8H50
  custom 0.254x0.254 smd: D(0,1.118) G(-1.016,-1.118) S(1.016,-1.118)
SOT-6-1H50
  rect 0.584x1.219 smd: 1(-0.95,-1.194) 2(0,-1.194) 3(0.95,-1.194) 4(0.95,1.194) 5(0,1.194) 6(-0.95,1.194)
SOT-6H44
  rect 0.584x1.016 smd: 1(-0.953,-1.346) 2(0,-1.346) 3(0.953,-1.346) 4(0.953,1.346) 5(0,1.346) 6(-0.953,1.346)
SOT-6H58
  rect 0.584x1.016 smd: 1(-0.953,-1.346) 2(0,-1.346) 3(0.953,-1.346) 4(0.953,1.346) 5(0,1.346) 6(-0.953,1.346)
SOT-23-9H44
  custom 0.178x0.178 smd: 1(-0.95,-0.999) 2(0.95,-0.999) 3(0,0.999)
SOT-89-4541H63
  rect 0.864x1.753 smd: 1(-1.5,0) 3(1.5,0)
  custom 0.476x0.476 smd: 2(0,0)
SOT-223H71
  rect 1.27x2.032 smd: 1(-2.286,0) 3(2.286,0)
  custom 0.889x0.889 smd: 2(0,0)
SOT-363H44
  rect 0.406x1.016 smd: 1(-0.65,-0.94) 2(0,-0.94) 3(0.65,-0.94) 4(0.65,0.94) 5(0,0.94) 6(-0.65,0.94)
SPR10637H367
  rect 10.287x3.404 smd: 1(-2.146,0)
STF256R109H99
  round 6.502 hole 2.769: 1(0,0)
TPAD24
  round 0.61 smd: 1(0,0)
TPAD28
  round 0.711 smd: 1(0,0)
TQFP128H63
  rect 0.305x1.778 smd: 1(9.249,7.62) 2(8.75,7.62) 3(8.25,7.62) 4(7.75,7.62) 5(7.25,7.62) 6(6.75,7.62) 7(6.25,7.62) 8(5.751,7.62) 9(5.25,7.62) 10(4.75,7.62) 11(4.249,7.62) 12(3.75,7.62) 13(3.25,7.62) 14(2.75,7.62) 15(2.25,7.62) 16(1.75,7.62) 17(1.25,7.62) 18(0.751,7.62) 19(0.25,7.62) 20(-0.25,7.62) 21(-0.751,7.62) 22(-1.25,7.62) 23(-1.75,7.62) 24(-2.25,7.62) 25(-2.75,7.62) 26(-3.25,7.62) 27(-3.75,7.62) 28(-4.249,7.62) 29(-4.75,7.62) 30(-5.25,7.62) 31(-5.751,7.62) 32(-6.25,7.62) 33(-6.75,7.62) 34(-7.25,7.62) 35(-7.75,7.62) 36(-8.25,7.62) 37(-8.75,7.62) 38(-9.249,7.62) 65(-9.249,-7.62) 66(-8.75,-7.62) 67(-8.25,-7.62) 68(-7.75,-7.62) 69(-7.25,-7.62) 70(-6.75,-7.62) 71(-6.25,-7.62) 72(-5.751,-7.62) 73(-5.25,-7.62) 74(-4.75,-7.62) 75(-4.249,-7.62) 76(-3.75,-7.62) 77(-3.25,-7.62) 78(-2.75,-7.62) 79(-2.25,-7.62) 80(-1.75,-7.62) 81(-1.25,-7.62) 82(-0.751,-7.62) 83(-0.25,-7.62) 84(0.25,-7.62) 85(0.751,-7.62) 86(1.25,-7.62) 87(1.75,-7.62) 88(2.25,-7.62) 89(2.75,-7.62) 90(3.25,-7.62) 91(3.75,-7.62) 92(4.249,-7.62) 93(4.75,-7.62) 94(5.25,-7.62) 95(5.751,-7.62) 96(6.25,-7.62) 97(6.75,-7.62) 98(7.25,-7.62) 99(7.75,-7.62) 100(8.25,-7.62) 101(8.75,-7.62) 102(9.249,-7.62)
  rect 1.778x0.305 smd: 39(-10.617,6.25) 40(-10.617,5.751) 41(-10.617,5.25) 42(-10.617,4.75) 43(-10.617,4.249) 44(-10.617,3.75) 45(-10.617,3.25) 46(-10.617,2.75) 47(-10.617,2.25) 48(-10.617,1.75) 49(-10.617,1.25) 50(-10.617,0.751) 51(-10.617,0.25) 52(-10.617,-0.25) 53(-10.617,-0.751) 54(-10.617,-1.25) 55(-10.617,-1.75) 56(-10.617,-2.25) 57(-10.617,-2.75) 58(-10.617,-3.25) 59(-10.617,-3.75) 60(-10.617,-4.249) 61(-10.617,-4.75) 62(-10.617,-5.25) 63(-10.617,-5.751) 64(-10.617,-6.25) 103(10.617,-6.25) 104(10.617,-5.751) 105(10.617,-5.25) 106(10.617,-4.75) 107(10.617,-4.249) 108(10.617,-3.75) 109(10.617,-3.25) 110(10.617,-2.75) 111(10.617,-2.25) 112(10.617,-1.75) 113(10.617,-1.25) 114(10.617,-0.751) 115(10.617,-0.25) 116(10.617,0.25) 117(10.617,0.751) 118(10.617,1.25) 119(10.617,1.75) 120(10.617,2.25) 121(10.617,2.75) 122(10.617,3.25) 123(10.617,3.75) 124(10.617,4.249) 125(10.617,4.75) 126(10.617,5.25) 127(10.617,5.751) 128(10.617,6.25)
TVS5436-1121H105
  rect 2.337x2.007 smd: 1(0,2.299) 2(0,-2.299)
unnamed
  round 0.254 hole 3.404 unplated: (0,0)
XFORM24Z151100H160
  rect 0.635x2.032 smd: 1(-5.445,-4.623) 2(-4.455,-4.623) 3(-3.465,-4.623) 4(-2.475,-4.623) 5(-1.485,-4.623) 6(-0.495,-4.623) 7(0.495,-4.623) 8(1.485,-4.623) 9(2.475,-4.623) 10(3.465,-4.623) 11(4.455,-4.623) 12(5.445,-4.623) 13(5.445,4.623) 14(4.455,4.623) 15(3.465,4.623) 16(2.475,4.623) 17(1.485,4.623) 18(0.495,4.623) 19(-0.495,4.623) 20(-1.485,4.623) 21(-2.475,4.623) 22(-3.465,4.623) 23(-4.455,4.623) 24(-5.445,4.623)

## Nets
3V3_VDD33: C492.2 C6705.1 C6724.1 C12378.1 C12379.1 GPU1.G8 GPU1.G9 GPU1.G10 GPU1.G12 R606.2
3V3AUX: C12162.2 C12163.1 GPU1.F11 R79842.2 R79850.2 R79852.2 U14.27
12V_FAN: C204.1 C12325.2 C12326.1 C12327.1 F21.1 FANC3.2 Q9624.S R361.1 R79914.1 R79935.2
12V_S: F21.2 Q9624.D R79935.1 R80234.2 R80235.2
12V_S0: PR5301.2 R80235.1
+3V_VA: C207.1 C229.1 C230.1 C12153.1 L5.2 U9.23 U9.25
+3VL: PG16.2
+5VL: PG13.2 PR163.1
+19V_AMP_AVCC: C246.1 R380.2 U10.12
+19V_AMP_PVCC: C232.1 C233.1 C247.1 C248.1 L6.2 R380.1 U10.13 U10.14 U10.27 U10.28
+DVDDIO_AUDIO: C12061.1 R886.2 U2.BA15
+P1V0_PRIME_PCH_FUSE_2V8: R892.1 U2.AL22
+V1P0A_VCCAMPHYPLL: C11837.1 R891.2 U2.A43 U2.B43 U2.C44 U2.C45
+V1P0A_VCCAPLL: R889.2 U2.AJ5 U2.AL5 U2.AN19
+V1P0A_VCCF24_1P0: C11839.1 R159.1 R890.2 U2.K2 U2.K3
+VCCFUSEPRG: CPU1.V6 R1822.2
+VCCFUSEPRG_R: R1822.1 R1823.2 R1824.2
+VCCPFUSE_3P3: R1732.1 U2.BD3 U2.BE3 U2.BE4
+VCCPGPPA: R1730.1 U2.BA31
+VCCPGPPD: R79833.2 U2.BA45 U2.BB45 U2.BC44 U2.BC45
+VCCPLL_OC: R65.2
+VCCPLL_OC_R: CPU1.AJ9 R64.1 R65.1
AGND: C206.1 C207.2 C208.1 C210.2 C211.2 C212.2 C213.2 C214.2 C215.2 C226.2 C229.2 C230.2 C231.2 C246.2 C249.1 C250.1 C264.2 C266.2 C267.2 C268.2 C270.2 C271.2 C272.2 C11358.2 C11359.2 C12127.2 C12153.2 LOUT1.5 LOUT1.P Q7.S Q14.S R367.2 R379.2 R382.1 R385.2 R386.2 R387.1 R397.1 R399.2 R412.2 R413.2 R417.2 R418.2 R419.2 R420.2 R423.2 R424.2 R79821.2 R79822.2 R79823.2 R79824.2 R79825.2 R79827.1 U9.22 U9.28 U9.42 U10.4 U9615.6 UHS1.5
AV12: C12155.2 R79843.1 U14.10
DV12S: C12157.1 C12158.2 R79843.2 U14.14
DV33_18: C12159.2 U14.18
