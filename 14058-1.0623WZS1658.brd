# Allegro board 14058-1.0623WZS1658.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWR_81203_CSSUM: length 27.4
  TOP w0.254: v2(33.85,244.97) 33.85,245.35 33.22,245.99 PR4440.2 ; PR4437.1 36.2,239.25 PR4436.1 35.31,237.79 34.84,237.32 32.14,237.32 28.62,240.85 28.62,243.23 PR4435.1 28.96,244.12 v2(29.3,244.46)
  BOTTOM w0.203: 36.88,245.08 PU4401.45
  BOTTOM w0.254: v2(29.3,244.46) 30.55,245.71 v3(30.82,245.71) 31.74,245.71 PC4425.2 32.9,245.92 PC4424.2 v2(33.85,244.97) 36.77,244.97 36.88,245.08
PWR_81203_CSSUMA: length 12.7
  TOP w0.254: PR4434.1 53.28,243.04 v2(53.28,243.57) 52.65,243.57 52.2,244.02 PR4425.2 v1(50.92,244.46)
  BOTTOM w0.203: PU4401.21 47.08,245.08 47.69,244.46
  BOTTOM w0.254: v2(53.28,243.57) 52.96,243.89 PR4423.1 51.63,243.89 PC4418.2 PC4419.2 48.68,244.14 48.64,244.18 47.97,244.18 47.69,244.46
PWR_81203_DIFF: length 6.4
  BOTTOM w0.203: v3(37.53,248.53) 37.53,248.27 38.73,247.08 PU4401.50
  BOTTOM w0.254: PR4451.2 34.49,250.24 PR4450.2 35.82,250.24 v3(37.53,248.53)
PWR_81203_DIFFA: length 7.1
  BOTTOM w0.203: 46.17,247.38 45.87,247.08 PU4401.16
  BOTTOM w0.254: 46.17,247.38 47.19,247.38 47.76,247.95 48.57,247.95 v3(49.09,248.47) 49.21,248.59 PR4457.2 50.23,248.46 50.23,247.57 PR4455.2
PWR_81203_FB: length 9.7
  BOTTOM w0.203: PC4405.2 36.84,248.33 38.49,246.68 PU4401.49
  BOTTOM w0.254: PC4405.2 PR4450.1 PR4453.2 34.23,249.48 v3(33.34,249.48) PC4403.2 31.44,249.48 PR4452.2
PWR_81203_FBA: length 9.9
  BOTTOM w0.203: PR4456.1 48.56,246.71 47.7,246.71 47.43,246.98 46.23,246.98 45.93,246.68 PU4401.17
  BOTTOM w0.254: PC4409.1 51.44,247.76 PR4454.2 PC4411.2 51.85,246.39 v3(51.15,246.39) 50.02,246.39 PR4455.1 PR4456.1
PWR_81203_ILIM: length 4.5
  BOTTOM w0.203: PU4401.46 39.13,245.55 37.57,245.55 37.26,245.86 v3(36.39,245.86) 35.31,245.86 PR4438.1
PWR_81203_ILIMA: length 4
  BOTTOM w0.203: PR4424.1 48.2,244.72 47.18,245.74 v3(46.91,245.74) 46.91,245.74 46.91,245.73 46.65,245.48 PU4401.20
PWR_81203_IOUT: length 8.7
  BOTTOM w0.203: PU4401.1 39.71,249.61 38.32,251
  BOTTOM w0.254: v3(36.71,255.79) PC4408.1 PR4409.2 36.63,253.4 36.63,252.69 38.32,251
PWR_81203_IOUTA: length 10.4
  TOP w0.254: PR4414.2 PC4414.1 49.98,251.51 v1(49.98,251.45) 47.57,249.03 v2(45.41,249.03)
  BOTTOM w0.203: 44.85,248.47 44.76,248.39 PU4401.13
  BOTTOM w0.254: v2(45.41,249.03) 44.85,248.47
PWR_81203_ROSC: length 5.2
  TOP w0.254: v2(43.5,250.43) 43.25,250.68 v1(43.25,251.39) 43.43,251.57 44.2,251.57 PR4418.1
  BOTTOM w0.203: PU4401.8 42.51,249.56 43.38,250.43 v2(43.5,250.43)
PWR_81203_SCLK: length 4.4
  BOTTOM w0.102: PU4401.5 41.31,248.8 41.41,248.91 41.41,250.74 41.09,251.07 v3(41.09,251.6) PR4460.1
PWR_81203_SDIO: length 5
  BOTTOM w0.102: PR4459.1 38.8,251.88 v3(39.16,251.52) 40.4,250.28 40.4,248.91 40.51,248.8 PU4401.3
PWR_81203_TSEN: length 7.7
  TOP w0.254: PR4416.1 40.01,239.06 39.5,238.56 v2(39.5,238.03)
  BOTTOM w0.203: PC4415.1 39.5,240.79 40.51,241.79 PU4401.37
  BOTTOM w0.254: PC4415.1 39.5,239.5 40.39,238.61 v3(40.39,238.27) 40.16,238.03 v2(39.5,238.03)
PWR_81203_TSEN1: length 27.9
  TOP w0.254: v2(41.42,237.02) 41.34,237.1 PR4417.1 40.46,237.16 PR4416.2
  BOTTOM w0.254: PR8624.2 18.28,234.57 19.51,235.8 28.46,235.8 29.35,234.91 v3(33.34,234.91) 39.21,234.91 40.28,235.98 40.61,235.98 41.22,236.59 41.22,236.81 v2(41.42,237.02)
PWR_81203_TSENA: length 7.4
  BOTTOM w0.203: PU4401.11 43.71,248.73 44.09,249.11 44.11,249.11
  BOTTOM w0.254: PR4419.1 48.08,253.23 v3(47.68,252.83) 46.99,252.14 PC4416.1 46.17,251.64 46.17,251.17 44.11,249.11
PWR_81203_TSENA1: length 17.3
  BOTTOM w0.254: PR4419.2 49.09,254.68 PR4420.1 50.17,255.76 50.17,255.77 50.54,256.15 v3(53.41,256.15) 59.01,256.15 PR4464.2
PWR_81203_VCC: length 1.8
  BOTTOM w0.203: 42.11,250.18 PU4401.7
  vias: v3(43.25,251.83)
PWR_81203_VRMP: length 5.9
  BOTTOM w0.203: PU4401.9 42.91,249.46 43.37,249.92 44.14,249.92
  BOTTOM w0.508: 44.14,249.92 44.65,250.43 v3(44.65,250.81) PC4429.1 PR4403.2
PWR_81203_VSN: length 7.1
  BOTTOM w0.203: PU4401.52 39.19,249.33
  BOTTOM w0.254: PR4408.2 PC4407.1 37.01,251.51 v3(38.35,250.18) 39.19,249.33
PWR_81203_VSNA: length 8.4
  BOTTOM w0.203: PU4401.14 45.49,247.88
  BOTTOM w0.254: 48.84,251.32 48.84,250.49 PC4413.1 48.84,250.11 48.84,249.7 48.3,249.16 46.77,249.16 45.49,247.88 ; 48.84,251.32 v3(48.58,251.32) ; 48.84,251.32 48.84,251.45 49.98,252.59 PR4413.2
PWR_81203_VSP: length 9.1
  BOTTOM w0.203: 38.19,249.26 38.19,248.12 38.84,247.48 PU4401.51
  BOTTOM w0.254: PC4406.1 PR4407.1 33.89,250.96 34.67,250.96 34.69,250.94 36.52,250.94 v3(36.7,250.75) 38.19,249.26
PWR_81203_VSPA: length 9
  BOTTOM w0.203: 45.63,247.48 PU4401.15
  BOTTOM w0.254: PR4412.1 PC4412.1 49.5,251.57 49.22,251.29 49.22,249.54 48.46,248.78 46.93,248.78 46.61,248.46 ; 46.61,248.46 45.63,247.48 ; 46.61,248.46 v3(46.81,248.27)
PWR_CHG_ACDET: length 6.2
  TOP w0.254: U55.6 71.67,40.71 v2(71.84,40.88)
  BOTTOM w0.254: PR5270.2 71.67,36.33 71.67,36.97 v3(72.08,37.37) 71.89,37.57 PR5286.1 PC5232.1 71.89,40.84 v2(71.84,40.88)
PWR_CHG_ACN: length 9.4
  TOP w0.254: U55.1 74.48,40.83 75.41,41.77 76.55,41.77 PC5235.2 77.18,41.39 PC5233.1 78.99,41.39 v2(79.22,41.62) ; PG4905.2 79.47,44.32 79.34,44.18 v2(79.21,44.18)
  BOTTOM w0.254: v2(79.21,44.18) 79.21,44.05 79.19,44.04 v3(79.19,43.04) 79.19,41.64 v2(79.22,41.62)
PWR_CHG_ACP: length 7.8
  TOP w0.254: 75.76,42.15 v1(75.76,42.43) ; 75.76,42.15 76.42,42.15 77.06,42.79 77.18,42.66 PC5234.1 78.18,42.66 PG4907.2 ; 75.76,42.15 75.25,42.15 73.98,40.87 U55.2
PWR_CHG_BTST: length 4.1
  TOP w0.305: U55.17 75.88,38.09 76.14,37.83 76.14,37.58
  TOP w0.508: 76.14,37.58 76.4,37.32 76.4,36.73 76.73,36.4 v1(76.73,36.28) 76.75,36.31 PR5281.1
PWR_CHG_BTST_1: length 3.9
  TOP w0.508: PD4401.K 78.52,33.74 78.87,34.1 78.87,35.23 ; PC5236.1 78.87,37.39 PR5281.2 78.87,35.23 ; 78.87,35.23 v1(78.86,35.22)
PWR_CHG_CMPIN: length 11.9
  TOP w0.254: v2(69.03,40.25) PR5468.1 68.15,40.3 PR5469.2 67.1,41.3 PR5470.1 ; PR5288.2 73.76,42.09 v1(73.76,41.95) 73.76,41.8 v2(73.22,41.26) 72.97,41.01 U55.4
  L4 w0.254: v2(73.22,41.26) 73.22,40.88 72.28,39.94 69.33,39.94 v2(69.03,40.25)
  BOTTOM w0.254: v2(69.03,40.25) 69.86,40.25 PR5467.2
PWR_CHG_CMPIN_R: length 3.5
  TOP w0.254: PQ5006.6 67.11,43.66 v2(66.74,43.29) 66.74,42.54 PR5470.2
  BOTTOM w0.254: v3(67.66,43.29) v2(66.74,43.29)
PWR_CHG_CMPIN_RR: length 4.9
  TOP w0.254: PR5469.1 68.15,42.49 v2(68.6,42.94) 68.83,43.17 68.83,44.61 69.17,44.96 PQ5006.3
  BOTTOM w0.254: v2(68.6,42.94) 68.6,42.23 v3(68.4,42.02)
PWR_CHG_ILIM: length 3.9
  TOP w0.305: 71.67,36.93 U55.10
  TOP w0.508: 71.67,36.93 71.67,36.12 71.26,35.71 71.26,35.15 v1(71.26,35.14) 71.26,35.13 71.26,34.73 71.56,34.44 PR5268.1
PWR_CHG_IOUT: length 6.8
  TOP w0.254: v2(68.97,41.26) 70.11,40.12 PC5245.1 71.2,39.09 U55.7
  BOTTOM w0.254: PR5290.1 69.92,41.71 PR5467.1 69.03,41.2 v2(68.97,41.26) 68.76,41.26 v3(68.23,40.72)
PWR_CHG_PHASE: length 3.5
  TOP w0.305: 76.32,39.09 U55.19
  TOP w0.508: 76.32,39.09 76.91,39.09 v1(77.27,38.74) 77.29,38.72 PC5236.2
PWR_CHG_SRN: length 3.7
  TOP w0.254: 73.03,35.34 73.03,34.01 PR5277.2 ; 73.03,35.34 v1(72.56,35.34) ; 73.03,35.34 73.03,35.9 72.97,35.96 U55.12
PWR_CHG_SRN_R: length 1.1
  TOP w0.254: PR5277.1 72.72,31.83 R79876.2
PWR_CHG_SRP: length 3.7
  TOP w0.254: 73.42,34.73 73.42,34.04 PR5285.2 ; 73.42,34.73 73.42,35.9 73.48,35.96 U55.13 ; 73.42,34.73 v1(73.81,34.73)
PWR_CHG_SRP_R: length 1.1
  TOP w0.254: R79876.1 73.76,31.78 PR5285.1
PWR_CHG_VCC: length 7
  TOP w0.305: U55.20 75.62,39.59 v2(76.14,40.12)
  BOTTOM w0.762: v2(76.14,40.12) 76.14,39.61 77.36,38.39 PC4432.1 77.36,36.46 v3(77.34,36.44) 77.36,36.41 77.36,34.81 PR5284.2
PWR_DCBATOUT_1D0V:
  vias: v1(163.24,125.79) v3(162.86,125.79) v4(161.74,123.94) v4(162.25,124.7) v4(162.88,123.94) v4(163.52,124.7) v4(164.03,123.94)
PWR_DCBATOUT_3V:
  vias: v1(29.41,83.37) v4(35.38,80.5) v4(36.39,80.5)
PWR_DCBATOUT_5V:
  vias: v1(38.55,63.49)
PWR_DCBATOUT_VCC:
  vias: v3(8.04,196.12) v3(12.92,194.83) v3(15.61,200.14) v4(10.1,198.49) v4(10.1,197.47) v4(10.1,196.46) v4(10.1,195.44) v4(11.12,198.49) v4(11.12,197.47) v4(11.12,196.46) v4(11.12,195.44) v4(13.91,199.25) v4(13.91,198.23) v4(13.91,197.22) v4(13.91,196.2) v4(14.93,199.25) v4(14.93,198.23) v4(14.93,197.22) v4(14.93,196.2)
PWR_DCBATOUT_VCC2:
  vias: v3(7.84,217.08) v3(15.79,213.17) v4(10.1,217.16) v4(10.1,216.14) v4(10.1,215.12) v4(11.12,217.16) v4(11.12,216.14) v4(11.12,215.12) v4(11.12,214.11) v4(13.91,217.16) v4(13.91,216.14) v4(13.91,215.12) v4(13.91,214.11) v4(14.93,217.16) v4(14.93,216.14) v4(14.93,215.12) v4(14.93,214.11)
PWR_DCBATOUT_VCC3: length 47.1
  L4 w0.508: v2(45.66,253.83) 42.57,250.74 30.92,250.74 30.53,251.13 26.91,251.13 10.58,234.8 10.58,232.42 10.61,232.4 v4(10.61,231.76)
  BOTTOM w0.508: PR4403.1 v2(45.66,253.83)
  vias: v3(7.99,232.42) v3(12.26,228.28) v3(15.82,230.36) v4(9.59,231.76) v4(9.59,230.75) v4(9.59,229.73) v4(9.59,228.71) v4(10.61,230.75) v4(10.61,229.73) v4(10.61,228.71) v4(13.91,232.4) v4(13.91,231.38) v4(13.91,230.36) v4(13.91,229.35) v4(14.93,232.4) v4(14.93,231.38) v4(14.93,230.36) v4(14.93,229.35)
PWR_DCBATOUT_VCCIO:
  vias: v1(19.25,181.6)
PWR_DCBATOUT_VCCSA:
  vias: v3(25.82,152.01) v3(25.88,148.86) v4(25.47,150.99) v4(25.47,149.97) v4(26.61,150.99) v4(26.61,149.97)
PWR_DCBATOUT_VDDQ: length 17.7
  L3 w0.508: v4(158.06,219.7) 163.9,213.85 163.9,212.08 165.68,210.3 166.69,210.3 167.41,209.58 167.41,209.58 v2(167.77,209.22)
  BOTTOM w0.508: PC90.1 167.04,209.38 167.2,209.22 v2(167.77,209.22) 167.77,209.23 167.96,209.42 PR187.1
  vias: v1(143.05,255.15) v1(151.28,223.02) v1(162.76,248.53) v1(166.21,231.35) v4(153.99,220.97) v4(153.99,219.7) v4(155.26,220.97) v4(155.26,219.7) v4(156.66,220.97) v4(156.66,219.7) v4(158.06,220.97)
PWR_LED_YELLOW_C: length 11.6
  TOP w0.254: PWRCN1.9 36.43,16.42 36.25,16.24 36.25,15.06 36.7,14.62 v1(37.92,14.62) 38.26,14.62 39.43,13.45 R757.2 40.01,13.45 Q65.D 44.46,12.18 R759.1
PWR_LED_YELLOW_C2: length 2.7
  TOP w0.254: R757.1 R756.2 39.69,10.5 39.06,9.87 v1(39.06,9.51)
PWR_VCC_BST1: length 2.9
  TOP w0.305: 9.59,190.74 PU4.1
  TOP w0.508: 9.59,190.74 9.59,191.15 v1(9.75,191.3) 9.75,192.39 PR77.2
PWR_VCC_BST1R: length 1.6
  TOP w0.508: PC33.1 12.49,192.39 PR77.1
PWR_VCC_BST2: length 3
  TOP w0.305: 9.59,209.53 PU9.1
  TOP w0.508: 9.59,209.53 9.59,209.86 v1(10.03,210.3) PR84.2
PWR_VCC_BST2R: length 1.8
  TOP w0.508: PR84.1 12.46,211.19 PC37.1
PWR_VCC_BST3: length 3.7
  TOP w0.305: 14.8,236.33 PU14.1
  TOP w0.508: 14.8,236.33 15.74,236.33 PR90.2 15.87,237.36 16.33,237.82 v1(16.33,237.98)
PWR_VCC_BST3R: length 4.1
  TOP w0.508: v1(19.12,237.73) 19.12,237.53 PR90.1 18.61,235.39 PC41.1
PWR_VCC_DRH1: length 12.6
  TOP w0.305: v4(11.96,191.3) 11.96,191.07 11.63,190.74 PU4.8
  BOTTOM w0.762: v4(11.96,191.3) 11.96,191.43 15.33,194.8 v3(15.79,194.8) 20.57,194.8 PR79.1
PWR_VCC_DRH1_G: length 14.5
  TOP w0.508: PR80.1 25.46,201.62 25.11,201.97 v1(24.99,201.97) 24.81,201.97 24.41,201.57 24.41,200.81 23.87,200.27 23.31,200.27
  TOP w0.762: v4(23.31,201.66) 23.31,200.27
  L3 w1.016: v4(23.31,195.44) v4(23.31,201.66)
  BOTTOM w0.762: PU3.4 v4(23.31,195.44) 23.26,195.39 PR79.2
PWR_VCC_DRH2: length 11.5
  TOP w0.305: v4(11.7,209.79) 11.63,209.72 PU9.8
  BOTTOM w0.762: PR85.1 20.54,211.34 v3(14.24,211.34) 13.25,211.34 v4(11.7,209.79)
PWR_VCC_DRH2_G: length 12.8
  TOP w0.508: PU7.4 23.95,216.78 24.99,217.82 v1(25.27,217.82) 25.41,217.68 PR86.1
  TOP w0.762: PU7.4 v4(23.31,217.79)
  L3 w1.016: v4(23.31,217.79) v4(23.31,211.95)
  BOTTOM w0.762: PU8.4 v4(23.31,211.95) 23.26,211.9 PR85.2
PWR_VCC_DRH3: length 8.4
  TOP w0.305: PU14.8 14.55,234.3 14.8,234.56 15.34,234.56 v4(15.56,234.78)
  TOP w1.016: PR91.1 20.26,235.06 v4(20.14,235.19)
  L3 w1.016: v4(15.56,234.78) 15.56,234.9 15.85,235.19 v4(20.14,235.19)
  BOTTOM w0.254: v4(15.56,234.78) 15.56,234.78 v3(14.88,234.78)
PWR_VCC_DRH3_G: length 13.1
  TOP w0.508: PR92.1 PU12.4
  TOP w0.762: PR91.2 23.31,235.01 v4(23.31,233.54) PU12.4
  TOP w1.016: PR91.2 24.83,235.06 v1(24.86,235.09)
  L3 w1.016: v4(23.31,227.7) v4(23.31,233.54)
  BOTTOM w0.762: PU13.4 v4(23.31,227.7)
PWR_VCC_DRL1: length 15.4
  TOP w0.305: PU4.5 12.12,188.59 12.64,188.07 v4(13.02,188.07)
  TOP w0.762: PU5.4 v4(17.72,186.55)
  L3 w1.016: v4(18.03,192.37) 17.72,192.06 17.72,188.84 ; 17.72,188.84 13.79,188.84 v4(13.02,188.07) ; 17.72,188.84 v4(17.72,186.55)
  BOTTOM w0.508: v4(13.02,188.07) 13,188.05 v3(12.36,188.05)
  BOTTOM w0.762: PU6.4 17.72,192.06 v4(18.03,192.37)
PWR_VCC_DRL2: length 15.6
  TOP w0.305: v4(13,206.87) 12.64,206.87 12.12,207.39 PU9.5
  TOP w0.762: PU10.4 v4(17.72,203.06)
  L3 w1.016: v4(13,206.87) 13,206.51 13.53,205.98 17.72,205.98 ; 17.72,205.98 v4(17.72,203.06) ; 17.72,205.98 17.72,208.54 v4(18.05,208.88)
  BOTTOM w0.508: v3(12.34,206.87) v4(13,206.87)
  BOTTOM w0.762: PU11.4 17.72,208.54 v4(18.05,208.88)
PWR_VCC_DRL3: length 27.2
  TOP w0.305: 12.01,233.54 12.65,234.19 PU14.5
  TOP w0.762: PU15.4 v4(17.72,218.68)
  TOP w1.016: 12.01,233.54 11.5,233.03 v4(11.5,232.9)
  L3 w1.016: v4(17.72,218.68) 17.72,218.68 17.72,221.6 ; v4(11.5,232.9) 12.39,232.02 12.39,222.62 13.4,221.6 17.72,221.6 ; v4(17.95,224.62) 17.72,224.4 17.72,221.6
  BOTTOM w0.254: v3(11.52,233.59) 11.52,232.93 v4(11.5,232.9)
  BOTTOM w0.762: v4(17.95,224.62) 17.72,224.39 PU16.4
PWR_VCC_EN1: length 3.3
  TOP w0.254: PU4.3 8.7,189.09 v1(8.12,189.67) 7.24,190.55 PR81.1
PWR_VCC_EN2: length 3.9
  TOP w0.254: PU9.3 7.69,207.89 v1(7.18,208.39) 7.32,208.53 7.32,209.21 PR87.1
PWR_VCC_EN3: length 2.9
  TOP w0.254: PU14.3 13.15,237.22 13.15,237.22 v1(12.52,237.86) 12.2,238.17 PR93.1
PWR_VCC_LX1: length 10.7
  TOP w0.305: PU4.7 12.13,189.59 v4(12.64,190.11)
  TOP w0.508: PC33.2 12.77,190.11 v4(12.64,190.11)
  BOTTOM w0.762: 19.5,193.41 15.94,193.41 v4(12.64,190.11)
  vias: v3(26.46,189.14) v3(26.99,196.12) v4(24.71,198.36) v4(24.71,197.22) v4(24.73,199.43) v4(24.86,191.81) v4(24.83,190.74) v4(24.86,188.12) v4(24.83,187.06) v4(25.85,199.38) v4(25.85,198.36) v4(25.85,197.22) v4(25.98,191.76) v4(25.98,190.74) v4(25.98,188.07) v4(25.98,187.06) v4(27.02,199.43) v4(26.99,198.36) v4(26.99,197.22) v4(27.12,190.74) v4(27.12,187.06) v4(27.22,200.52) v4(27.15,191.81) v4(27.15,188.12) v4(28.14,200.52) v4(28.14,199.38) v4(28.14,198.36) v4(28.14,197.22) v4(28.26,191.76) v4(28.26,190.74) v4(28.26,188.07) v4(28.26,187.06)
PWR_VCC_LX2: length 9.7
  TOP w0.305: PU9.7 12.13,208.39 v4(12.64,208.9)
  TOP w0.508: v4(12.64,208.9) 12.77,208.9 PC37.2
  BOTTOM w0.762: 19.5,209.92 13.81,209.92 12.79,208.9 v4(12.64,208.9)
  vias: v3(26.1,216.95) v3(27.32,210.45) v3(27.7,205.5) v4(24.71,206.87) v4(24.71,204.58) v4(24.71,203.57) v4(24.73,207.94) v4(24.83,215.25) v4(24.83,214.11) v4(24.83,213.09) v4(25.85,207.89) v4(25.85,206.87) v4(25.85,204.58) v4(25.85,203.57) v4(25.98,215.25) v4(25.98,214.11) v4(25.98,213.09) v4(27.02,207.94) v4(26.99,206.87) v4(26.99,204.58) v4(26.99,203.57) v4(27.12,215.25) v4(27.12,214.11) v4(27.12,213.09) v4(27.25,216.52) v4(28.14,207.89) v4(28.14,206.87) v4(28.14,204.58) v4(28.14,203.57) v4(28.26,216.52) v4(28.26,215.25) v4(28.26,214.11) v4(28.26,213.09)
PWR_VCC_LX3: length 17
  TOP w0.305: v4(14.8,233.44) 14.01,233.44 13.65,233.8 PU14.7
  TOP w0.508: v4(14.8,233.44) 14.95,233.29 15.56,233.29 16.83,234.56 PC41.2
  L3 w1.016: v4(14.8,233.44) 20.8,233.44 22.55,235.19 24.45,235.19 25.22,234.43 v4(25.22,233.54)
  vias: v3(26.36,232.73) v3(27.91,224.01) v4(24.71,221.09) v4(24.71,220.08) v4(24.71,219.06) v4(24.83,231.38) v4(24.83,230.24) v4(24.96,227.44) v4(24.96,226.43) v4(25.85,221.09) v4(25.85,220.08) v4(25.85,219.06) v4(25.98,231.38) v4(25.98,230.24) v4(26.1,227.44) v4(26.1,226.43) v4(26.99,221.09) v4(26.99,220.08) v4(26.99,219.06) v4(27.12,231.38) v4(27.12,230.24) v4(27.25,232.9) v4(27.25,227.44) v4(27.25,226.43) v4(28.14,221.09) v4(28.14,220.08) v4(28.14,219.06) v4(28.26,231.38) v4(28.26,230.24) v4(28.39,232.9) v4(28.39,227.44) v4(28.39,226.43)
PWR_VCC_SNB1: length 2.9
  TOP w0.508: PC36.1 19.36,194.38 v1(19.3,194.45) 20.31,194.45 PR82.2
PWR_VCC_SNB2: length 2.8
  TOP w0.508: PR88.2 20.24,210.96 19.31,210.96 v1(19.26,211.01) PC40.1
PWR_VCC_SNB3: length 2.8
  TOP w0.508: PC44.1 v1(19.41,226.71) 19.41,226.74 20.33,226.74 PR94.2
PWR_VCC_VCC1: length 5.3
  TOP w0.305: PC34.1 7.89,188.59 PU4.4
  TOP w0.508: v1(6.75,189.47) 6.75,189.39 7.63,188.52 PC34.1 7.63,187.63 7.99,187.26 PR74.2
PWR_VCC_VCC2: length 5.3
  TOP w0.305: 7.85,207.08 8.16,207.39 PU9.4
  TOP w0.508: 7.85,207.08 v1(7.63,207.08) PC39.1 8.76,205.35 PR83.2
PWR_VCC_VCC3: length 4.8
  TOP w0.305: PU14.4 11.31,236.33 PC43.1
  TOP w0.508: PC43.1 11.11,236.41 PR89.2 v1(7.97,236.41)
PWR_VCCIO: length 36.3
  TOP w0.508: v2(25.1,162.23) 24.72,162.61 PR4801.1
  TOP w0.635: PT20.1 39.31,182.9 ; PT20.1 40.37,181.85 ; PT20.1 38.26,181.85 ; PT20.1 39.31,180.8
  BOTTOM w0.381: v2(25.1,162.23) 24.07,163.26 24.07,170.93 26.5,173.35 29.61,173.35 29.85,173.6 34.34,173.6 34.38,173.63 36.3,173.63 v4(39.44,176.77)
  BOTTOM w0.635: PT20.1 39.31,182.9 ; PT20.1 38.26,181.85 ; PT20.1 40.37,181.85 ; PT20.1 39.31,180.8
  vias: v3(33.6,177) v3(34.18,182.89) v3(43.45,174.56) v4(32.33,180.07) v4(32.71,175.12) v4(33.47,180.07) v4(33.62,175.12) v4(34.61,180.07) v4(34.74,175.12) v4(35.76,177.91) v4(35.76,176.77) v4(36.9,177.91) v4(36.9,176.77) v4(38.17,177.91) v4(38.17,176.77) v4(41.73,179.06) v4(41.73,177.91) v4(41.73,176.77) v4(41.73,175.63) v4(41.85,180.33) v4(41.98,174.74) v4(42.87,181.34) v4(42.87,180.2) v4(42.87,179.06) v4(42.87,177.91) v4(42.87,176.77) v4(42.87,175.63)
PWR_VCCIO_BOOT: length 5.1
  TOP w0.305: PR139.1 18.94,172.22 18.13,171.41 18.13,169.84 18.09,169.8 v1(18.09,169.45) 18.15,169.4 19.48,169.4 PU32.10
PWR_VCCIO_BOOT_R: length 2.3
  TOP w0.508: PR139.2 PC62.1 20.46,173.77 v1(20.46,174.84)
PWR_VCCIO_CS: length 5.5
  TOP w0.254: PU32.2 20.14,165.86 20.01,165.72 18.93,165.72 18.3,165.09 17.91,165.09 17.6,164.77 v1(17.6,164.58) 17.6,164.2 16.77,163.37 PR136.2
PWR_VCCIO_EN: length 3.8
  TOP w0.254: R1968.2 PC64.1 19.7,164.88 v1(19.87,165.04) 20.64,165.82 PU32.3
PWR_VCCIO_EN_G1: length 9.8
  TOP w0.254: R1961.2 C12055.1 18.93,160.51 18.74,160.51 18.36,160.13 U173.2 18.36,159.07 18.81,158.61 19.08,158.61 19.25,158.43 19.32,158.43 19.46,158.28 19.46,158.22 21.66,156.03 v1(21.67,156.03) 21.71,155.98 21.71,154.6 R80228.2
PWR_VCCIO_EN_G2: length 4.3
  TOP w0.254: U173.6 19.69,156.99 R1963.2 v1(18.74,156.2) 18.61,156.32 18.61,156.83 18.36,157.09 U173.5
PWR_VCCIO_EN_R: length 5.1
  TOP w0.254: U173.3 17.71,160.37 18.29,160.95 R1964.2 R1967.2 18.69,162.51 R1968.1 17.76,163.14 v1(17.67,163.23)
PWR_VCCIO_FB: length 6.7
  TOP w0.254: PC67.2 PR146.2 22.07,162.34 v1(21.35,162.34) 21.34,162.36 PR147.1 21.28,163.44 20.64,164.07 20.64,165.16 21.07,165.59 21.07,165.6 21.14,165.67 PU32.4
PWR_VCCIO_FB_R: length 5.9
  TOP w0.254: PC67.1 24.38,161.35 24.48,161.45 v1(24.53,161.45) 24.45,161.53 24.45,161.61 23.69,162.37 23.46,162.37 PR146.1 23.18,162.29 23.69,162.8 23.69,162.85 24.28,163.44 24.33,163.44 PR4801.2 24.45,163.63 PR4802.2
PWR_VCCIO_LGATE: length 4.6
  TOP w0.762: 22.8,169.98 23.59,170.77 23.59,171.51 23.56,171.54 23.56,172.58 v1(23.69,172.71) 22.68,173.72
PWR_VCCIO_PG: length 170.5
  TOP w0.254: v2(18.1,165.64) 18.04,165.71 PC4431.1 ; PC4431.1 19.62,166.48 PU32.1 ; PC4431.1 PR135.2 ; R79947.1 28.33,130.67 25.55,130.67 24.71,129.83 23.48,129.83 22.87,129.22 21.45,129.22 19.73,130.94 19.73,133.23 18.81,134.15 v1(18.81,138.53) 18.81,139.62 v2(19.36,140.17) ; v2(36.01,256.78) 35.76,256.53 R1966.1
  L3 w0.254: v2(36.01,256.78) 34.87,256.78 33.72,255.63 33.72,255.26 32.95,254.49 22.47,254.49 21.41,253.43 21.41,250.5 12.82,241.92 10.28,241.92 4.06,235.7 4.06,185.74 11.12,178.68 11.12,171.11 13.84,168.39 15.81,168.39 18.1,166.09 v2(18.1,165.64) 18.84,164.91 18.84,154.58 19.36,154.06 v2(19.36,140.17)
PWR_VCCIO_PG_D: length 9.2
  TOP w0.102: PR123.2 30.42,129.59 30.42,130.33 31.15,131.05 U9617.D 34.61,131.05 v1(35.12,131.56) 35.12,133.23 U9616.G
PWR_VCCIO_PG_G: length 5.5
  TOP w0.102: U9617.G 31.25,132.89 v1(30.68,133.46) 29.72,132.51 C12341.1 R79947.2 R79946.2
PWR_VCCIO_PHASE: length 14.4
  TOP w0.305: v4(20.79,170.92) 20.64,170.78 PU32.8
  TOP w0.508: PC62.2 20.57,172.1 20.57,171.22 20.79,171 v4(20.79,170.92)
  L3 w1.016: v4(20.79,170.92) 20.64,171.07 20.64,172.15 26.87,178.37 v4(26.87,179.86)
  vias: v3(24.12,174.59) v3(29.23,178.88) v4(26.61,175.12) v4(27.76,175.12) v4(28.01,179.95) v4(28.9,175.12) v4(29.15,179.95)
PWR_VCCIO_RF: length 2.9
  TOP w0.254: PR143.1 23.36,166.61 23.31,166.56 v1(23.31,166.51) 23.26,166.51 23.21,166.46 PU32.5
PWR_VCCIO_SNB: length 3.8
  BOTTOM w0.508: PR145.2 23.74,179.65 23.5,179.9 22.65,179.9 v3(22.29,179.54) 22.29,178.48 PC65.1
PWR_VCCIO_UGATE: length 17.4
  TOP w0.305: 19.83,170.39 20.14,170.08 PU32.9
  TOP w0.406: PU31.4 25.45,181.79 25.44,181.8 v4(25.44,181.86)
  TOP w0.508: 19.83,170.39 19.83,170.95 v1(19.73,171.06) 19.25,171.06 v4(18.87,170.67)
  L3 w1.016: v4(18.87,170.67) 18.87,172.71 25.22,179.06 25.22,181.63 v4(25.44,181.86)
PWR_VCCSA_BOOT: length 4.2
  TOP w0.305: 24.45,138.92 24.97,138.4 PU28.4
  TOP w0.508: v1(22.78,140.58) 23.11,140.24 PR19.1 24.45,138.92
PWR_VCCSA_BOOT_R: length 3.2
  TOP w0.508: PC5.1 24.66,141.97 PR19.2 v1(23.01,142.18)
PWR_VCCSA_COMP: length 4.5
  TOP w0.305: v1(22.8,136.94) 22.8,136.36 23.33,135.83 23.9,135.83 23.96,135.89 PU28.8
  TOP w0.508: PC8.1 21.79,136.7 PC7.1 21.9,136.94 v1(22.8,136.94)
PWR_VCCSA_COMP_R: length 3.2
  TOP w0.508: PR11.1 20.83,135.88 PC7.2 20.71,136.89 v1(19.75,136.89) C12442.1
PWR_VCCSA_CSN: length 71.2
  TOP w0.254: PU28.12 26.87,135.24 27.7,134.4 PC11.1 28.34,133.91 28.67,134.24 PC10.2 PR13.2 ; v1(28.9,133.46) 29.69,134.25 PR13.2 ; v2(30.57,134.83) 30.38,134.64 PR13.2 ; PG12.2 33.04,165.98 v2(32.94,166.08)
  L3 w0.254: v2(32.94,166.08) 32.73,166.28 32.73,170.75 30.88,172.6 25.28,172.6 23.06,170.38 23.06,164.23 19.86,161.03 19.86,155 20.39,154.47 20.39,141.51 20.77,141.13 20.77,136.89 23.24,134.42 30.16,134.42 v2(30.57,134.83)
PWR_VCCSA_CSP: length 5.6
  TOP w0.254: PU28.13 28.25,135.89 28.61,135.53 PC10.1 PR13.1 30.04,135.88 30.05,135.94 PR10.2 30.05,137.03 30.68,137.65 v1(31.03,137.65)
PWR_VCCSA_CSP_R: length 64.5
  TOP w0.254: PR10.1 31.5,136.01 31.5,135.25 v1(31.38,135.14) 31.06,135.14 30.75,135.44 30.75,135.5 v2(30.57,135.67) ; PG11.2 31.87,165.98 v2(32.02,166.13)
  L3 w0.254: v2(30.57,135.67) 30.23,135.33 27.38,135.33 26.98,134.93 23.45,134.93 21.28,137.1 21.28,141.34 20.9,141.72 20.9,154.68 20.36,155.21 20.36,160.82 23.56,164.02 23.56,170.17 25.49,172.1 30.67,172.1 32.23,170.54 32.23,166.33 v2(32.02,166.13)
PWR_VCCSA_EN: length 10.6
  TOP w0.102: PU28.14 28.8,136.39 30.63,138.21 v1(32.48,138.21) 32.75,138.21 PR9.1 32.9,136.33 U9616.D
PWR_VCCSA_FB: length 10.6
  TOP w0.254: PC8.2 PR11.2 C12442.2 ; PC8.2 22.01,135.15 v1(22.87,135.15) 24.36,135.15 24.45,135.24 PU28.9 ; PC8.2 21.98,134.73 PR14.1 22.29,133.84 23.25,132.89 PC9.1 23.69,132.38 PR12.1 PR15.1
PWR_VCCSA_FB_L: length 2.1
  TOP w0.254: v1(21.28,132.83) PC9.2 PR17.1
PWR_VCCSA_LGATE: length 25.8
  TOP w0.305: v4(26.83,138.96) 26.52,138.96 25.97,138.41 PU28.2
  TOP w0.889: PU30.4 v4(35.25,153.53)
  L3 w1.016: v4(26.83,138.96) 26.83,140.16 28.14,141.46 28.14,148.58 29.43,149.87 v4(29.43,153.53) v4(35.25,153.53)
  BOTTOM w0.508: v4(26.83,138.96) v3(26.83,139.85)
  BOTTOM w0.762: PU29.4 v4(29.43,153.53)
PWR_VCCSA_PG: length 5.5
  TOP w0.254: PU28.6 24.23,136.98 23.97,136.98 23.37,137.58 21.54,137.58 PC4701.2 PR4.2 v1(21.47,139.94)
PWR_VCCSA_PHASE: length 24.8
  TOP w0.305: PU28.3 25.47,139.05 v4(25.47,139.05)
  TOP w0.508: PC5.2 26.1,139.69 v4(25.47,139.05)
  L3 w1.016: v4(25.47,139.05) 24.48,140.04 24.48,158.76 25.09,159.37 v4(25.09,160.51)
  vias: v3(26.13,167.6) v3(26.18,159.09) v3(31.13,162.83) v4(26.04,168.5) v4(26.1,163.31) v4(26.1,162.29) v4(26.94,168.64) v4(27.25,163.31) v4(27.25,162.29) v4(27.86,168.64) v4(28.39,163.31) v4(28.39,162.29) v4(28.77,168.64) v4(29.53,163.31) v4(29.53,162.29) v4(31.69,161.66) v4(31.69,160.64) v4(32.84,161.66) v4(32.84,160.64)
PWR_VCCSA_UGATE: length 23.7
  TOP w0.305: v4(23.36,138.49) 24.33,137.53 PU28.5
  L3 w1.016: v4(21.68,157.29) 21.98,157.29 22.8,156.46 22.8,139.05 v4(23.36,138.49)
  BOTTOM w0.508: v3(23.99,137.86) v4(23.36,138.49)
  BOTTOM w1.016: PR20.1 21.71,157.26 v4(21.68,157.29)
PWR_VCCSA_UGATE_R: length 5
  TOP w0.508: PU27.4 v4(23.82,160.53)
  BOTTOM w1.016: v4(23.82,160.53) 23.8,160.53 23.49,160.84 22.74,160.84 v3(22.64,160.74) 22.37,160.48 22.37,159.76 22.94,159.19 PR20.2
PWR_VCCSA_VCC: length 6.5
  TOP w0.305: PU28.15 28.32,136.89 PC3.1
  TOP w0.508: PR2.2 30.85,139.33 v1(29.99,138.47) 29.91,138.39 29.91,138.29 28.96,137.34 28.77,137.34 PC3.1
PWR_VCCSA_VCCP: length 6
  TOP w0.305: PU28.1 26.87,138.04 27.59,138.76 27.59,139.34 27.25,139.69 PC1.1
  TOP w0.508: PR8.2 28.82,139.71 v1(28.59,139.48) 28.38,139.48 27.86,140 PC1.1
PWR_VCCSA_VSEN: length 3.9
  TOP w0.254: v1(23.21,133.87) 23.21,133.79 23.72,133.27 PR12.2 24.33,133.72 25.47,134.86 PU28.10
PWR_VDDQ_BOOT: length 4.1
  BOTTOM w0.203: 168.47,218.93 168.63,218.78 PU40.18
  BOTTOM w0.508: 168.47,218.93 168.47,220 v3(168.37,220.1) PR186.1
PWR_VDDQ_BOOT_L: length 2.6
  BOTTOM w0.508: v3(164.23,221.22) 164.25,221.19 PC93.1 166.82,221.19 PR186.2
PWR_VDDQ_CS: length 5.6
  BOTTOM w0.203: PC87.2 163.33,215.31 163.52,215.51 v3(164.2,215.51) 164.25,215.45 164.32,215.45 164.45,215.33 166.02,215.33 166.31,215.62 PU40.13
  BOTTOM w0.254: PR183.2 PC87.2
PWR_VDDQ_EN: length 14.5
  BOTTOM w0.203: PU40.8 168.63,212.9
  BOTTOM w0.254: R1956.2 R1958.1 ; R1956.2 162.76,207.6 U171.3 ; R1956.2 v3(164.52,209.22) 164.66,209.22 165.38,208.49 167.94,208.49 168.6,209.16 168.6,210.81 168.59,210.81 168.59,212.87 168.63,212.9
PWR_VDDQ_FB: length 6.8
  BOTTOM w0.203: PU40.6 169.78,214.07 170.12,213.73
  BOTTOM w0.254: 170.12,213.73 170.38,213.47 PR193.1 171.27,210.74 PC96.2 PR192.2 172.41,209.79 172.2,209.59 v3(172.2,209.51)
PWR_VDDQ_LGATE: length 21.7
  TOP w0.762: PU42.4 v4(153.99,214.11)
  L4 w1.016: v4(153.99,214.11) 153.99,212.2 ; 153.99,212.2 v4(153.99,210.3) ; 153.99,212.2 158.69,212.2 163.26,216.78 v4(164.58,216.78)
  BOTTOM w0.203: v3(165.47,216.78) 166.34,216.78 166.69,216.42 PU40.15
  BOTTOM w0.762: PU41.4 v4(153.99,210.3)
  BOTTOM w1.016: v3(165.47,216.78) v4(164.58,216.78)
PWR_VDDQ_PG: length 8.7
  TOP w0.254: PR185.2 162.06,210.93 162.06,210.94 162.43,211.31 163.26,211.31 v2(163.52,211.06)
  BOTTOM w0.203: PU40.10 167.67,214.07 166.69,213.09
  BOTTOM w0.254: v2(163.52,211.06) 163.52,211.95 v3(163.65,212.08) 163.65,212.55 164.18,213.09 164.2,213.09 164.45,213.35 165.03,213.35 165.28,213.09 166.69,213.09
PWR_VDDQ_PHASE: length 26
  L4 w1.016: v4(145.65,214.24) 149.93,214.24 152.09,216.39 160.34,216.39 162.5,218.55 v4(166.19,218.55)
  BOTTOM w0.203: 166.89,217.61 167.33,217.17 PU40.16
  BOTTOM w1.016: 166.89,217.61 166.89,217.64 166.19,218.35 v4(166.19,218.55) 165.63,219.11 PC93.2
  vias: v3(142.31,215.05) v3(142.49,221.07) v3(144.29,209.97) v4(141.19,213.35) v4(141.42,219.06) v4(142.31,213.35) v4(142.56,218.93) v4(143.33,213.35) v4(143.71,218.93) v4(144.6,213.35) v4(144.85,218.93)
PWR_VDDQ_SENSE: length 9.4
  BOTTOM w0.203: PU40.5 170.18,214.56 170.38,214.36
  BOTTOM w0.254: v3(176.32,211.54) 175.65,212.22 174.71,212.22 173.93,211.44 PR191.2 173.69,211.63 PR192.1 PC96.1 171.01,212.01 171.01,213.28 170.91,213.38 170.91,213.83 170.38,214.36
PWR_VDDQ_SNB: length 3.3
  BOTTOM w0.508: PC97.1 151.71,217.1 151.71,217.11 v3(151.71,217.38) 151.61,217.49 150.89,217.49 150.26,216.85 PR190.2
PWR_VDDQ_TON: length 3.1
  BOTTOM w0.203: PU40.9 168.23,213.48 168.09,213.35
  BOTTOM w0.254: PR187.2 v3(167.96,212.46) 167.96,213.22 168.09,213.35
PWR_VDDQ_UGATE: length 27.2
  TOP w0.254: v2(167.83,218.48) 167.84,218.48 v1(167.84,219.34)
  TOP w0.762: v4(147.01,215.89) 147.01,216.9 PU39.4
  L4 w1.016: v2(167.83,218.48) 167.84,218.48 167.84,219.32 166.95,220.2 161.74,220.2 159.58,218.05 151.33,218.05 149.17,215.89 v4(147.01,215.89)
  BOTTOM w0.203: PU40.17 168.23,217.91 167.83,218.3 167.83,218.48 v2(167.83,218.48)
PWR_VDDQ_VDD: length 8.7
  TOP w0.508: PR181.1 162.82,212.39 v2(161.87,213.35)
  BOTTOM w0.203: PU40.11 167.08,214.49 166.76,214.17
  BOTTOM w0.508: v2(161.87,213.35) 161.74,213.47 PR183.1 PC87.1 PC86.1 164.15,214.43 164.6,213.98 v3(165.42,213.98) 166.57,213.98 166.76,214.17
PWR_VDDQ_VDDP: length 11.6
  TOP w0.508: PR184.1 162.57,208.29 PC92.1 164.23,209.41 v1(164.28,209.46) 164.28,211.7 163.65,212.33 163.65,213.6 v2(164.79,214.74)
  BOTTOM w0.203: v2(164.79,214.74) 166.08,214.74 166.56,215.22 PU40.12
PWR_VDDQ_VTTIN: length 9.7
  BOTTOM w0.203: PU40.19 169.03,218.22 169.23,218.43
  BOTTOM w0.508: 169.23,218.43 170.38,219.57 v3(170.38,219.76) 170.38,219.82 169.79,220.41 PC94.1 169.79,221.93 168.85,222.87 PR188.2 PR189.2
PWR_VDDQ_VTTREF: length 7.3
  BOTTOM w0.203: PU40.4 170.66,215.22 170.88,215
  BOTTOM w0.254: v3(176.19,213.5) 176.19,213.7 174.69,215.2 PR196.2 172.48,215.2 PC98.1 171.9,214.62 171.27,214.62 171.24,214.64 171.22,214.64 170.91,214.95 170.91,214.97 170.88,215
PWR_VGA_CORE_BOOT1: length 4.3
  TOP w0.305: U9619.1 104.26,103.95
  TOP w0.508: PR43.1 106.55,106.21 105.8,105.46 105.8,105.33 105.48,105.02 105.35,105.02 v1(105.1,104.76) 105.08,104.76 104.26,103.95
PWR_VGA_CORE_BOOT1_1: length 2.8
  TOP w0.508: PR43.2 108.91,106.11 108.91,105.27 v1(109.04,105.14) 108.91,105.02 PC19.1
PWR_VGA_CORE_COMP: length 5.9
  TOP w0.254: U9619.12 100.57,100.34 100.42,100.19 99.64,100.19 99.23,99.78 99.23,99.38 v1(98.98,99.12) 98.49,99.15 98.45,99.15 97.57,100.03 PC8303.1 97.53,100.27 96.96,100.84 PR8326.2
PWR_VGA_CORE_COMP_1: length 2.4
  TOP w0.254: PC8309.2 96.55,102.72 97.17,102.1 97.17,101.97 97.3,101.84 v1(97.3,101.71) 97.27,101.71 97.15,101.59 96.47,101.59 PR8326.1
PWR_VGA_CORE_EN: length 11.9
  TOP w0.102: v2(104.03,110.77) 104.32,110.48 PR8325.2 104.32,109.5 103.09,108.27 PR8328.2 102.84,108.02 102.84,106.19 102.23,105.58 PC8501.1 102.23,104.98 102.76,104.44 102.76,104.01 102.81,103.97 U9619.3
  BOTTOM w0.102: v2(104.03,110.77) 104.03,109.66 v3(103.83,109.46) 103.83,108.7 PD8301.A
PWR_VGA_CORE_FB: length 6.9
  TOP w0.254: PR8311.1 PC8309.1 97.47,102.68 98.35,102.68 PR8318.2 98.62,101.54 98.6,101.51 98.6,101.43 98.54,101.38 v1(98.54,101.26) 98.52,101.23 98.52,101.21 98.46,101.14 PC8303.2 98.85,100.27 99.28,100.7 100.12,100.7 100.26,100.84 U9619.11
PWR_VGA_CORE_FBRTN: length 3.3
  TOP w0.254: U9619.10 v2(99.51,101.34)
  BOTTOM w0.254: PR8306.2 98.53,100.19 99.26,100.19 v3(99.51,100.44) v2(99.51,101.34)
PWR_VGA_CORE_FS: length 3.6
  TOP w0.254: U9619.9 100,101.84 v2(99.51,102.32)
  BOTTOM w0.254: v2(99.51,102.32) 99.66,102.48 v3(100.53,102.48) 100.65,102.35 PR8334.1
PWR_VGA_CORE_LGATE1: length 25.6
  TOP w0.305: v4(105.56,101.97) 105.19,102.34 U9619.23
  TOP w0.508: PR8312.1 106.7,101.31 v1(106.47,101.54) 106.04,101.97 v4(105.56,101.97)
  TOP w1.016: v4(122.24,95.36) 122.24,95.36 PU5202.4
  L4 w1.016: v4(122.24,95.36) v4(116.15,95.36) 111.6,95.36 105.56,101.41 v4(105.56,101.97)
  BOTTOM w0.762: v4(116.15,95.36) 116.15,95.36 PU5204.4
PWR_VGA_CORE_PGOOD: length 6.5
  TOP w0.254: PR8315.2 105.82,96.57 106.14,96.89 106.14,97.38 v1(106.08,97.44) 106.08,97.45 105.83,97.7 104.96,97.7 PR8304.1 104.84,97.71 104.84,98.67 104.43,99.08 103.14,99.08 102.81,99.42 U9619.16
PWR_VGA_CORE_PHASE1: length 19.6
  TOP w0.305: U9619.24 104.57,102.84 105.1,103.36 v4(105.48,103.36)
  TOP w1.016: PC19.2 106.5,103.36 v4(105.48,103.36) ; PU1.1 112.85,101.08 113.23,101.46 v4(115.39,101.46) 114.88,100.95 PR114.2
  L4 w1.016: v4(115.39,101.46) 113.78,101.46 113.15,100.82 108.48,100.82 105.96,103.34 105.5,103.34 v4(105.48,103.36)
  vias: v3(110.31,104.51) v3(118.69,107.05) v4(111.91,105.65) v4(111.93,104.13) v4(112.72,107.3) v4(113.43,105.57) v4(113.61,104.25) v4(113.84,107.3) v4(114.72,103.75) v4(115.36,107.22) v4(115.39,105.52) v4(115.51,102.73) v4(117.32,107.17) v4(120.08,107.17) v4(121.48,107.17) v4(121.48,106.16) v4(121.48,104.76) v4(121.48,103.36)
PWR_VGA_CORE_PSI: length 7.8
  TOP w0.305: U9619.4 102.31,104.12 102.3,104.13 v2(102.3,104.25)
  BOTTOM w0.508: v2(102.3,104.25) 101.54,104.25 101.47,104.33 v3(101.42,104.33) 101.42,104.38 100.84,104.95 PC8315.1 PR8335.1 100.84,106.29 100.65,106.48 100.65,108.05 PR8308.2 99.75,108.2 99.26,107.71 R80016.1
PWR_VGA_CORE_PVCC: length 6.6
  TOP w0.305: U9619.21 104.76,101.34 105.12,100.98 105.12,100.78
  TOP w0.508: v2(105.12,100.45) 105.12,100.45 105.12,100.78
  BOTTOM w0.508: PR8313.2 105.61,97.26 104.59,98.27 104.59,99.38 PC8302.1 104.08,99.88 104.08,100.54 v3(104.21,100.67) 104.43,100.45 v2(105.12,100.45)
PWR_VGA_CORE_REFIN: length 5.7
  TOP w0.254: U9619.7 100.65,103.65 v1(99.66,104.64) 99.35,104.95 PC8317.1 97.88,104.98 PR8305.2 97.15,105.41 PR8316.1
PWR_VGA_CORE_SENCE+: length 8.4
  TOP w0.127: GPU1.F2 91.19,104.32 91.54,103.96 91.93,103.96 91.95,103.99 92.5,103.99 92.75,103.75
  TOP w0.254: v2(93.16,103.1) 93.16,103.33 92.75,103.75
  BOTTOM w0.254: v2(93.16,103.1) 93.16,103.2 93.65,103.68 94.49,103.68 95.55,102.63 95.64,102.54 PR8329.2 PR8317.1 97.21,102.17 v3(97.21,101.64)
PWR_VGA_CORE_SENCE-: length 9.2
  TOP w0.127: 93.03,104 92.71,104.32 GPU1.F1
  TOP w0.254: v2(93.86,103.18) 93.03,104
  BOTTOM w0.254: v3(98.42,101.46) 97.52,100.56 PR8306.1 96.44,101.4 PR8333.1 95.89,101.4 95.17,102.12 95.17,102.47 94.33,103.3 93.98,103.3 v2(93.86,103.18)
PWR_VGA_CORE_SENSE+_1: length 4
  TOP w0.254: PR8311.2 96.55,104.29 96.77,104.51 v2(96.84,104.51)
  BOTTOM w0.254: v3(95.93,104.54) 96.16,104.54 96.17,104.53 96.72,104.53 96.74,104.51 v2(96.84,104.51) PR8317.2 PC8312.2
PWR_VGA_CORE_SNB: length 2.5
  TOP w0.508: PC5246.1 114.87,96.04 114.87,96.48 v1(114.88,96.49) 114.87,96.5 114.87,96.94 PR114.1
PWR_VGA_CORE_TALERT#: length 4.8
  TOP w0.305: U9619.14 101.81,98.78 102.31,98.28
  TOP w0.508: PR8319.2 PR8327.1 103.38,96.98 103.26,97.11 103.26,97.29 102.98,97.56 v1(102.98,97.68) 102.9,97.68 102.31,98.27 102.31,98.28
PWR_VGA_CORE_TSNS: length 10.9
  TOP w0.305: 101.31,98.52 U9619.13
  TOP w0.508: PC8307.1 102.62,95.17 104.11,93.69 106.03,93.69 PR60.1 ; PC8307.1 102.43,97.04 101.31,98.16 v1(101.31,98.28) 101.31,98.52 ; PC8307.1 101.48,95.17 PR8323.2
PWR_VGA_CORE_UGATE1: length 3.4
  TOP w0.305: v1(103.45,105.02) 103.45,104.76 103.32,104.63 103.32,104.18 103.31,104.16 U9619.2
  TOP w1.016: v1(103.45,105.02) 103.92,105.49 103.92,105.56 104.64,106.28 PR8302.1
PWR_VGA_CORE_UGATE1_R: length 18.3
  TOP w0.762: v4(109.04,102.6) 108.65,102.22 PU1.4
  TOP w1.016: v4(106.32,107.89) 105.94,108.27 PR8302.2
  L4 w1.016: v4(112.59,102.6) v4(109.04,102.6) 106.32,105.32 v4(106.32,107.89)
  BOTTOM w0.508: v3(114.5,99.58) PR8331.1 112.91,100.63 PU5203.4
  BOTTOM w0.762: PU5203.4 112.46,102.48 v4(112.59,102.6)
PWR_VGA_CORE_VCC: length 6.4
  TOP w0.305: U9619.15 102.31,99.21 v2(102.97,98.55)
  BOTTOM w0.508: v2(102.97,98.55) 102.97,97.9 103.32,97.55 PC8308.1 102.86,96.89 102.3,97.45 v3(101.77,97.45) 101.67,97.34 PR8330.2
PWR_VGA_CORE_VID: length 3.5
  TOP w0.254: PR8324.1 PC8311.1 101.34,105.71 v1(101.34,104.76) 101.34,104.46 101.81,103.99 U9619.5
PWR_VGA_CORE_VIDBUF: length 6.7
  TOP w0.254: U9619.6 101.31,103.89 99.76,105.44 99.76,106.5 99.05,107.21 v1(99.05,107.68) 99,107.72 99,107.77 PR8303.1
PWR_VGA_CORE_VREF: length 12.8
  TOP w0.254: v2(99.76,99.55) 100.07,99.55 100.67,98.95 100.67,97.51 101.03,97.15 101.03,97.14 PR8323.1 ; v2(99.64,103.24) 99.64,103.09 100.39,102.34 U9619.8
  L4 w0.254: v2(99.64,103.24) 98.98,102.58 98.98,100.34 v2(99.76,99.55)
  BOTTOM w0.254: PR8309.1 97.86,104.95 PC8314.1 99.57,104.25 v3(99.69,104.25) 99.74,104.2 99.74,103.34 v2(99.64,103.24)
PWR_VGA_CORE_VREF_1: length 5.9
  TOP w0.254: PR8303.2 99.05,108.83 97.77,107.54 v2(97.77,106.53) 97.77,106.47 97.66,106.36 97.66,106.1 97.73,106.02 PR8305.1
  BOTTOM w0.254: v3(96.67,106.29) 96.92,106.53 v2(97.77,106.53) 97.77,106.47 97.73,106.44 PR8305.1
PWR_VGA_CORE_VREF_2: length 2.9
  TOP w0.254: v1(95.03,106.62) 96.27,106.62 PR8316.2 PR8320.1
PWR_VGA_VRAM_BOOT: length 2.8
  TOP w0.305: PU8602.20 44.26,107.27 44.57,107.58 44.57,107.61 44.9,107.94
  TOP w0.508: PR8618.1 45.03,108.06 44.9,107.94
PWR_VGA_VRAM_BOOT_RC: length 1.3
  TOP w0.508: PC8608.1 PR8618.2
PWR_VGA_VRAM_FB: length 5.4
  TOP w0.305: PU8602.5 41.36,103.38 40.96,102.98 40.96,102.86
  TOP w0.508: 40.96,102.86 40.86,102.86 40.63,102.63 40.24,102.63 PR8621.1 ; v1(40.2,101.71) PR8621.1 ; PR8621.1 39.96,102.48 PC8614.2 PR8620.2
PWR_VGA_VRAM_LX: length 2.2
  TOP w0.305: PU8602.18 45.26,105.47 44.94,105.14 PU8602.25
  vias: v1(37.89,100.01)
PWR_VGA_VRAM_PFM: length 4.4
  TOP w0.305: v1(40.43,105.22) 41.27,104.38 PU8602.3
  TOP w0.508: PR8339.1 PR8338.1 40.14,105.51 v1(40.43,105.22)
PWR_VGA_VRAM_POK: length 135
  TOP w0.102: R80231.2 118.56,46.72 119.58,46.72 120.21,47.36 120.21,48.8 120.55,49.14 120.55,49.73 120,50.28 118.18,50.28 117.44,51.01 116.78,51.01 116.35,51.44 116.35,51.5 115.56,52.3 114.99,52.3 114.32,51.63 113.41,51.63 113.14,51.9 113.14,55.26 v2(108.13,60.27) ; v2(36.29,108.02) 36.29,108.47 36.52,108.7 v1(36.9,108.7) 37.15,108.7 37.98,107.87 PR8623.2 37.99,107.69 PC12174.1 39.49,107.14 39.63,107.14 41.37,105.4 41.94,105.4 PU8602.1
  L4 w0.127: v2(36.29,108.02) 35.86,107.59 35.86,105.88 35.67,105.69 35.67,101.12 34.99,100.44 34.99,97.5 36.26,96.23 36.26,93.8 36.9,93.16 36.9,92.44 37.45,91.9 49.8,91.9 51.29,90.41 52.32,90.41 55.31,87.41 55.31,86.73 57.98,84.06 58.61,84.06 59.25,83.42 59.25,83.17 65.6,76.82 69.41,76.82 70.3,75.93 78.53,75.93 84.65,69.81 84.65,69.1 87.85,65.9 101.26,65.9 103.42,63.74 105.68,63.74 107.77,61.65 107.77,60.69 108.13,60.33 v2(108.13,60.27)
PWR_VGA_VRAM_SNB: length 4.2
  TOP w0.508: PC8610.1 38.22,95.13 36.87,95.13 v1(36.62,95.39) 36.62,95.95 37.36,96.68 PR8615.1
PWR_VGA_VRAM_SS: length 3.6
  TOP w0.305: PU8602.23 41.41,106.2 v1(40.63,106.98)
  TOP w0.508: PC8617.1 39.92,107.69 v1(40.63,106.98)
PWR_VGA_VRAM_TON: length 5.7
  TOP w0.305: 41.96,102.33 PU8602.6
  TOP w0.508: 41.96,102.33 41.96,102.19 40.72,100.95 39.29,100.95 v1(38.85,101.38) 37.8,101.38 PR8617.2
PWR_VGA_VRAM_VCC: length 6
  TOP w0.305: v2(44.01,107.81) 43.76,107.56 PU8602.21
  BOTTOM w0.508: v2(44.01,107.81) 43.63,108.19 PC8615.1 43.62,108.82 42.88,108.82 42.52,109.18 v3(42.52,109.49) 42.52,109.9 42.78,110.16 PR8616.1
PWR_VGT__BST1A: length 3.4
  TOP w0.305: PU19.1 68,263.32 68.19,263.51 v1(68.34,263.51)
  TOP w0.508: PR95.2 68.83,263.51 v1(68.34,263.51)
PWR_VGT_BST1AR: length 3.6
  TOP w0.508: PC45.1 71.7,260.72 71.89,260.91 v1(72.08,260.91) 72.08,262.19 PR95.1
PWR_VGT_BST2A: length 2.7
  TOP w0.305: 91.63,259.32 PU24.1
  TOP w0.356: 91.63,259.32 90.93,259.32 PR105.2
PWR_VGT_BST2AR: length 3.3
  TOP w0.508: PC49.1 v1(90.11,264.15) 89.86,263.89 PR105.1
PWR_VGT_DRH1A: length 21.9
  TOP w0.305: PU19.8 68.9,260.08 69.28,260.46 69.28,260.54 v4(69.38,260.64)
  L3 w1.016: v4(69.38,260.64) 69.39,260.62 70.9,260.62 72.97,258.56 79.7,258.56 82.44,255.81 82.44,253.02 v4(82.31,252.89)
  BOTTOM w0.254: v4(69.38,260.64) 70.07,260.64 v3(70.07,260.64)
  BOTTOM w1.016: PR103.1 v4(82.31,252.89)
PWR_VGT_DRH1A_G: length 11.5
  TOP w0.762: PU18.4 v4(79.06,254.37)
  L3 w1.016: v4(79.06,254.37) 78.87,254.56 v4(73.22,254.56)
  BOTTOM w0.508: PU17.4 74.05,254.56 v4(73.22,254.56) PR101.1 72.21,255.46 v3(72.05,255.61)
  BOTTOM w0.762: v4(79.06,254.37) 80.38,254.37 PR103.2
PWR_VGT_DRH2A: length 35.9
  TOP w0.305: v4(91.59,262.83) 91.59,262.22 92.16,261.64 PU24.8
  TOP w1.016: v4(110.23,249.29) PR107.1
  L3 w1.016: v4(110.23,249.29) 97.35,249.29 95.7,250.94 93.11,250.94 89.6,254.45 89.6,261.48 90.95,262.83 v4(91.59,262.83)
  BOTTOM w0.254: v3(91.59,262.14) v4(91.59,262.83)
PWR_VGT_DRH2A_G: length 16.5
  TOP w0.762: 110.2,254.34 110.2,254.47 110.18,254.49 PU23.4
  TOP w1.016: 110.2,254.34 110.23,254.32 PR107.2 110.28,252.49 111.3,252.49 v4(111.73,252.92)
  L3 w1.016: v4(105.35,256.02) 109.39,256.02 111.63,253.78 111.63,253.02 v4(111.73,252.92)
  BOTTOM w0.254: v3(111.73,251.98) v4(111.73,252.92)
  BOTTOM w0.508: PR108.1 105.16,255.83 v4(105.35,256.02)
  BOTTOM w0.762: v4(105.35,256.02) PU22.4
PWR_VGT_DRVLA1: length 15.9
  TOP w0.305: PU19.5 66.5,259.59 v4(65.98,259.07)
  TOP w0.762: PU21.4 v4(64.08,255)
  TOP w1.016: v4(64.08,255) v1(62.91,255)
  L3 w1.016: v4(69.92,255) v4(64.08,255) 63.82,255.26 63.82,257.92 64.97,259.07 v4(65.98,259.07)
  BOTTOM w0.762: PU20.4 v4(69.92,255)
PWR_VGT_DRVLA2: length 7.1
  L3 w1.016: v2(96.34,261.73) v4(102.3,261.73)
  BOTTOM w0.762: PU25.4 v4(102.3,261.73)
  vias: v1(95.17,261.71)
PWR_VGT_EN1A: length 4.4
  TOP w0.254: PU19.3 67,262.59 66.34,263.26 v1(64.84,263.26) 63.51,263.26 PR102.1
PWR_VGT_EN2A: length 3.5
  TOP w0.254: PU24.3 93.16,258.67 92.27,257.79 v1(92.27,257.54) 92.27,257.42 92.02,257.16 PR109.1
PWR_VGT_LX1A: length 22.1
  TOP w0.305: PU19.7 67.5,259.45 68.01,258.94 v4(68.78,258.94)
  TOP w0.508: v4(68.78,258.94) 69.26,258.94 69.64,259.32 PC45.2
  L3 w1.016: v4(68.78,258.94) 69.16,258.56 70.55,258.56 72.33,256.78 79.06,256.78 80.75,255.1 80.75,253.64 79.7,252.59 78.17,252.59 v4(78.05,252.72)
  vias: v1(64.36,247.31) v1(67.76,244.99) v3(67.68,243.75) v3(73.55,246.95) v3(74.57,252.41) v4(65.47,247.89) v4(65.47,246.75) v4(65.47,245.6) v4(66.49,244.21) v4(66.62,247.89) v4(66.62,246.75) v4(66.62,245.6) v4(67.76,247.89) v4(67.76,246.75) v4(68.78,244.21) v4(68.9,247.89) v4(68.9,246.75) v4(68.9,245.6) v4(69.92,244.21) v4(70.05,247.89) v4(70.05,246.75) v4(70.05,245.6) v4(70.55,252.46) v4(70.55,251.32) v4(70.55,250.18) v4(70.94,244.84) v4(70.94,243.7) v4(71.7,252.46) v4(71.7,251.32) v4(71.7,250.18) v4(72.08,244.84) v4(72.08,243.7) v4(72.84,252.46) v4(72.84,251.32) v4(72.84,250.18) v4(73.22,244.84) v4(73.22,243.7) v4(75.76,252.72) v4(75.76,251.57) v4(75.76,250.43) v4(75.76,249.41) v4(76.9,252.72) v4(76.9,251.57) v4(76.9,250.43) v4(76.9,249.41) v4(78.05,251.57) v4(78.05,250.43) v4(78.05,249.41)
PWR_VGT_LX2A: length 30.2
  TOP w0.305: PU24.7 92.66,262.5 v4(92.78,262.62)
  TOP w0.508: v4(92.78,262.62) 92.78,263.89 PC49.2
  L3 w1.016: v4(108.65,251.07) 97.99,251.07 96.46,252.59 93.8,252.59 91.26,255.13 91.26,260.59 92.78,262.11 v4(92.78,262.62)
  vias: v1(104.21,255.59) v3(96.79,251.98) v3(103.68,257.87) v3(109.9,252.64) v4(97.12,254.62) v4(97.12,253.48) v4(98.24,254.62) v4(98.24,253.48) v4(98.24,252.34) v4(99.38,254.62) v4(99.38,253.48) v4(99.38,252.34) v4(100.53,254.62) v4(100.53,253.48) v4(100.53,252.34) v4(101.8,254.62) v4(103.19,256.02) v4(103.19,255) v4(105.61,254.49) v4(105.61,253.35) v4(105.61,252.21) v4(106.75,254.49) v4(106.75,253.35) v4(106.75,252.21) v4(107.89,254.49) v4(107.89,253.35) v4(107.89,252.21) v4(108.91,254.49) v4(108.91,253.35) v4(108.91,252.21)
PWR_VGT_SNB1A: length 2.8
  TOP w0.508: v1(71.85,259.22) 71.38,258.75 PC48.1 71.7,257.86 PR104.2
PWR_VGT_SNB2A: length 3
  TOP w0.508: PR110.2 103.74,260.08 103.29,260.53 103.29,261.59 v1(103.34,261.63) 103.42,261.63 103.51,261.54 PC52.1
PWR_VGT_VCC1A: length 4.9
  TOP w0.305: PU19.4 64.78,262.12 PC47.1
  TOP w0.508: PC47.1 64.78,261.24 PR98.2 v1(62.62,260.79)
PWR_VGT_VCC2A: length 5.6
  TOP w0.305: PU24.4 93.66,258.44 93.29,258.08 PC51.1
  TOP w0.508: PC51.1 94.42,257.22 PR106.2 95.07,257.87 v1(95.07,259.21)
PWR_VGT_VIN:
  vias: v3(77.82,262.19) v3(80.31,256.73) v3(84.55,262.27) v4(79.83,260.72) v4(80.46,259.32) v4(80.97,260.72) v4(81.6,259.32) v4(81.6,258.3) v4(82.11,260.72) v4(82.75,259.32) v4(82.75,258.3) v4(83.25,260.72) v4(83.89,259.32) v4(83.89,258.3) v4(84.52,260.72) v4(85.79,260.72)
PWR_VGT_VIN2:
  vias: v1(106.55,264.6) v1(118.33,264.53) v3(110.15,263.94) v3(115.41,257.69) v3(120.85,264.07) v4(106.11,263.38) v4(107.26,263.38) v4(112.85,260.46) v4(112.85,259.32) v4(112.85,258.18) v4(113.99,260.46) v4(113.99,259.32) v4(113.99,258.18) v4(117.16,260.46) v4(117.16,259.32) v4(117.16,258.18) v4(118.05,263.26) v4(118.43,260.46) v4(118.43,259.32) v4(118.43,258.18) v4(119.32,263.26)
PWR_VTT_EN: length 3
  TOP w0.102: R31.1 v1(109.71,238.49) 109.71,238.63 110.43,239.36 Q1228.5
PWRBTN_N: length 309.3
  TOP w0.102: C526.2 22.47,15.54 v2(22.56,15.63) 23.36,16.43 R746.2 ; v2(42.13,114.14) 42.13,118.21 41.24,119.09 41.24,123.07 41.6,123.43 R1792.1 ; v2(150.31,52.38) 150.31,51.89 150.83,51.37 152.58,51.37 153.15,51.95 153.15,52.98 153.7,53.53 157.37,53.53 158.63,54.79 R1787.1 158.63,56.37 R139.1 ; v2(98.54,59.77) 98.57,59.8 R332.1
  L3 w0.127: v2(91.38,66.53) 91.35,66.53 89.9,65.08 89.9,64.69 90.59,63.99 91.51,63.99 92.08,64.57 94.18,64.57 94.9,63.85 94.9,63.27 91.47,59.84 91.47,58.74 89.86,57.12 88.37,57.12 87.52,56.27 85.48,56.27 84.57,55.36 83.64,55.36 79.74,51.46 79.53,51.46 78.72,50.65 68.56,50.65 67.78,51.42 51.41,51.42 50.39,52.44 44.61,52.44 43.43,53.62 38.88,53.62 38.26,52.99 38.26,52.99 37.13,51.87 35.2,51.87 35.12,51.95 32.49,51.95 30.5,49.96 30.5,48.31 24.9,42.71 24.9,17.97 v2(22.56,15.63)
  L4 w0.127: v2(91.38,66.53) 91.14,66.29 87.99,66.29 85.67,68.62 85.67,69.34 78.69,76.31 76.4,76.31 74.75,77.96 64.99,77.96 63.37,79.58 63.37,79.84 58.59,84.62 57.96,84.62 55.82,86.76 55.82,87.51 50.29,93.04 47.5,93.04 46.74,92.28 37.6,92.28 37.28,92.6 37.28,93.32 36.65,93.96 36.65,96.39 35.38,97.66 35.38,100.29 36.05,100.96 36.05,105.43 36.24,105.63 36.24,107.15 37.12,108.03 37.12,110.58 39.21,112.67 40.67,112.67 v2(42.13,114.14) ; v2(126.23,49.64) 125.76,49.17 124.91,49.17 124.4,49.68 121,49.68 120.39,49.07 113.71,49.07 113.06,49.72 112.26,49.72 111.63,50.35 111.63,50.91 111.19,51.34 111.19,53.18 108.75,55.62 105.46,55.62 102.68,58.39 99.91,58.39 v2(98.54,59.77)
  BOTTOM w0.102: v2(98.54,59.77) 98.19,59.77 95.82,62.14 93.35,62.14 92.63,62.86 92.63,65.29 91.39,66.53 v2(91.38,66.53) ; v2(150.31,52.38) 149.6,52.38 149.01,51.8 128.47,51.8 v3(127.7,51.04) 126.31,49.64 v2(126.23,49.64)
PWRBTN_N_CN: length 1.2
  TOP w0.102: R1787.2 159.63,55.24 TP224.1
PWRCN_DET_N: length 344.7
  TOP w0.102: PWRCN1.5 36.03,18.42 34.7,19.75 29.48,19.75 27.04,17.31 v1(25.49,17.31) 25.49,17.89 v2(25.88,18.27) ; U2.AA44 140.35,88.5 140.35,88.71 140.12,88.94 140.12,90.5 140.3,90.68 140.3,94.6 140.12,94.78 140.12,95.33 140.23,95.43 140.23,96.76 140.81,97.34 140.81,98.51 142.72,100.42 v2(142.94,100.42)
  L3 w0.127: v2(37.94,50.53) 37.9,50.57 33.04,50.57 32.7,50.22 32.7,49.39 29.95,46.65 29.95,46.13 25.68,41.86 25.68,18.46 v2(25.88,18.27) ; v2(160.85,16.95) 161.7,17.8 161.7,29.64 162.34,30.27 162.34,30.66 162.25,30.75 162.25,38.25 165.93,41.93 165.93,43.51 166.69,44.28 166.69,47.87 172.65,53.82 172.65,59.7 172.56,59.79 172.56,68.12 173.93,69.49 173.93,71.16 179.75,76.97 179.75,79.78 185.21,85.24 185.94,85.24 186.97,86.28 186.97,87.53 v2(186.38,88.12)
  L4 w0.127: v2(37.94,50.53) 38,50.48 38.49,50.48 40.9,48.07 41.88,48.07 43.11,46.84 46.66,46.84 48.07,48.24 49.33,48.25 49.47,48.25 50.28,49.06 61,49.06 64.14,45.92 65.01,45.92 65.05,45.95 75.98,45.95 76.01,45.92 103.17,45.92 106.86,42.23 106.86,41.47 108.22,40.11 108.22,39.47 112.52,35.18 112.52,32.27 117.4,27.39 121.66,27.39 122.97,26.08 125.38,26.08 126.49,24.98 134.88,24.98 139.64,20.22 144.55,20.22 145.64,19.12 149.84,19.12 152.01,16.95 v2(160.85,16.95)
  BOTTOM w0.102: v2(25.88,18.27) 25.75,18.15 D5214.2 ; v2(142.94,100.42) 143.9,100.42 R79951.2 146.35,102.87 v3(147.54,102.87) 154.59,102.87 157.19,100.27 170.53,100.27 178.6,92.19 178.6,91.27 182.23,87.64 185.9,87.64 v2(186.38,88.12)
PWRGD_3V: length 328.8
  TOP w0.102: v2(55.31,131.25) 55.24,131.18 55.24,131.1 53.59,129.45 48.85,129.45 R1791.1 ; R338.1 91.7,59.68 R339.1 C201.1 R336.2 90.11,62.72 89.9,62.93 89.9,66.8 91.17,68.06 v2(91.38,68.06) ; R155.1 152.96,57.92 151.99,56.94 151.99,56.27 152.09,56.16 152.09,54.74 151.57,54.22 149.99,54.22 147.68,51.9 131.46,51.9 v2(130.9,51.34) ; v2(147.55,117.59) 141.29,117.59 138.68,120.2 122.89,120.2 120.92,122.18 120.47,122.18 120.22,121.93 119.84,121.93 119.45,122.33 v2(119.45,122.9)
  L3 w0.127: v2(55.31,131.25) 60.73,131.25 62.16,129.82 73.96,129.82 76.02,131.88 76.02,132.83 77.78,134.59 78.59,134.59 80.68,132.51 88.87,132.51 90.33,131.05 102.81,131.05 110.97,122.9 v2(119.45,122.9)
  L4 w0.127: v2(147.55,117.59) 147.55,107.35 154.34,100.57 154.34,98.12 v2(153.99,97.77) ; v2(172.33,51.94) 172.33,52.01 170.79,53.54 157.07,53.54 153.06,49.53 147.52,49.53 145.71,51.34 v2(130.9,51.34) 130.67,51.58 122.82,51.58 121.58,52.82 117.16,52.82 113.86,56.11 113.86,56.62 111.57,58.91 111.24,58.91 110.52,59.63 110.52,60.22 109.12,61.62 109.12,64.33 108.62,64.83 107.47,64.83 106.75,65.56 104.93,65.56 103.08,67.41 99.79,67.41 99.14,68.06 98.24,68.06 97.77,68.53 95.79,68.53 95.08,67.82 91.62,67.82 v2(91.38,68.06)
  BOTTOM w0.102: v2(172.33,51.94) 171.95,52.32 171.95,57.63 172.83,58.5 172.83,67.36 174.47,69 174.47,74.64 v3(174.44,74.66) 175.15,75.37 175.15,78.22 171.62,81.75 171.62,91.58 170.38,92.82 166.46,92.82 v3(166.19,92.54) 166.03,92.39 158.3,92.39 R79943.1 156.15,94.54 Q3.G 155.1,96.92 154.5,97.52 154.37,97.52 154.12,97.77 v2(153.99,97.77)
PWRGD_3V_B: length 8.2
  TOP w0.102: v2(152.98,99.58) 153,99.61 153,101.8 Q2.B 152.62,102.69 R117.2
  BOTTOM w0.102: Q3.D 154.12,96.76 153.49,97.4 v3(153.49,98.46) 153.49,99.07 v2(152.98,99.58)
PWRGD_3V_B_1: length 4.2
  TOP w0.102: Q10.5 94.94,58.34 R337.2 ; Q10.6 95.59,58.36 R337.2 ; R337.2 95.26,57.71 v1(95.88,57.09)
PWRGD_3V_C: length 15.3
  TOP w0.102: v2(150.21,95.77) 150.69,95.77 151.29,96.37 Q4.G 151.59,96.44 152.67,95.36 v1(152.93,95.36) 153.66,96.1 153.66,97.04 152.84,97.86 152.84,98.93 151.38,100.39 Q2.C 148.94,100.53 R118.2 C147.1
  BOTTOM w0.102: v2(150.21,95.77) 150.21,96.33 150.09,96.44 Q1.G
PWRGD_3V_LL: length 5
  TOP w0.102: Q10.3 94.29,60.8 93.54,60.06 93.03,60.06 92.65,59.68 v1(92.65,58.53) 92.4,58.28 92.08,58.28 R338.2
PWRGD_PS_L: length 7.8
  BOTTOM w0.102: R288.2 120,57.35 v3(119.83,57.19) 119.03,57.19 C189.1 119.68,56.21 R293.1 120.48,56.21 121.04,56.77 121.62,56.77 122.85,58 Q6.2
PWRGD_PS_L1: length 5.9
  TOP w0.102: R287.2 125.04,59.93 v2(125.04,59.37)
  BOTTOM w0.102: Q6.5 122.85,59.96 123.01,59.8 123.39,59.8 123.5,59.92 Q6.6 124.64,60.58 v3(125.04,60.18) v2(125.04,59.37)
PWRGD_PS_L2: length 7.6
  BOTTOM w0.102: R292.1 123.68,57.22 v3(124.15,56.76) 124.48,56.76 125.11,57.39 125.11,58.29 123.99,59.42 122.4,59.42 122.2,59.22 Q6.3
PWROK3_1: length 4
  TOP w0.102: U109.29 120.13,62.01 121.35,63.23 v1(121.61,63.23) 122.05,63.68 R298.2
PWROK3_1_R: length 43.6
  TOP w0.102: v2(94.43,63.65) 94.43,63.36 94.18,63.11 93.29,63.11 92.91,62.72 R336.1 R335.2 ; v2(122.95,61.63) 122.93,61.63 122.93,61.63 123.06,61.76 123.06,62.36 R298.1
  BOTTOM w0.102: v2(122.95,61.63) 122.93,61.63 122.93,61.63 122.93,62.72 120.89,64.76 117.03,64.76 116.52,64.25 v3(115.77,64.25) 115.73,64.25 114.12,65.86 114.12,68.14 113.71,68.54 111.56,68.54 105.66,62.64 105.66,62.27 105.56,62.17 105.56,62.16 105.1,61.71 102.44,61.71 101.05,60.31 99.72,60.31 99.04,60.99 98.57,60.99 95.9,63.65 v2(94.43,63.65)
