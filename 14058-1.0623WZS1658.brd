# Allegro board 14058-1.0623WZS1658.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SCALAR_PC_SW1: length 3.6
  BOTTOM w0.254: Q9602.E 45.25,39.23 v3(46.3,39.23) 46.79,39.23 47.5,39.94 R9601.2
SCALAR_PC_SW2: length 4.5
  BOTTOM w0.254: Q9602.B 45.44,41.74 45.92,41.26 v3(46.17,41.26) 47.38,41.26 R9602.2 47.5,41.77 R9603.1
SCALAR_PC_SW3: length 7.3
  BOTTOM w0.254: Q9601.G 39.59,38.34 C12171.1 40.39,38.4 R9604.1 40.39,39.74 39.95,40.18 39.95,40.63 v3(40.2,40.88) 40.58,40.88 40.9,40.56 R9605.1 41.41,40.75 Q9602.C
SCALAR_PC_SW4: length 5.8
  BOTTOM w0.254: 49.69,43.96 49.98,43.67 v3(49.98,43.29) 49.69,43 48.34,43 47.87,42.53 R9603.2 ; 49.69,43.96 49.8,44.08 49.8,44.37 49.56,44.61 PQ5007.5 ; 49.69,43.96 PQ5007.6
SCALAR_PC_SW5: length 9.5
  BOTTOM w0.254: PQ5007.3 46.96,45.66 46.75,45.86 45.66,45.86 45.38,45.58 45.38,44.18 45.46,44.1 45.46,44.05 v3(45.52,44) 45.46,43.94 45.46,43.36 45.38,43.28 45.38,43.27 44.49,42.38 44.11,42.38 43.19,41.45 R9605.2
SCALAR_SIO_PU: length 113.5
  TOP w0.102: v2(108.98,69.46) 109,69.44 109,68.88 108.78,68.66 RN6.1 108.47,69.11 108.24,69.34 108.02,69.34 107.82,69.15 RN6.2 ; R314.2 123.98,57.11 R79820.2 123.58,55.97 R1946.1 124.99,55.23 R304.1 125.8,54.42 v2(125.8,54.29) ; v2(97.2,63.61) 97.2,63.68 96.12,64.76 95.53,64.76 R318.1 93.66,65.44 R305.2 93.6,66.1 R317.2 ; v2(125.42,49.64) 125.42,47.23 v2(125.16,46.98) 124.91,46.72 124.39,46.72 118.8,41.13 116.82,41.13 115.82,40.13 113.72,40.13 113.15,40.7 108.92,40.7 R79638.2 R79637.2
  L3 w0.127: v2(125.42,49.64) 125.42,50.74 125.84,51.16 125.84,54.25 v2(125.8,54.29) ; v2(97.2,63.61) 97.2,63.89 102.9,69.59 102.9,70.18 103.38,70.66 104.11,70.66 v2(104.28,70.83)
  L4 w0.127: v2(108.98,69.46) 111.54,66.9 111.54,64.58 112.33,63.79 112.33,61.99 117.11,57.21 118.36,57.21 120.34,55.23 124.86,55.23 v2(125.8,54.29)
  BOTTOM w0.102: v2(125.16,46.98) 124.66,46.47 123.26,46.47 122.62,47.1 121.66,47.1 120.92,46.37 120.63,46.37 111.38,46.37 108.4,49.35 R80236.2 ; R277.1 97.61,62.72 97.2,63.13 v2(97.2,63.61) ; v2(125.42,49.64) 125.16,49.9 R80244.2 123.83,49.14 122.85,49.14 121.63,50.35 v3(121.1,50.35) R316.2 ; v2(104.28,70.83) 104.37,70.83 105.74,69.46 v2(108.98,69.46)
SD_CD#: length 18.2
  TOP w0.102: v2(181.6,146.47) 181.55,146.47 181.53,146.49 MEMCD1.CD
  L3 w0.127: v2(181.6,146.47) 181.13,146 181.13,142.41 184.08,139.47 188.63,139.47 v2(189.68,138.42)
  BOTTOM w0.102: v2(181.6,146.47) 180.82,146.47 v3(180.66,146.62) ; U14.30 190.39,139.13 v2(189.68,138.42)
SD_CLK_C_1: length 22.1
  TOP w0.102: MEMCD1.5 181.6,145.09 v2(181.6,145.1)
  L3 w0.127: v2(181.6,145.1) 183.21,145.1 183.77,145.66 183.77,147.23 183.89,147.36 184.27,147.36 184.4,147.23 184.4,145.66 184.53,145.53 195.27,145.53 195.4,145.4 196.67,145.4 196.84,145.22 v2(196.92,145.22)
  BOTTOM w0.102: v2(181.6,145.1) 181.43,144.93 v3(180.66,144.93) ; v2(196.92,145.22) 196.85,145.22 196.67,145.4 R79846.2
SD_CMD: length 21.6
  TOP w0.102: MEMCD1.2 181.57,138.14 v2(181.6,138.11)
  L3 w0.127: v2(181.6,138.11) 182.24,138.11 182.58,137.77 190.68,137.77 192.5,139.58 193.24,139.58 197.1,143.45 v2(197.81,143.45)
  BOTTOM w0.102: v2(197.81,143.45) 197.73,143.37 R79847.2 ; v3(182.42,138.09) 181.63,138.09 v2(181.6,138.11)
SD_DAT0: length 23
  TOP w0.089: v2(181.63,149.52) 181.4,149.29 MEMCD1.7
  L3 w0.102: v2(181.63,149.52) 182.7,150.58 183.85,150.58 184.15,150.88 184.15,152.23 184.25,152.34 184.65,152.34 184.75,152.23 184.75,150.88 185.05,150.58 185.73,150.58 186.02,150.88 186.02,152.21 186.13,152.31 186.53,152.31 186.63,152.21 186.63,150.88 186.93,150.58 189.62,150.58 192.26,147.94 193.62,147.94 v2(193.79,148.12)
  BOTTOM w0.089: v3(181.6,148.68) 181.6,149.49 v2(181.63,149.52) ; v2(193.79,148.12) 194.03,147.88 R79845.2
SD_DAT1: length 22.9
  TOP w0.089: MEMCD1.8 181.39,150.69 v2(181.63,150.45)
  L3 w0.102: v2(193.21,148.65) 192.83,148.27 192.4,148.27 189.76,150.91 187.07,150.91 186.96,151.01 186.96,152.35 186.67,152.64 185.99,152.64 185.69,152.35 185.69,151.01 185.59,150.91 185.19,150.91 185.08,151.01 185.08,152.37 184.79,152.67 184.11,152.67 183.81,152.37 183.81,151.01 183.71,150.91 182.56,150.91 182.1,150.45 v2(181.63,150.45)
  BOTTOM w0.089: R79844.2 192.94,148.33 193.21,148.6 v2(193.21,148.65) ; v2(181.63,150.45) 181.63,150.46 v3(180.69,150.46)
SD_DAT2: length 22.3
  TOP w0.102: v2(181.63,135.19) 181.48,135.34 MEMCD1.9
  L3 w0.127: v2(181.63,135.19) 183.69,135.19 184.96,136.46 193.01,136.46 196.26,139.71 196.26,140.45 197.19,141.38 v2(197.81,141.38)
  BOTTOM w0.102: v3(181.63,134.35) v2(181.63,135.19) ; R79849.2 197.39,140.96 v2(197.81,141.38)
SD_DAT3: length 22.4
  TOP w0.102: v2(181.6,137.04) 181.6,136.97 181.37,136.74 MEMCD1.1
  L3 w0.127: v2(197.81,142.23) 197.05,142.23 195.76,140.94 195.76,139.75 192.97,136.96 182.76,136.96 182.67,137.04 v2(181.6,137.04)
  BOTTOM w0.102: R79848.2 197.11,142.23 v2(197.81,142.23) ; v2(181.6,137.04) 181.4,136.84 v3(180.74,136.84)
SD_LN0_M: length 19.1
  TOP w0.089: v2(200.91,128.03) 200.67,128.27 200.67,128.75 201.03,129.12 MEMCD1.12
  L4 w0.102: v2(192.93,138.92) 192.93,138.45 193.32,138.06 195.46,138.06 200.65,132.86 200.65,128.29 v2(200.91,128.03)
  BOTTOM w0.089: U14.25 192.36,139.63 192.36,139.04 192.6,138.8 192.81,138.8 v2(192.93,138.92) ; v3(201.34,127.6) 201.34,127.6 v2(200.91,128.03)
SD_LN0_P: length 19.1
  TOP w0.089: MEMCD1.11 199.93,129.11 200.32,128.71 200.32,128.38 v2(199.97,128.03)
  L4 w0.102: v2(192.22,138.29) 192.63,138.29 193.19,137.73 195.32,137.73 200.32,132.73 200.32,128.38 v2(199.97,128.03)
  BOTTOM w0.089: U14.26 192.02,139.63 192.02,138.9 192.22,138.7 v2(192.22,138.29) ; v2(199.97,128.03) 199.56,127.61 v3(199.56,127.57)
SD_LN1_M: length 30.8
  TOP w0.089: v2(197.55,155.56) 197.97,155.14 199.17,155.14 200.35,156.32 200.35,156.83 199.93,157.25 MEMCD1.16
  L4 w0.102: v2(197.05,139.13) 197.32,139.41 198.83,139.41 200.06,140.65 200.06,154.38 199.2,155.24 197.87,155.24 v2(197.55,155.56)
  BOTTOM w0.089: 196.16,139.43 195.4,139.43 194.09,140.74 193.63,140.74 193.63,140.74 U14.23 ; 196.16,139.43 196.75,139.43 v2(197.05,139.13) ; 196.16,139.43 v3(196.16,139.1) ; v2(197.55,155.56) 197.53,155.56 197.16,155.93 v3(197.07,155.93)
SD_LN1_P: length 30.4
  TOP w0.089: MEMCD1.15 200.69,157.18 200.69,156.18 199.31,154.8 197.94,154.8 v2(197.55,154.42)
  L4 w0.102: v2(197.55,154.42) 198.05,154.91 199.07,154.91 199.73,154.24 199.73,152.31 199.51,152.09 199.51,151.78 199.73,151.56 199.73,151.25 199.51,151.03 199.51,150.72 199.73,150.5 199.73,140.78 198.69,139.74 197.38,139.74 v2(197.05,140.07)
  BOTTOM w0.089: U14.22 193.71,141.14 193.77,141.08 194.23,141.08 195.54,139.77 196.75,139.77 v2(197.05,140.07) ; v3(197.13,153.97) 197.55,154.39 v2(197.55,154.42)
SD_VDD2: length 15.5
  TOP w0.762: MEMCD1.14 202.13,156.07 v2(202,155.94)
  L4 w1.016: v2(191.33,146.8) 191.43,146.9 194.61,146.9 197.55,149.85 197.55,151.75 v2(198.57,152.77)
  BOTTOM w0.203: U14.13 191.19,145.9 v3(191.2,145.91) 191.2,146.67 v2(191.33,146.8)
  vias: v3(199.71,152.39)
SD_WAKE#: length 10.4
  TOP w0.102: R79862.1 145.09,95.78 145.09,93.97 v1(144.44,93.32) 143.63,92.51 143.63,89.91 142.69,88.98 142.69,88.68 142.29,88.28 U2.AE44
SD_WAKE#_IC: length 99.2
  TOP w0.102: v2(143.51,101.65) 144.41,100.75 144.41,98.3 R79862.2
  L3 w0.127: v2(143.51,101.65) 143.84,101.65 144.63,102.44 147.91,102.44 148.66,101.69 149.35,101.69 150.1,102.44 155.17,102.44 157.19,100.42 168.42,100.42 169.19,99.64 173.73,99.64 174.81,100.72 174.81,102.13 174.61,102.33 174.61,112.96 174.35,113.21 174.35,128.73 171.65,131.43 v2(171.65,132.32)
  BOTTOM w0.102: v2(171.65,132.32) 171.87,132.55 183.91,132.55 v3(184.9,131.56) 185.01,131.46 187.19,131.46 187.5,131.15 188.74,131.15 188.87,131.28 188.87,132.28 187.72,133.42 187.72,136.75 R79852.1 187.58,138.23 189.02,139.66 U14.32
SD_WP: length 29.9
  TOP w0.102: MEMCD1.WP 179.15,152.09 179.06,152.01 v2(179.04,152.01)
  L3 w0.127: v2(188.94,135.42) 188.87,135.5 186.76,135.5 185.98,134.72 181.43,134.72 178.57,137.59 178.57,151.51 179.04,151.98 v2(179.04,152.01)
  BOTTOM w0.102: v3(179.04,152.92) v2(179.04,152.01) ; R79851.2 189.31,135.79 v2(188.94,135.42)
SDIN: length 55.4
  TOP w0.102: R9502.2 65.46,6.32 65.09,6.69 v1(65.09,6.72) 65.04,6.77 64.41,6.77 63.8,6.16 63.24,6.16 62.32,7.07 60.29,7.07 58.62,8.75 v2(58.62,9.36) ; v2(36.39,29.7) 36.85,29.25 36.85,28.73 36.51,28.39 SCA1.116
  L4 w0.127: v2(36.39,29.7) 36.39,29.63 36.86,29.16 36.86,28.43 35.34,26.9 35.34,19.3 40.36,14.28 45.25,14.28 46.95,15.98 48.94,15.98 49.96,17 53.63,17 59.09,11.55 59.09,9.83 v2(58.62,9.36)
SDIN_1: length 3.9
  TOP w0.102: R9502.1 64.34,5.42 v1(63.26,5.42) 62.05,5.42 61.54,5.93 61.54,6.46
SDOUT: length 30.4
  TOP w0.102: R9506.1 v2(52.77,10.53) ; SCA1.117 37.01,26.02 37.03,26.01 v2(37.03,25.51)
  L3 w0.127: v2(37.03,25.51) 37.03,25.39 37.29,25.12 37.29,21.84 37.28,21.83 37.28,20.32 39.2,18.41 39.2,17.25 40.2,16.24 v2(40.2,15.38)
  BOTTOM w0.102: v2(40.2,15.38) 41.04,16.22 44.09,16.22 45.18,15.13 v3(45.9,15.13) 46.86,15.13 47.25,15.52 48.67,15.52 50.41,13.78 50.91,13.78 52.34,12.34 52.34,11.71 52.77,11.28 v2(52.77,10.53)
SDREG2: length 3.2
  BOTTOM w0.203: U14.24 193.08,140.1 193.49,139.69
  BOTTOM w0.508: C12156.2 v3(194.52,139.28) 194.11,139.69 193.49,139.69
SENSE_B: length 5.3
  TOP w0.102: U9.33 182.17,60.04 182.75,60.62 183.97,60.62 v1(184.19,60.84) 184.42,61.07 R366.2 R365.2
SENSEA: length 3.4
  TOP w0.102: R79936.2 183.43,62.11 v1(183.03,61.71) 183.03,61.36 182.1,60.44 U9.34
SENSEA_D: length 7.2
  TOP w0.102: Q7.D 186.19,58.47 v2(186.38,58.28) ; v2(185.06,62.93) 184.85,62.72 184.85,62.15 R79936.1
  BOTTOM w0.102: v2(186.38,58.28) 185.3,59.36 v3(185.3,61.02) 185.3,62.66 185.06,62.9 v2(185.06,62.93)
SER_IRQ: length 10.1
  TOP w0.102: v5(150.87,74.28) 150.83,74.28 150.48,74.63 150.26,74.63 U2.BA17
  BOTTOM w0.102: R200.1 158.25,73.14 157.23,73.14 R197.2 156.68,73.61 v3(155.64,73.61) 155.61,73.61 154.61,74.61 152.8,74.61 152.62,74.79 151.62,74.79 151.44,74.61 151.2,74.61 v5(150.87,74.28)
SER_IRQ_LT_R: length 66.4
  TOP w0.102: U109.36 116.58,65.5 v2(116.02,66.05) 115.26,66.81 R264.1
  BOTTOM w0.102: R200.2 160.22,73.07 v3(160.22,72.63) 160.22,72.29 159.77,71.84 159.77,71.17 160.25,70.69 160.5,70.69 162.25,68.94 162.25,68.39 163.12,67.52 163.12,64.38 161.16,62.42 160.91,62.42 160.79,62.29 154.94,62.29 154.46,62.77 151.67,62.77 151.31,63.13 148.08,63.13 145.56,60.62 141.37,60.62 140.58,59.83 128.52,59.83 127.74,60.62 126.93,60.62 123.98,63.56 123.81,63.56 121.32,66.05 v2(116.02,66.05)
SHDN_MUTE_AP_CTL: length 6.9
  TOP w0.102: v1(45.26,51.6) 45.26,50.57 R9554.1 45.53,50.22 45.53,48.25 44.95,47.67 44.95,46.23 44.68,45.95 SCA1.36
SIDE_USB3_RX1+: length 11.1
  TOP w0.102: L20.3 185.14,114.63 185.39,114.37 185.66,114.37 186.19,114.9 186.46,114.9 186.59,115.04 U15.9 U15.2 188.43,115.04 188.56,114.9 189.49,114.9 190.37,114.03 192.86,114.03 193.74,113.15 194.02,113.15 194.12,113.25 SSUSB1.6
SIDE_USB3_RX1-: length 11.1
  TOP w0.102: L20.2 185.17,113.95 185.39,114.16 185.75,114.16 186.28,114.69 186.48,114.69 186.61,114.56 U15.10 U15.1 188.43,114.56 188.56,114.69 189.41,114.69 190.28,113.82 192.77,113.82 193.65,112.93 194.02,112.93 194.12,112.83 SSUSB1.5
SIDE_USB3_RX2+: length 10.3
  TOP w0.102: SSUSB2.6 194.12,91.75 194.02,91.65 193.83,91.65 193.2,92.28 192.56,92.28 190.76,94.08 190.47,94.08 190.33,94.21 U16.2 U16.9 188.47,94.21 188.33,94.08 187.94,94.08 187.05,93.18 186.7,93.18 186.47,93.42 L18.3
SIDE_USB3_RX2-: length 10.3
  TOP w0.102: SSUSB2.5 194.12,91.33 194.02,91.43 193.74,91.43 193.11,92.06 192.47,92.06 190.68,93.86 190.47,93.86 190.33,93.73 U16.1 U16.10 188.49,93.73 188.36,93.86 188.03,93.86 187.14,92.97 186.7,92.97 186.47,92.74 L18.2
SIDE_USB3_TX1+: length 11.4
  TOP w0.102: SSUSB1.9 194.12,119.25 194.02,119.15 193.6,119.15 192.77,118.31 191.62,118.31 189.73,116.42 188.56,116.42 188.43,116.56 U15.5 U15.6 186.64,116.56 186.51,116.42 186.12,116.42 185.87,116.68 185.41,116.68 185.17,116.91 L19.3
SIDE_USB3_TX1-: length 11.4
  TOP w0.102: SSUSB1.8 194.12,118.83 194.02,118.93 193.69,118.93 192.86,118.1 191.71,118.1 189.82,116.21 188.56,116.21 188.43,116.08 U15.4 U15.7 186.64,116.08 186.51,116.21 186.03,116.21 185.78,116.46 185.43,116.46 185.2,116.23 L19.2
SIDE_USB3_TX2+: length 9.9
  TOP w0.102: SSUSB2.9 194.12,97.75 194.02,97.65 193.69,97.65 192.88,96.84 192.37,96.84 191.13,95.6 190.47,95.6 190.33,95.73 U16.5 U16.6 188.44,95.73 188.31,95.59 187.55,95.59 187.29,95.85 186.7,95.85 186.47,96.08 L17.3
SIDE_USB3_TX2-: length 9.9
  TOP w0.102: L17.2 186.49,95.4 186.73,95.64 187.2,95.64 187.46,95.38 188.32,95.38 188.45,95.25 U16.7 U16.4 190.33,95.25 190.47,95.38 191.22,95.38 192.46,96.62 192.97,96.62 193.78,97.43 194.02,97.43 194.12,97.33 SSUSB2.8
SIO_AGND: length 32.8
  TOP w0.203: U109.83 102.56,56.01 102.44,55.89 102.65,55.89 102.94,55.61 U109.84
  TOP w0.508: R79619.1 97.68,55.47 97.68,56.16 v2(97.58,56.27) 96.64,56.27 96.34,55.97 96.18,55.97 94.87,54.66 C179.2 R252.2 ; R252.2 C184.2 94.87,52.25 95.64,51.48 v2(95.88,51.48) ; R252.2 95.99,53.45 C181.2 R259.2 ; R79945.2 101.15,56.06 101.29,56.06 101.62,55.74 v2(101.67,55.74) 101.82,55.89 102.44,55.89
  L4 w0.508: v2(97.58,56.27) 101.09,56.27 101.62,55.74 v2(101.67,55.74)
  BOTTOM w0.508: R79620.1 101.22,56.12 101.24,56.12 101.62,55.74 v2(101.67,55.74) 101.73,55.8 R79621.1 ; R272.2 C183.2 102.69,52.88 C188.2 v3(100.78,52.88) 99.75,52.88 97.58,55.05 v2(97.58,56.27) ; R80238.2 C12446.2 95.56,51.17 v2(95.88,51.48)
SIO_AMD SVID_EN: length 4.1
  TOP w0.102: v2(120.62,61.8) 120.26,61.44 120.26,61 120.07,60.81 U109.26
  BOTTOM w0.102: 119.58,61.96 119.58,61.26 R296.1 ; 119.58,61.96 120.09,61.96 120.25,61.8 v2(120.62,61.8) ; 119.58,61.96 v3(119.57,61.96)
SIO_ATXPG: length 6.4
  TOP w0.102: U109.16 120.04,56.81 120.22,56.63 120.9,56.63 121.04,56.77 121.69,56.77 v2(122.08,56.37)
  BOTTOM w0.102: v2(122.08,56.37) 122.12,56.34 122.12,55.61 v3(121.86,55.36) 121.99,55.23 R290.1 122.94,56.28 R292.2
SIO_AVCC3: length 13.7
  TOP w0.203: 103.26,50.59 103.48,50.81 U109.96
  TOP w0.508: C187.1 97.2,47.79 98.95,47.79 99.03,47.87 v1(99.56,47.87) 100.1,47.87 100.23,47.99 100.26,47.99 100.71,48.44 100.79,48.44 100.83,48.47 101.07,48.47 C186.2 101.49,48.82 103.26,50.59
  TOP w1.016: L1.1 95.12,47.48 C187.1
SIO_CE_N: length 44.4
  TOP w0.102: v2(95.6,71.59) 94.87,70.85 R308.1 ; U109.27 118.32,61.21 118.19,61.07 117.4,61.07 116.05,59.72 v2(116.05,57.44)
  L4 w0.127: v2(95.6,71.59) 96.34,70.85 98.77,70.85 100.51,69.12 101.71,69.12 101.72,69.11 106.79,69.11 111.16,64.74 111.16,62.62 116.05,57.74 v2(116.05,57.44)
  BOTTOM w0.102: v2(95.6,71.59) v3(96.49,71.59) 96.67,71.41 96.67,66.24 96.13,65.71 96.13,65.06 95.57,64.5 U6.1
SIO_CLK_DB: length 7.8
  TOP w0.102: R79687.1 113.8,71.55 v1(112.85,70.6) 112.34,70.09 112.34,68.92 112.33,68.91 112.33,66.12 111.77,65.57 U109.48
SIO_COPEN#: length 6.4
  TOP w0.102: U109.65 103.83,63.61 103.19,64.25 103.19,64.95 v1(101.16,66.98) R303.1
SIO_DAT_DB: length 9.4
  TOP w0.102: U109.49 111.38,65.49 112.1,66.22 112.1,69.01 112.11,69.01 112.11,71.1 112.1,71.11 112.1,71.63 v1(112.85,72.38) 113.35,72.88 R79975.1
SIO_DEBUG_RX: length 4.7
  TOP w0.102: v2(114.72,51.14) 114.72,50.95 115.37,50.3 U109.122
  BOTTOM w0.102: R268.1 114.75,49.36 TP104.1 114.75,51.12 v2(114.72,51.14)
SIO_DEBUG_TX: length 5.1
  TOP w0.102: U109.121 114.97,50.2 114.05,51.12 v2(113.96,51.12)
  BOTTOM w0.102: R267.1 114.12,49.52 TP103.1 113.48,50.63 v2(113.96,51.12)
SIO_GPU_EN: length 229.6
  TOP w0.102: D5205.K 99.13,121.65 98.54,122.24 98.54,123.06 98.81,123.33 99.06,123.51 100.76,123.51 101.6,124.34 103.22,124.34 v2(104.59,125.72) ; D5206.K 35.25,105.4 35.78,105.93 v2(37.09,105.93) ; v2(115.37,51.84) 116.18,51.03 U109.124 ; v2(106.93,131.94) 104.97,131.94 104.59,132.32 D5209.K 104.39,134.05 100.83,134.05 100.63,133.84 100.63,132.44 100.3,132.12 99.84,132.12 99.61,132.34 99.49,132.34 v2(99.26,132.57)
  L3 w0.127: v2(95.07,77.71) 94.57,78.21 90.73,78.21 83,70.47 81.45,70.47 81.22,70.24 v2(81.17,70.24)
  L4 w0.127: v2(115.37,51.84) 115.27,51.84 115.09,52.02 114.87,52.02 108.42,58.46 107.46,58.46 106.44,59.48 104.71,59.48 102.06,62.13 92.61,62.13 92.18,62.56 87.78,62.56 87.23,63.1 85.92,63.1 83.64,65.39 83.64,66.68 82.02,68.29 82.02,69.45 81.23,70.24 v2(81.17,70.24) ; v2(99.26,132.57) 97.92,131.24 87.19,131.24 83.01,127.06 59.3,127.06 58.39,126.15 58.39,125.84 58.07,125.53 54.74,125.53 43.27,114.06 43.27,112.07 38.63,107.43 37.66,107.43 37.06,106.83 37.06,105.99 37.09,105.96 v2(37.09,105.93) ; v2(95.07,77.71) 95.4,78.04 95.4,80.2 97.92,82.73 97.92,83.61 100.61,86.31 100.61,92.02 101.25,92.66 101.25,97.46 100.13,98.58 v2(100.13,98.74)
  BOTTOM w0.102: v2(106.93,131.94) 106.93,128.95 v3(106.85,128.86) 104.59,126.61 v2(104.59,125.72) 104.59,124.69 105.25,124.03 105.25,122.37 101.81,118.93 101.81,111.1 103.12,109.79 103.12,109.13 102.48,108.49 102.48,106.62 102.94,106.16 PD8301.K 102.94,103.11 103.9,102.14 103.9,101.4 102.39,99.88 101.9,99.88 100.75,98.74 v2(100.13,98.74) ; R80018.1 116.55,49.86 116.55,50.65 115.37,51.84 v2(115.37,51.84)
SIO_GPU_RST: length 104.7
  TOP w0.102: v2(98.95,109.64) 98.95,109.71 99.08,109.84 99.08,110.54 98.68,110.93 98.68,112.57 98.75,112.63 98.75,112.76 99.27,113.29 U9621.1 ; U109.126 116.98,50.52 v2(117.01,50.56)
  L3 w0.127: v2(81.45,69.35) 82.19,70.09 83.18,70.09 90.8,77.71 v2(92.14,77.71)
  L4 w0.127: v2(98.95,109.64) 96.92,107.6 96.92,105.64 97.69,104.86 97.69,104.15 97.36,103.82 97.36,92.23 97.7,91.89 97.7,89.07 99.09,87.68 99.09,86.94 96.39,84.25 96.39,83.36 92.14,79.11 v2(92.14,77.71) ; v2(117.01,50.56) 116.81,50.56 115.99,51.37 115.16,51.37 114.92,51.61 114.73,51.61 108.27,58.08 105.85,58.08 105.81,58.12 105.04,58.12 103.35,59.8 102.72,59.8 101.63,60.9 101.63,61.27 101.36,61.54 101.15,61.75 92.46,61.75 92.02,62.18 88.98,62.18 88.78,61.97 86.51,61.97 82.11,66.38 82.11,67.45 81.45,68.11 v2(81.45,69.35)
  BOTTOM w0.102: R79922.1 118.81,49.07 v3(118.08,49.8) 117.77,49.8 v2(117.01,50.56)
SIO_GREEN: length 120.7
  TOP w0.203: v2(121.46,59.17) 121.43,59.2 120.68,59.2 120.28,59.61 U109.23
  TOP w0.254: Q9646.2 Q9646.5 41.47,6.02 R80202.2 42.55,5.89 42.87,6.21 v2(42.87,7.3)
  L3 w0.254: v2(42.87,7.3) 45.32,7.3 48.84,10.81 48.84,12.49 50.2,13.85 50.97,13.85 51.77,13.05 55.28,13.05 63.06,20.83 63.06,24.83 63.95,25.72 63.95,28.37 68.13,32.55 77.81,32.55 79.73,34.47 86.8,34.47 89.76,37.43 89.76,42.42 91.82,44.47 102.85,44.47 104.1,44.47 104.1,44.47 105.79,44.47 111.95,50.63 111.95,50.92 112.26,51.24 112.26,52.72 113.78,54.23 116.57,54.23 116.9,53.91 117.96,53.91 118.92,54.86 118.92,57.52 120.63,59.23 121.4,59.23 v2(121.46,59.17)
  BOTTOM w0.254: v3(43.76,7.73) 43.33,7.3 v2(42.87,7.3)
SIO_GREEN_PWM: length 104.2
  TOP w0.203: v2(118.03,56.7) 118.08,56.7 118.37,56.41 U109.15
  L3 w0.254: v2(118.03,56.7) 118.51,56.22 118.51,55.03 117.8,54.31 117.07,54.31 116.74,54.64 113.61,54.64 110.43,51.46 110.43,50.26 105.05,44.88 103.93,44.88 91.65,44.88 89.35,42.58 89.35,40.97 87.22,38.84 87.22,36.4 85.69,34.87 79.56,34.87 77.65,32.96 67.96,32.96 63.37,28.36 63.37,26.81 61.92,25.36 61.92,20.26 55.12,13.46 51.94,13.46 51.14,14.26 50.04,14.26 47.21,11.44 v2(47.21,10.53)
  BOTTOM w0.254: R762.1 45.79,9.13 v3(46.55,9.89) 47.19,10.53 v2(47.21,10.53)
SIO_GREEN_R: length 11.4
  TOP w0.254: R758.1 39.19,8.75 39.31,8.88 39.32,8.88 40.58,10.13 41.88,10.13 42.12,9.89 Q9646.1 43.11,9.18 R760.2 43.63,10.75 Q65.G 42.92,10.93 v2(42.92,10.28)
  BOTTOM w0.254: v2(42.92,10.28) v3(42.92,9.47) 43.25,9.13 R762.2
SIO_HDD_LED: length 103.3
  TOP w0.102: U109.11 120.89,54.81 v2(121.48,54.22) ; v2(50.72,13.32) 50.69,13.32 50.44,13.58 v1(49.68,13.58) 49.68,12.91 50.13,12.46 R747.2 50.5,12.33 R749.1
  L3 w0.127: v2(121.48,54.22) 120.47,54.22 119.79,53.54 115.47,53.54 115.13,53.2 113.23,53.2 112.63,52.6 112.63,51.44 112.95,51.12 112.95,50.51 106.58,44.13 104.24,44.13 104.24,44.13 102.7,44.13 102.7,44.13 91.96,44.13 90.1,42.27 90.1,37.28 86.94,34.12 79.87,34.12 77.93,32.18 68.24,32.18 64.29,28.23 64.29,25.56 63.4,24.67 63.4,20.69 55.43,12.71 51.33,12.71 v2(50.72,13.32)
SIO_HDD_LED_1: length 3.7
  TOP w0.102: R749.2 49.48,11.44 v1(49.45,11.41) 49.44,11.42 48.99,11.42 48.58,11.01 48.58,10.24 Q63.B
SIO_HOLD#: length 3.1
  BOTTOM w0.102: R311.1 102.66,65.05 101.86,65.05 v3(101.75,65.16) 101.14,65.77 U6.7
SIO_INT#: length 6.5
  TOP w0.102: U109.100 106.58,51.46 v2(107.91,52.8)
  BOTTOM w0.102: R80236.1 107.77,51.36 v3(107.77,51.93) 107.77,52.65 v2(107.91,52.8)
SIO_K8PWR_EN: length 4.1
  TOP w0.102: U109.123 115.77,50.78 v2(115.66,50.89)
  BOTTOM w0.102: R269.1 116.02,49.35 TP105.1 116.02,50.54 v2(115.66,50.89)
SIO_LVDS_BL_ADJ: length 7.5
  TOP w0.165: U109.10 120.52,54.41 122.55,52.37 122.55,50.54 v1(122.42,50.41) 123.06,49.77 R284.1
SIO_MAIN_VCC3: length 3.6
  TOP w0.203: U109.89 101.95,53.61 v1(101.72,53.38)
  TOP w0.508: R286.1 101.21,53.2 101.22,53.19 101.53,53.19 v1(101.72,53.38)
SIO_MEM_EVENT_L: length 7.6
  TOP w0.102: U109.53 109.78,66.64 110.5,67.37 110.5,69.54 v1(110.13,69.92) 108.72,71.33 R279.2
SIO_PCIRSTIN#: length 6.2
  TOP w0.102: U109.128 117.78,48.27 118.66,47.38 v1(119.32,47.38) 119.58,47.64 119.58,49.29 v2(119.32,49.54)
  BOTTOM w0.102: v2(119.32,49.54) 119.08,49.78 R316.1
SIO_PSON_D: length 3.6
  BOTTOM w0.102: R323.1 113.35,58.13 113.35,58.13 113.35,57.49 v3(113.22,57.36) 112.94,57.07 Q8.D
SIO_PSON_N: length 22.4
  TOP w0.102: U109.73 105.43,60.01 106.01,60.6 v2(106.01,61.98) ; R318.2 96.61,65.44 v2(96.65,65.4)
  L4 w0.127: v2(106.01,61.98) 106.01,61.98 104.47,61.98 101.02,65.43 96.71,65.43 96.68,65.4 v2(96.65,65.4)
  BOTTOM w0.102: Q8.G 109.88,59.47 109.53,59.81 107.94,59.81 107.51,60.24 107.51,61.89 106.8,62.6 v3(106.75,62.6) 106.63,62.6 106.02,61.98 v2(106.01,61.98)
SIO_SCK: length 29.5
  L4 w0.127: v2(114.5,58.03) 114.5,58.11 109.81,62.8 109.81,64.62 108.91,65.52 107.76,65.52 105.18,68.1 100.08,68.1 99.23,68.95 98.58,68.95 v2(98.49,69.04)
  BOTTOM w0.102: v2(114.5,58.03) 114.52,58.03 114.75,58.25 R294.2 ; v3(98.19,69.99) 98.19,69.38 98.49,69.07 v2(98.49,69.04) 98.88,68.66 98.88,67.57 99.4,67.04 U6.6 100.15,67.17 R312.1 C197.1
SIO_SCK_R: length 7
  TOP w0.102: U109.22 120.17,59.21 120.68,58.69 v2(120.85,58.69)
  BOTTOM w0.102: R294.1 116.55,58.52 116.87,58.52 117.07,58.72 117.64,58.72 117.84,58.52 118.29,58.52 118.89,59.12 v3(119.68,59.12) 120.42,59.12 v2(120.85,58.69)
SIO_SI: length 29.5
  TOP w0.102: U109.21 118.2,58.81 v2(118.03,58.98)
  L4 w0.127: v2(118.03,58.98) 116.74,58.98 112.97,62.75 112.97,64.05 112.18,64.84 112.18,66.81 112.18,66.82 112.18,67.28 109.71,69.74 109.71,69.76 109.28,70.18 108.23,70.18 107.67,69.62 103.28,69.62 103.27,69.62 101.63,69.62 v2(101.41,69.84)
  BOTTOM w0.102: U6.5 100.02,69.38 v3(100.48,69.84) 100.48,69.84 v2(101.41,69.84) 101.42,69.84 101.42,69.33 101.73,69.01 R313.1
SIO_SMB2_CLK: length 9.7
  TOP w0.102: U109.63 105.77,65.47 105.55,65.7 104.32,65.7 103.45,66.56 102.38,66.56 101.47,67.47 101.47,68.64 100.65,69.46 v1(100.27,69.46) 99.83,69.46 R306.1
SIO_SMB2_DATA: length 11.2
  TOP w0.102: R307.1 99.46,71.12 v1(100.36,71.12) 100.5,70.98 100.5,70.1 101.82,68.78 101.82,67.62 102.52,66.92 103.6,66.92 104.46,66.05 105.7,66.05 106.18,65.57 U109.62
SIO_SMCLK0: length 139.5
  TOP w0.102: RN5.3 102.74,67.86 102.85,67.97 104.07,67.97 104.87,67.17 v2(105.01,67.17) 105.09,67.25 105.51,67.25 106.98,65.78 U109.60 ; R79690.1 13.66,20.56 v2(14.04,20.94)
  L3 w0.127: v2(38.01,21.07) 38.01,25.19 38.26,25.45 38.26,26.66 37.32,27.6 37.32,31.76 39.63,34.07 39.63,38.77 39.12,39.28 39.12,45.67 41.81,48.36 41.81,49.55 42.72,50.45 44.63,50.45 45.18,49.9 47.34,49.9 48.37,48.87 63.79,48.87 64.96,47.7 79.15,47.7 80.52,49.07 81.66,49.07 86.48,53.89 87.32,53.89 87.32,53.88 88.51,53.88 89.35,54.72 92.17,54.72 92.74,55.29 95.27,55.29 99.39,59.42 99.39,61.44 101.42,63.46 101.42,64.91 104.01,67.51 104.4,67.51 104.75,67.17 v2(105.01,67.17)
  BOTTOM w0.102: v2(14.04,20.94) 15.31,22.21 v3(19.88,22.21) 23.06,22.21 23.46,21.8 31.97,21.8 33.31,20.46 37.4,20.46 v2(38.01,21.07)
SIO_SMDAT0: length 133.9
  TOP w0.102: U109.61 106.58,65.68 105.84,66.41 104.84,66.41 v2(104.21,67.04) 103.79,67.46 RN5.4 ; v2(18.15,20.69) 17.15,20.69 R79691.1
  L3 w0.127: v2(104.21,67.04) 104.16,67.04 101.8,64.67 101.8,63.31 99.77,61.28 99.77,59.26 95.43,54.91 92.9,54.91 92.33,54.34 89.5,54.34 88.67,53.5 87.16,53.5 86.63,53.5 81.82,48.69 80.68,48.69 79.31,47.32 64.8,47.32 63.66,48.46 56.81,48.46 56.2,47.85 48.85,47.85 47.19,49.52 45.03,49.52 44.47,50.07 42.87,50.07 42.2,49.39 42.2,48.21 39.5,45.51 39.5,39.44 40.01,38.93 40.01,33.9 37.7,31.58 37.7,30.78 38.64,29.84 38.64,20.69 v2(38.32,20.37)
  BOTTOM w0.102: v2(18.15,20.69) 19.12,20.69 20.64,19.16 v3(24.45,19.16) 30.68,19.16 31.46,19.94 37.89,19.94 v2(38.32,20.37)
SIO_SO: length 31.8
  TOP w0.102: v2(110.66,63.16) 110.66,63.11 111.02,62.75 111.28,62.75 111.43,62.9 111.94,62.9 112.97,63.94 U109.45 ; R309.1 93.8,69.2 94.51,69.91 v2(94.98,69.91)
  L4 w0.127: v2(94.98,69.91) 95.19,70.13 95.51,70.13 95.86,70.47 98.22,70.47 98.35,70.34 98.92,70.34 100.4,68.86 100.74,68.86 100.74,68.86 106.68,68.86 110.66,64.88 v2(110.66,63.16)
  BOTTOM w0.102: U6.2 95.5,65.77 96.23,66.5 96.23,69.9 v3(96.16,69.98) 95.46,69.98 95.4,69.91 v2(94.98,69.91)
SIO_UART1_RX: length 130.8
  TOP w0.102: v2(120.64,57.14) 120.57,57.21 U109.17 ; R9553.2 31.21,52.89 31.51,53.2 32.65,53.2 33.09,52.76 33.09,51.62 33.23,51.48 v2(33.27,51.48) ; v2(90.37,64.88) 90.37,66.13 v1(90.46,66.22) 90.49,66.25 90.49,66.29 91.24,67.04 91.78,67.04 R317.1
  L3 w0.127: v2(99.38,72.76) 97.22,70.6 93.52,70.6 93.03,70.11 93.03,70.09 92.4,69.46 92.4,69.2 92.14,68.95 92.14,66.53 90.49,64.88 v2(90.37,64.88) 90.87,64.38 91.33,64.38 91.9,64.95 94.34,64.95 95.28,64 95.28,63.11 91.85,59.68 91.85,58.58 90,56.73 88.51,56.73 87.67,55.89 85.64,55.89 80.83,51.08 79.69,51.08 78.88,50.27 68.4,50.27 67.62,51.04 51.25,51.04 50.23,52.06 44.45,52.06 43.27,53.24 39.04,53.24 38.64,52.84 38.64,52.83 37.29,51.48 v2(33.27,51.48)
  L4 w0.127: v2(99.38,72.76) 99.89,72.25 99.89,70.7 101.22,69.37 101.82,69.37 101.82,69.37 107.77,69.37 108.33,69.92 109.18,69.92 109.45,69.65 109.45,69.64 111.92,67.17 111.92,64.74 112.71,63.95 112.71,62.15 117.27,57.59 118.64,57.59 118.94,57.29 120.49,57.29 v2(120.64,57.14)
SIO_UART1_RX_R: length 4.2
  TOP w0.102: SCA1.59 32.51,49.8 31.65,50.66 31.45,50.66 v1(31.32,50.79) 31.21,50.9 R9553.1
SIO_UART1_TX: length 168.4
  TOP w0.102: R79820.1 122.69,56.37 121.95,57.12 121.3,57.12 120.82,57.61 U109.18 118.61,57.61 118.6,57.6 117.81,57.6 117.26,58.15 v2(117.26,58.26) ; v2(33.61,50.1) 33.61,50.1 33.61,50.17 34.11,50.66 v1(34.11,51.04) 34.09,51.03 33.04,51.03 32.77,51.29 32.77,52.32 32.34,52.75 R9555.2
  L3 w0.127: v2(117.26,58.26) 117.53,57.99 117.53,56.53 117.76,56.3 117.76,55.7 117.31,55.24 111.7,55.24 109.67,53.22 109.67,52.83 110.09,52.41 110.09,50.4 104.91,45.22 103.79,45.22 90.56,45.22 89.01,43.67 89.01,41.11 86.87,38.98 86.87,36.66 85.45,35.24 79.44,35.24 77.5,33.3 67.82,33.3 63.02,28.5 63.02,27.16 56.62,20.75 56.62,17.32 53.91,14.6 49.89,14.6 47.63,12.34 45.91,12.34 45.66,12.09 39.8,12.09 37.07,14.82 36.45,14.82 35.2,13.58 29.63,13.58 28.77,14.43 28.77,16.74 30.17,18.14 30.17,24.47 30.55,24.85 30.55,28.82 30.68,28.94 30.68,39.86 32.71,41.9 32.71,48.2 33.61,49.1 v2(33.61,50.1)
SIO_UART1_TX_R: length 3.9
  TOP w0.102: SCA1.58 33.01,50.16 v1(32.62,50.56) 32.23,50.95 R9555.1
SIO_VCORE: length 6.1
  TOP w0.203: U109.33 117.78,65.54 118.26,66.03
  TOP w0.508: 118.26,66.03 118.26,66.73 117.04,67.94 v1(116.86,67.94) 116.69,68.11 C191.1 C12151.1
SIO_VIN1: length 16.1
  TOP w0.203: 104.87,51.43 104.69,51.61 U109.94
  TOP w0.305: 104.87,51.43 104.87,50.52 104.42,50.07
  TOP w0.508: R80216.2 93.9,46.21 v1(94.68,45.43) 94.79,45.33 98.81,45.33 R80215.1 99.6,45.9 100.04,46.34 100.94,46.34 102.69,48.09 102.69,48.8 103.95,50.07 104.42,50.07
SIO_VIN2: length 18.1
  TOP w0.203: TP107.1 101.8,50.91 102.89,52.01 U109.93
  TOP w0.508: v2(92.37,51.51) 92.37,51.32 94.23,49.47 96.13,49.47 96.35,49.25 98.41,49.25 98.7,49.55 99.59,49.55 100.2,50.15 100.78,50.15 TP107.1
  BOTTOM w0.508: v2(92.37,51.51) 92.37,51.29 93.52,50.15 R80238.1 C12446.1 94.14,52.03 R80239.1
SIO_VIN3: length 24.3
  TOP w0.203: 99.23,50.66 99.38,50.81 100.04,50.81 100.07,50.84 100.07,50.84 100.76,51.52 101.91,51.52 102.79,52.41 U109.92
  TOP w0.508: 99.23,50.66 99.05,50.48 98.54,50.48 98.07,50.01 96.68,50.01 96.46,50.23 94.54,50.23 v2(93.29,51.48) ; R252.1 C179.1 93.99,54.91 93.16,55.74 R250.1 92.65,55.8 92.65,57.17 92.39,57.44 v2(92.39,57.45)
  BOTTOM w0.508: v2(92.39,57.45) 92.67,57.45 93.16,56.95 93.16,55.99 92.25,55.08 92.25,52.73 v3(92.42,52.55) 93.29,51.69 v2(93.29,51.48)
SIO_VIN4: length 10.9
  TOP w0.203: U109.91 102.3,52.81 102.18,52.69
  TOP w0.508: R259.1 C181.1 96.03,52.41 96.61,51.83 96.61,51.22 97.06,50.77 97.72,50.77 98.21,51.27 v1(98.75,51.27) 98.9,51.42 99.79,51.42 100.14,51.78 100.36,51.99 R255.1 100.6,52.42 101.91,52.42 102.18,52.69
SIO_VIN5: length 7
  TOP w0.203: U109.90 105.47,53.21 v2(105.99,52.69)
  BOTTOM w0.508: v2(105.99,52.69) 105.16,51.87 v3(104.97,51.87) R272.1 C183.1 102.75,51.8 R266.1
SIO_VREF: length 9.9
  TOP w0.203: 102.57,54.01 U109.88
  TOP w0.254: 102.57,54.01 102.42,54.16 101.19,54.16 v2(101.08,54.27) 100.89,54.07 100.69,54.07 100.45,53.83 99.07,53.83 R79623.2
  BOTTOM w0.254: R79622.2 102.81,53.77 C188.1 101.58,53.77 v2(101.08,54.27) 100.95,54.41 R79624.2 v3(99.23,54.41)
SIO_WP#: length 4
  TOP w0.102: v2(93.47,68.39) 93.12,68.04 R310.1
  BOTTOM w0.102: U6.3 94.43,67.04 93.47,68 v2(93.47,68.39) 93.46,68.39 93.46,69.18 v3(93.44,69.2)
SIO_WRST#: length 6.3
  TOP w0.102: R319.2 113.87,69 C12152.1 113.17,68.97 112.89,68.69 v1(112.89,67.04) 112.89,66.36 112.17,65.64 U109.47
SIO_YELLOW: length 130.4
  TOP w0.254: R299.1 123.77,61.83 v2(123.89,61.71) ; Q64.G 38.04,4.28 v1(38.19,4.28) 42.78,4.28 R755.2 43.82,5 44.16,5.35 44.16,7.82 45.28,8.93 45.28,10.01 44.65,10.65 R759.2 44.99,11.44 45.03,11.44 45.29,11.7 45.29,11.82 45.88,12.4 49.23,12.4 v2(49.37,12.27)
  L3 w0.254: v2(123.89,61.71) 123.89,61.58 122.88,60.57 122.88,53.71 121.86,52.69 118.56,52.69 118.06,53.19 115.67,53.19 115.34,52.86 113.61,52.86 113.06,52.31 113.06,51.49 113.29,51.26 113.29,50.37 106.72,43.79 92.1,43.79 90.44,42.13 90.44,37.14 87.05,33.74 79.98,33.74 78.07,31.84 68.39,31.84 64.64,28.09 64.64,21.49 63.75,20.6 63.75,20.55 55.53,12.33 49.43,12.33 v2(49.37,12.27)
SIO_YELLOW_IC: length 5.9
  TOP w0.203: 120.45,63.09 120.17,62.81 U109.31
  TOP w0.254: R299.2 123.77,64.12 123.26,64.63 v1(122.75,64.63) 121.99,64.63 120.45,63.09
SKEW1: length 15.4
  TOP w0.102: R1687.2 133.61,100.44 R1688.1 132.72,99.16 133.6,98.28 133.6,97.65 134.21,97.04 134.21,94 134.08,93.87 134.08,92.25 134.69,91.64 134.69,91.53 v1(135.31,90.91) 136.14,90.08 136.85,90.08 137.1,89.83 137.1,89.27 136.9,89.07 136.9,88.68 136.69,88.47 136.69,88.27 136.61,88.19 U2.P44
SKEW2: length 12.8
  TOP w0.102: R79932.2 R79933.1 136.4,97.83 136.85,97.38 136.85,96.46 137.29,96.02 137.29,93.28 v1(137.75,92.82) 137.37,92.43 137.37,91.02 137.97,90.42 137.97,88.81 137.97,88.81 137.97,88.33 138.3,88 U2.U43
SKEW3: length 6.2
  TOP w0.102: U2.U42 138.62,87.27 138.83,87.06 v2(138.83,87.01)
  BOTTOM w0.102: v2(138.83,87.01) 138.83,87.44 138.09,88.17 v3(138.09,88.68) 137.81,88.96 137.81,90.42 R1685.1 138.37,90.98 R1684.2
SKL_CNL_N: length 49.4
  TOP w0.102: v2(77.36,203.16) 76.91,202.71 CPU1.AB36
  BOTTOM w0.102: v2(77.36,203.16) 75.66,204.86 75.66,211.53 75.66,212.86 v3(81.6,218.8) 84,221.2 89.46,221.2 94.65,226.4 103.39,226.4 106.59,229.6 R24.2
SKL_PCUDEBUG_0: length 71
  TOP w0.102: v2(47.31,133.72) 47.31,133.59 47.06,133.34 R46.1 41.92,133.53 41.03,134.42 R1766.1 ; CPU1.H15 v5(62.7,181.77)
  L4 w0.127: v2(47.31,133.72) 47.31,134.51 48.72,135.91 49.35,135.91 54.7,141.27 54.7,149.32 55.8,150.41 55.8,164.88 54.65,166.02 54.65,177.93 58.49,181.77 v5(62.7,181.77)
  BOTTOM w0.102: XDPC1.9 v3(45.81,133.51) 47.1,133.51 v2(47.31,133.72)
SKL_PCUDEBUG_1: length 71.4
  TOP w0.102: R47.1 43.47,132.19 44.36,133.08 48.46,133.08 48.6,133.22 v2(48.69,133.22) ; CPU1.F15 v5(61.78,180.85)
  L4 w0.127: v2(48.69,133.22) 48.75,133.22 49.51,133.98 49.51,135.53 54.96,140.98 54.96,149.21 56.05,150.31 56.05,164.95 54.88,166.12 54.88,177.84 58.55,181.5 61.14,181.5 61.78,180.86 v5(61.78,180.85)
  BOTTOM w0.102: XDPC1.11 45.6,133.01 45.6,133 46.03,133 46.03,133.01 47.21,133.01 v3(47.59,132.62) 48.09,132.62 v2(48.69,133.22)
SKL_PCUDEBUG_2: length 70.4
  TOP w0.102: R48.1 43.62,131.05 45.01,132.44 v2(45.79,132.44) ; CPU1.F16 v5(61.78,182.68)
  L4 w0.127: v2(45.79,132.44) 46.59,133.24 46.59,134.51 48.51,136.42 49.14,136.42 54.2,141.48 54.2,149.53 55.29,150.62 55.29,164.73 54.2,165.82 54.2,179.14 55.69,180.64 56.67,180.64 58.29,182.25 61.35,182.25 v5(61.78,182.68)
  BOTTOM w0.102: v3(62.68,183.55) 62.5,183.37 62.47,183.37 v5(61.78,182.68) ; v2(45.79,132.44) 45,132.44 44.57,132.01 XDPC1.15
SKL_PCUDEBUG_3: length 75
  TOP w0.102: v2(46.55,132.45) 47.31,131.69 R49.1 51.38,131.88 TP137.1 52.14,133.72 R10.1 ; CPU1.H16 v5(63.61,182.68)
  L4 w0.127: v2(46.55,132.45) 46.84,132.74 46.84,134.4 48.61,136.17 49.25,136.17 54.45,141.37 54.45,149.42 55.54,150.52 55.54,164.81 54.43,165.93 54.43,179.05 55.78,180.41 56.77,180.41 58.38,182.02 61.45,182.02 61.69,182.26 63.19,182.26 v5(63.61,182.68)
  BOTTOM w0.102: v2(46.55,132.45) 46.08,131.98 44.87,131.98 44.67,131.78 44.35,131.78 44.07,131.51 XDPC1.17
SKL_PCUDEBUG_4: length 80.2
  TOP w0.102: R50.1 41.66,128.38 41.47,128.38 v1(40.73,127.65) 40.21,127.13 v2(39.69,127.13) ; v5(60.87,185.43) CPU1.F19
  L4 w0.127: v5(60.87,185.43) 60.64,185.66 60.6,185.66 60.41,185.84 58.91,185.84 58.25,185.18 57.01,185.18 52.25,180.43 52.25,164.67 52.43,164.49 52.43,151.13 51.68,150.38 51.68,149.27 46.42,144.01 46.42,140.76 42.1,136.43 39.9,136.43 38.23,134.77 38.23,132.08 37.99,131.84 37.99,128.83 v2(39.69,127.13)
  BOTTOM w0.102: XDPC1.27 41.49,129.01 41.31,128.82 40.97,128.82 40.63,128.49 40.63,128.15 40.61,128.12 40.61,127.72 40.11,127.22 39.79,127.22 v2(39.69,127.13)
SKL_PCUDEBUG_5: length 93.8
  TOP w0.102: CPU1.H18 v5(62.7,184.51) ; R51.1 41.92,147.46 v1(42.27,147.81) 45.4,147.81 47.65,150.06 49.49,150.06 v2(50.13,150.71)
  L4 w0.127: v2(39.57,126.35) 37.74,128.18 37.74,131.94 37.98,132.18 37.98,134.88 39.79,136.69 41.28,136.69 42.87,138.28 42.87,140.28 45.03,142.44 45.03,145.3 50.13,150.4 v2(50.13,150.71) 50.13,150.99 51.16,152.02 51.16,163.94 51.11,164 51.11,180.9 57.27,187.06 58.04,187.06 58.85,187.87 60.54,187.87 60.68,187.72 60.99,187.72 61.31,187.4 61.31,187.13 61.63,186.81 61.9,186.81 62.24,186.47 62.24,185.19 62.7,184.74 v5(62.7,184.51)
  BOTTOM w0.102: XDPC1.29 41.15,128.51 40.86,128.22 40.86,128.05 40.84,128.03 40.84,127.52 40.63,127.31 40.63,127.18 40.38,126.92 40.38,126.79 39.94,126.35 v2(39.57,126.35)
SKL_PCUDEBUG_6: length 86.4
  TOP w0.102: R52.1 41.32,126.9 41.32,126.4 v1(40.57,125.65) 40.39,125.46 v2(39.57,125.46) ; CPU1.G21 v5(61.78,187.25)
  L4 w0.127: v2(39.57,125.46) 39.57,125.69 37.48,127.77 37.48,132.05 37.73,132.29 37.73,134.98 39.69,136.94 41.17,136.94 42.61,138.38 42.61,140.44 44.77,142.6 44.77,145.41 48.46,149.09 48.46,149.7 50.91,152.15 50.91,163.84 50.88,163.86 50.88,180.99 57.09,187.21 57.09,187.65 58.03,188.59 61.04,188.59 61.31,188.32 61.31,187.84 61.78,187.37 v5(61.78,187.25)
  BOTTOM w0.102: v2(39.57,125.46) 39.79,125.69 39.79,125.89 40.61,126.7 40.61,126.83 40.86,127.08 40.86,127.22 40.97,127.32 41.43,127.32 41.61,127.51 XDPC1.33
SKL_PCUDEBUG_7: length 93.6
  TOP w0.102: v2(47.84,149.61) 44.9,146.67 v1(43.38,146.67) 42.8,146.67 R53.1 ; CPU1.H20 v5(62.7,186.34)
  L4 w0.127: v2(39.57,124.7) 37.23,127.04 37.23,132.15 37.47,132.39 37.47,135.09 39.63,137.25 41.12,137.25 42.36,138.49 42.36,140.55 44.52,142.7 44.52,145.91 47.82,149.21 47.82,149.59 v2(47.84,149.61) 50.54,152.31 50.65,152.38 50.65,181.09 56.86,187.3 56.86,187.74 57.94,188.82 61.73,188.82 62.51,188.03 62.51,186.52 v5(62.7,186.34)
  BOTTOM w0.102: XDPC1.35 41.11,127.01 40.84,126.73 40.84,126.61 40.02,125.79 40.02,125.27 39.69,124.94 39.69,124.83 v2(39.57,124.7)
SKL_PCUDEBUG_8: length 88.4
  TOP w0.102: v5(62.7,182.68) CPU1.G16 ; R54.1 42.63,137.65 v1(43.26,138.29) 42.78,138.77 41.57,138.77 v2(41.47,138.67)
  L4 w0.127: v5(62.7,182.68) 63.02,182.68 63.44,183.1 63.74,183.1 64.06,183.43 64.06,186.51 63.06,187.52 63.06,188.13 61.92,189.27 57.75,189.27 56.41,187.93 56.41,187.56 50.15,181.3 50.15,153.34 47.73,150.93 47.73,150.62 47.11,150 47.11,149.27 44.01,146.17 44.01,143.69 41.47,141.15 v2(41.47,138.67)
  BOTTOM w0.102: XDPC1.10 35.03,133.51 34.11,134.43 34.11,137.02 36.29,139.2 37.29,139.2 37.6,139.51 37.98,139.51 38.28,139.2 40.94,139.2 v2(41.47,138.67)
SKL_PCUDEBUG_9: length 92.4
  TOP w0.102: v2(39.57,157.21) 39.06,157.72 R55.2 ; R56.1 38.56,132.89 v1(38.58,132.91) 39.22,133.55 39.5,133.55 39.54,133.52 v2(39.65,133.52) ; CPU1.E16 v5(60.87,182.68)
  L3 w0.127: v2(39.57,157.21) 40.07,157.21 42.46,154.82 51.9,154.82 53.47,156.4 v2(54.06,156.4)
  L4 w0.127: v2(39.65,133.52) 39.69,133.55 44.75,133.55 45.41,134.21 45.41,134.76 48.1,137.45 48.73,137.45 53.18,141.9 53.18,149.95 54.06,150.83 v2(54.06,156.4) 54.06,164.5 53.26,165.29 53.26,179.73 55.77,182.24 56.92,182.24 57.63,182.94 57.63,183.76 57.93,184.07 58.53,184.07 58.71,184.24 60.26,184.24 60.45,184.05 61,184.05 61.29,183.77 61.29,183.1 v5(60.87,182.68)
  BOTTOM w0.102: v2(39.65,133.52) 39.65,133.51 39.31,133.51 39.19,133.39 38.6,133.39 38.22,133.01 XDPC1.12
SKL_PCUDEBUG_10: length 74.7
  TOP w0.102: R57.1 36.31,131.89 36.77,131.43 v1(37.15,131.43) 38.98,131.43 39.54,131.99 v2(39.65,131.99) ; v5(60.87,183.6) CPU1.F17
  L4 w0.127: v5(60.87,183.6) 60.58,183.6 60.16,184.02 58.86,184.02 58.59,183.74 58.59,183.54 57.06,182.01 55.86,182.01 53.51,179.66 53.51,167.11 53.51,165.37 54.53,164.35 54.53,150.94 53.43,149.85 53.43,141.79 48.84,137.2 48.2,137.2 45.66,134.66 45.66,134.1 44.79,133.23 40.89,133.23 v2(39.65,131.99)
  BOTTOM w0.102: XDPC1.16 39.42,132.01 39.43,131.99 v2(39.65,131.99)
SKL_PCUDEBUG_11: length 82
  TOP w0.102: R58.1 44.01,139.56 v2(44.14,139.69) ; v5(63.65,183.6) 63.18,183.14 CPU1.H17
  L4 w0.127: v2(44.14,139.69) 44.99,139.69 46.07,140.76 46.07,144.01 51.43,149.37 51.43,150.7 52.18,151.45 52.18,164.42 52.02,164.57 52.02,180.52 56.92,185.41 58.16,185.41 58.82,186.07 60.5,186.07 60.69,185.88 61,185.88 61.33,185.56 61.33,185.29 61.65,184.96 61.92,184.96 62.24,184.64 62.24,184.37 62.63,183.98 63.26,183.98 v5(63.65,183.6)
  BOTTOM w0.102: v2(44.14,139.69) 43.58,139.69 43.56,139.66 39.37,139.66 39.06,139.97 v3(37.36,139.97) 36.73,139.97 33.88,137.11 33.88,133.86 33.87,133.86 33.87,133.43 33.88,133.43 33.88,132.96 35.33,131.51 XDPC1.18
SKL_PCUDEBUG_12: length 93.9
  TOP w0.102: R59.1 39.57,146.41 40.02,145.96 40.1,145.96 41.09,144.97 42.02,144.97 42.41,145.36 42.41,145.39 42.68,145.66 43.06,145.66 43.41,145.31 43.88,145.31 47.66,149.08 49.95,149.08 v2(50.17,149.31) ; CPU1.G20 v5(61.78,186.34)
  L4 w0.127: v5(61.78,186.34) 61.5,186.34 61.08,186.76 58.39,186.76 58.23,186.6 57.46,186.6 51.57,180.71 51.57,164.22 51.67,164.12 51.67,151.74 50.92,150.99 50.92,150.06 v2(50.17,149.31) 49.76,149.31 45.54,145.09 45.54,141.56 44.16,140.19 v2(43.5,140.19)
  BOTTOM w0.102: v2(43.5,140.19) 43.2,139.89 40.98,139.89 40.7,140.17 v3(39.58,140.17) 39.27,140.48 36.88,140.48 33.6,137.2 33.6,132.7 34.13,132.17 34.13,129.34 34.46,129.01 XDPC1.28
SKL_PCUDEBUG_13: length 82.6
  TOP w0.102: R60.1 36.96,128.51 v2(34.61,128.51) ; CPU1.F20 v5(60.87,186.34)
  L4 w0.127: v5(60.87,186.34) 57.52,186.34 51.8,180.62 51.8,164.35 51.92,164.22 51.92,151.56 51.17,150.81 51.17,149.48 45.81,144.12 45.81,141.18 v2(44.99,140.35)
  BOTTOM w0.102: v2(44.99,140.35) 43.98,140.35 43.69,140.65 42.77,140.65 42.52,140.4 v3(41.47,140.4) 41.16,140.71 36.78,140.71 33.37,137.29 33.37,132.61 33.9,132.07 33.9,129.24 34.35,128.8 34.35,128.78 v2(34.61,128.51) 34.62,128.51 XDPC1.30
SKL_PCUDEBUG_14: length 83.9
  TOP w0.102: R61.1 34.87,127.49 v2(34.61,127.75) ; CPU1.F21 v5(60.87,187.25)
  L4 w0.127: v5(60.87,187.25) 60.63,187.5 60.59,187.5 60.45,187.64 58.94,187.64 58.13,186.83 57.36,186.83 51.34,180.81 51.34,164.13 51.42,164.05 51.42,151.88 50.6,151.06 50.6,150.52 45.28,145.2 45.28,141.97 v2(44.27,140.96)
  BOTTOM w0.102: v2(44.27,140.96) 42.75,140.96 42.42,140.63 42.04,140.63 41.73,140.94 36.69,140.94 33.14,137.39 33.14,132.51 33.37,132.28 v3(33.37,130.19) 33.37,128.99 v2(34.61,127.75) 34.86,127.51 XDPC1.34
SKL_PCUDEBUG_15: length 91.7
  TOP w0.102: R62.1 46.13,152.77 48.16,150.74 v2(48.2,150.74) ; CPU1.H19 63.59,185.41 v5(63.62,185.41)
  L4 w0.127: v2(42.23,141.08) 44.27,143.12 44.27,146.07 47.37,149.17 47.37,149.9 v2(48.2,150.74) 50.29,152.82 50.4,152.89 50.4,181.19 56.64,187.43 56.64,187.84 57.84,189.05 61.82,189.05 62.83,188.03 62.83,186.83 63.11,186.55 63.11,186.24 63.62,185.74 v5(63.62,185.41)
  BOTTOM w0.102: XDPC1.36 35.41,127.01 35.14,127.28 34.1,127.28 v3(33.57,127.8) 32.78,128.59 32.78,137.36 36.59,141.17 42.15,141.17 v2(42.23,141.08)
SKL_PCUSTB_0_DN: length 73.6
  TOP w0.254: v5(60.87,179.94) CPU1.E14
  L4 w0.254: v5(60.87,179.94) 60.87,179.8 60.52,179.45 59.77,179.45 59.3,179.92 57.7,179.92 55.4,177.62 55.4,166.57 56.75,165.22 56.75,150.02 56,149.27 56,140.53 51.96,136.49 v2(51.73,136.49)
  BOTTOM w0.254: 46.55,137.22 50.72,137.22 51.45,136.49 v2(51.73,136.49) ; 46.55,137.22 36.5,137.22 36.22,137.5 35.32,137.5 34.59,136.77 34.59,135.13 35.1,134.63 35.1,134.63 35.22,134.51 XDPC1.6 ; 46.55,137.22 v3(46.55,137.53)
SKL_PCUSTB_0_DP: length 73.7
  TOP w0.254: v5(61.78,179.94) 61.72,179.94 61.32,180.34 CPU1.F14
  L4 w0.254: v2(51.12,135.88) 51.89,135.88 56.38,140.37 56.38,149.11 57.13,149.86 57.13,165.38 55.78,166.72 55.78,177.46 57.86,179.54 59.15,179.54 59.62,179.07 60.68,179.07 61.55,179.94 v5(61.78,179.94)
  BOTTOM w0.254: v3(49.47,136.64) 49.47,136.84 ; 49.47,136.84 36.34,136.84 36.06,137.12 35.48,137.12 34.97,136.61 34.97,135.29 35.25,135.01 XDPC1.4 ; 49.47,136.84 50.56,136.84 51.12,136.28 v2(51.12,135.88)
SKL_PCUSTB_1_DN: length 76.9
  TOP w0.254: v1(38.92,129.67) 39.08,129.5 v2(39.56,129.5) ; v5(61.78,184.51) CPU1.G18
  L4 w0.127: 60.59,184.92 60.6,184.93 61.13,184.93 61.55,184.51 v5(61.78,184.51)
  L4 w0.254: v2(39.56,129.5) 38.44,130.63 38.44,131.65 38.68,131.89 38.68,134.59 39.43,135.34 43.32,135.34 46.3,138.33 48.44,138.33 52.35,142.24 52.35,150.42 53.14,151.21 53.14,164.41 52.55,165 52.55,180.31 57.13,184.89 58.37,184.89 58.4,184.92 60.59,184.92
  BOTTOM w0.254: XDPC1.24 38.27,130.01 38.52,129.75 39.31,129.75 v2(39.56,129.5)
SKL_PCUSTB_1_DP: length 74.8
  TOP w0.254: v1(40.39,130.14) 40.18,130.34 v2(39.76,130.34) ; v5(60.87,184.51) CPU1.F18
  L4 w0.254: v5(60.87,184.51) 60.4,184.51 60.38,184.54 58.55,184.54 58.53,184.51 57.29,184.51 52.93,180.15 52.93,165.16 53.52,164.56 53.52,151.05 52.74,150.26 52.74,142.08 48.6,137.95 46.46,137.95 43.48,134.96 39.59,134.96 39.06,134.43 39.06,131.74 38.82,131.49 38.82,130.79 39.26,130.34 v2(39.76,130.34)
  BOTTOM w0.254: v2(39.76,130.34) 39.56,130.14 38.68,130.14 38.31,130.51 XDPC1.22
SKL_XDP_MBP_0: length 65.3
  TOP w0.102: CPU1.D16 v5(59.95,182.68)
  L4 w0.127: v2(45.15,131.52) 45.15,132.6 46.17,133.62 46.17,134.45 48.4,136.68 49.04,136.68 53.94,141.58 53.94,149.64 55.03,150.73 55.03,164.66 53.97,165.73 53.97,179.24 55.6,180.87 56.58,180.87 58.81,183.1 59.53,183.1 v5(59.95,182.68)
  BOTTOM w0.102: v5(59.95,182.68) 59.95,182.16 v3(60.27,181.85) ; XDPC1.21 44.37,130.51 45.15,131.29 v2(45.15,131.52)
SKL_XDP_MBP_1: length 72.4
  TOP w0.102: CPU1.D17 v5(59.04,183.6)
  L4 w0.127: v2(39.71,127.89) 40.32,127.89 43.58,131.15 43.58,132.32 44.2,132.94 44.86,132.94 45.92,134 45.92,134.55 48.31,136.94 48.94,136.94 53.69,141.69 53.69,149.74 54.78,150.83 54.78,164.48 53.74,165.52 53.74,165.88 53.74,165.88 53.74,167.01 53.74,167.01 53.74,179.56 55.93,181.76 57.14,181.76 58.72,183.33 58.77,183.33 v5(59.04,183.6)
  BOTTOM w0.102: v3(58.11,182.87) 58.31,182.87 v5(59.04,183.6) ; XDPC1.23 40.94,130.01 40.46,129.53 40.46,128.64 39.71,127.89 v2(39.71,127.89)
SLEEVE: length 30.6
  TOP w0.203: 183.68,59.92 182.53,59.92 182.24,59.64 U9.32
  TOP w0.762: v2(182.47,73.37) 182.44,73.34 182.44,72.82 Q14.D ; v4(184.42,59.8) 184.36,59.8 184.31,59.85 183.75,59.85 183.68,59.92
  TOP w1.016: R80226.1 185.62,74.79 v4(185.49,74.92) 185.49,74.92 185.49,75.68 184.73,76.44 v1(184.73,76.95) 184.73,78.82 Q15.1
  L3 w0.762: v4(184.42,59.8) 186.24,61.62 186.24,65.53 185.11,66.66 185.11,69.07 185.49,69.45 v4(185.49,74.92)
  L4 w1.016: v2(182.47,73.37) 183.96,73.37 185.49,74.89 v4(185.49,74.92)
SLEEVE_CON: length 11
  TOP w1.016: 194.13,74.79 196.16,72.76 201.62,72.76 202.59,71.79 UHS1.4
  BOTTOM w0.254: v3(190.39,74.66) v2(191.2,74.66)
SLEEVE_G: length 8.2
  TOP w0.102: Q14.G 180.19,74.15 179.27,74.15 178.57,74.85 Q18.C 176.98,76.12 R407.2 178.19,76.63 R408.1 v1(179.52,76.57)
SLP_A#_CN: length 3.2
  TOP w0.102: TP222.1 160.25,74.18 159.74,73.67 158.46,73.67 158.45,73.66 157.93,73.66 R1786.2
SLP_S3_N: length 640.3
  TOP w0.102: R79789.1 50,50.53 49.99,50.53 48.53,50.53 v2(48.43,50.43) ; v2(174.08,104.51) 174.47,104.13 R451.2 ; v2(148.2,74.28) 148.36,74.28 148.88,73.75 U2.AW15 ; U109.68 102.69,62.01 100.59,64.11 100.09,64.11 v2(99.64,63.65) ; v2(16.96,157.21) 17.21,156.96 17.48,156.96 18.1,156.33 18.1,155.94 18.48,155.56 19.5,155.56 R80228.1 ; R505.1 v2(75.19,64.76) ; R506.1 v2(75.13,67.8)
  L3 w0.127: v2(48.43,50.43) 50.1,50.43 50.73,49.8 64.65,49.8 65.99,48.46 78.84,48.46 80.21,49.83 81.35,49.83 86.16,54.65 87.63,54.65 87.63,54.65 88.19,54.65 89.03,55.49 91.85,55.49 92.42,56.06 92.63,56.06 94.47,56.06 97.91,59.5 97.91,61.93 v2(99.64,63.65) 99.64,64.71 104.46,69.53 v2(104.46,70.09) ; v2(82.49,69.58) 82.22,69.58 81.92,69.28 81.92,69.16 81.65,68.88 81.26,68.88 80.98,69.16 80.98,69.77 80.79,69.96 77.29,69.96 v2(75.13,67.8) ; v2(148.2,74.28) 148.65,74.72 149.15,74.72 149.41,74.46 149.41,74.2 149.88,73.72 152.83,73.72 153.18,73.38 153.18,73.11 153.79,72.5 155.2,72.5 156.71,70.99 158.58,70.99 158.95,71.36 v2(158.95,71.84) ; v2(31.95,255.13) 31.47,255.61 21.22,255.61 19.03,253.42 19.03,251.42 16.58,248.97 14.9,248.97 2.34,236.41 2.34,174.31 9.42,167.23 9.56,167.23 17.18,159.62 17.18,157.43 v2(16.96,157.21) 16.45,156.7 16.45,116.88 15.04,115.47 15.04,108.04 v2(15.66,107.43)
  L4 w0.127: v2(158.95,71.84) 159.69,71.84 161.19,73.35 161.19,73.71 162.93,75.45 163.29,75.45 164.6,76.75 164.6,87.68 164.32,87.96 164.32,89.49 169.61,94.79 169.61,95.88 174.55,100.83 174.55,104.04 v2(174.08,104.51) 174.08,104.61 173.59,105.1 173.59,107.15 173.87,107.43 173.87,139.08 172.71,140.25 172.71,203.78 168.99,207.5 v2(168.99,207.94) ; v2(82.49,69.58) 82.4,69.49 82.4,68.45 84.02,66.83 84.02,65.55 86.08,63.49 86.81,63.49 87.39,63.49 87.93,62.94 92.23,62.94 92.4,63.11 99.09,63.11 v2(99.64,63.65)
  BOTTOM w0.102: v2(75.19,64.76) 75.58,65.15 75.58,67.35 v2(75.13,67.8) ; 169.36,209.41 169.36,210.3 169.23,210.43 R1736.2 ; 169.36,209.41 v3(169.36,209.41) ; 169.36,209.41 169.36,208.32 v2(168.99,207.94) ; v2(158.95,71.84) 158.95,70.73 158.5,70.28 R1785.1 158.5,69.82 156.24,67.56 156.24,67.48 156,67.25 156,64.37 156.63,63.74 156.63,63.27 156.34,62.98 151.75,62.98 151.39,63.33 147.74,63.33 145.37,60.97 140.86,60.97 140.07,60.18 128.67,60.18 127.88,60.97 127.08,60.97 124.13,63.92 123.96,63.92 121.42,66.46 117.71,66.46 114.69,69.48 110.64,69.48 109.9,68.74 v3(107.69,68.74) 105.81,68.74 v2(104.46,70.09) ; v2(31.95,255.13) 32.11,255.13 32.58,255.6 32.58,256.15 32.96,256.53 U175.2 ; v2(15.66,107.43) PQ5302.G 15.63,106.19 PC5312.1 16.01,104.13 19.47,104.13 20.39,103.21 20.39,102.19 23.11,99.48 23.11,90.99 21.59,89.47 17.11,89.47 12.41,84.77 6.87,84.77 4.38,82.28 4.38,68.07 5.74,66.71 13.47,66.71 19.63,60.56 19.63,58.67 20.93,57.37 23.67,57.37 24.68,58.38 30.39,58.38 34.02,54.75 44.87,54.75 48.43,51.19 v2(48.43,50.43)
SLP_S3_N_CN: length 1.3
  BOTTOM w0.102: R1785.2 159.42,69.84 160.6,69.84 TP223.1
SLP_S3_N_R3: length 6
  TOP w0.102: U109.76 104.61,58.81 105.35,59.55 105.47,59.55 107,61.08 107,61.24 107.05,61.29 v2(107.05,61.71)
  BOTTOM w0.102: v2(107.05,61.71) 107.05,61.37 106.75,61.07 TP256.1
SLP_S4_N: length 446.4
  TOP w0.102: Q31.G 77.93,63.45 v2(78,63.38) ; v2(38.95,154.16) 38.93,154.14 38.93,153.66 39.69,152.89 41.41,152.89 R1683.1 ; R1951.2 96.49,58.13 96.49,60.37 v2(96.59,60.48) ; v2(166.34,76.29) 166.31,76.26 166.01,76.26 165.97,76.3 165.55,76.3 165.49,76.36 164.7,76.36 R1784.1 164.34,76.24 164.23,76.24 164.1,76.11 163.14,76.11 161.41,74.38 161.41,74.03 161.02,73.65 160.22,73.65 159.89,73.32 158.61,73.32 158.34,73.05 155.45,73.05 154.72,73.77 154.25,73.77 154.11,73.91 151.8,73.91 151.57,73.69 U2.BD15 ; v2(174.06,105.78) 174.31,105.52 R453.2
  L3 w0.127: v2(34.44,96.72) 32.36,96.72 27.21,101.87 27.21,103.3 23.31,107.2 22.52,107.2 v2(20.26,109.46)
  L4 w0.127: v2(20.26,109.46) 20.17,109.55 20.17,111.23 20.69,111.75 20.69,113.27 20,113.97 20,125.1 20.87,125.97 22.02,125.97 23.42,127.37 23.42,131.7 23.59,131.86 23.59,131.87 24.22,132.5 28.99,137.26 28.99,139.72 31.44,142.17 31.44,144.65 33.02,146.23 33.02,147.84 38.93,153.75 38.93,154.14 v2(38.95,154.16) ; v2(96.59,60.48) 96.28,60.48 96.24,60.44 89.58,60.44 89.3,60.16 84.23,60.16 82.87,61.52 80.24,61.52 78.97,62.79 78.59,62.79 v2(78,63.38) 77.37,64.01 77.37,69.55 77.49,69.67 77.49,72.32 76.16,73.65 66.36,73.65 58.76,81.24 57.31,81.24 48.82,89.72 36.48,89.72 35.38,90.82 35.38,95.78 v2(34.44,96.72) ; v2(166.34,76.29) 164.98,77.65 164.98,87.93 164.7,88.21 164.7,89.33 170.25,94.88 170.25,95.98 174.94,100.67 174.94,104.9 v2(174.06,105.78) 174.88,106.6 174.88,111.84 174.25,112.48 174.25,124.34 174.86,124.95 174.86,128.1 175.08,128.32 175.08,136.35 175.29,136.57 175.29,202.98 174.32,203.95 173.3,203.95 169.87,207.37 169.87,208.4 169.1,209.17 168.71,209.17 167.59,208.05 163.58,208.05 162.85,208.77 v2(159.33,208.77)
  BOTTOM w0.102: v2(166.34,76.29) 166.43,76.29 166.59,76.12 v3(168.94,76.12) 168.94,75.33 169.87,74.41 169.87,61.85 168.8,60.79 168.8,59.32 167.05,57.57 165.75,57.57 163.26,55.08 160.37,55.08 159.79,55.66 155.87,55.66 155.77,55.56 155.77,55.56 155.49,55.28 155.49,54.57 155.47,54.54 155.05,54.13 154.35,53.43 154.05,53.43 152.58,53.43 150.7,51.55 149.78,51.55 149.09,50.86 135.14,50.86 131.89,47.61 125.14,47.61 124.35,46.82 123.41,46.82 122.75,47.48 121.53,47.48 120.77,46.72 111.53,46.72 111.09,47.16 111.09,47.19 109.11,49.17 109.11,51.14 108.4,51.85 108.4,52.96 107.15,54.2 106.35,54.2 103.42,57.14 99.01,57.14 96.78,59.36 96.78,60.28 v2(96.59,60.48) ; v2(159.33,208.77) 159.77,209.22 R1953.1
