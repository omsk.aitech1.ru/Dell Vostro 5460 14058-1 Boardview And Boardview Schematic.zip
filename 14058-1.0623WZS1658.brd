# Allegro board 14058-1.0623WZS1658.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_DATA_B0: length 122.2
  TOP w0.14: v5(79.14,201.34) 79.14,201.3 79.56,200.88 CPU1.AE34 ; v5(162.68,198.16) 162.68,198.03 162.1,197.45 DIMM2.5
  L3 w0.102: v5(79.14,201.34) 79.14,201.64 79.58,202.08 79.58,204.23 79.28,204.53 79.02,204.53 78.71,204.85 78.71,205.52
  L3 w0.191: v5(162.68,198.16) 162.68,198.2 160.65,200.23 160.65,201.76 159.26,203.15 159.26,203.42 160.01,204.17 160.01,204.44 159.74,204.71 159.47,204.71 158.72,203.96 158.45,203.96 158.18,204.23 158.18,204.5 158.93,205.25 158.93,205.52 158.66,205.79 158.39,205.79 157.64,205.04 157.37,205.04 156.37,206.04 154.83,206.04 154.64,205.85 154.64,204.68 154.41,204.46 154.1,204.46 153.88,204.68 153.88,205.85 153.68,206.04 129.27,206.04 113.07,222.24 89.16,222.24 78.71,211.79 78.71,205.52
  BOTTOM w0.14: v3(162.38,197.22) 162.68,197.52 v5(162.68,198.16)
M_DATA_B1: length 121.1
  TOP w0.14: v5(164.18,198.11) 162.92,196.85 DIMM2.7 ; CPU1.AE35 79.61,201.85 79.24,202.22 v5(79.12,202.22)
  L3 w0.102: v5(79.12,202.22) 78.73,202.61 78.73,204.22 78.43,204.52 78.17,204.52 77.79,204.89 77.79,207.05
  L3 w0.191: v5(164.18,198.11) 163.72,198.57 163.34,198.57 161.79,200.11 161.79,200.49 161.6,200.68 161.32,200.68 161.13,200.87 161.13,201.26 161.32,201.45 161.6,201.45 161.79,201.64 161.79,202.02 161.6,202.21 161.23,202.21 161,202.43 161,202.75 161.23,202.97 161.6,202.97 161.79,203.16 161.79,203.57 158.9,206.46 129.46,206.46 113.28,222.64 88.99,222.64 77.79,211.45 77.79,207.05
  BOTTOM w0.14: v3(164,197.12) 164.03,197.14 164.03,197.24 164.18,197.4 v5(164.18,198.11)
M_DATA_B2: length 121
  TOP w0.14: v5(81.9,200.46) 82.32,200.88 CPU1.AH34 ; v5(162.7,195.06) 162.09,194.45 DIMM2.15
  L3 w0.191: v5(81.9,200.46) 81.9,200.68 82.35,201.14 82.35,202.47 81.91,202.9 81.91,207.56 82.47,208.11 82.47,211.75 90.41,219.7 110.03,219.7 110.93,218.79 111.2,218.79 111.84,219.43 112.11,219.43 112.38,219.16 112.38,218.89 111.74,218.25 111.74,217.98 112.01,217.71 112.28,217.71 112.92,218.35 113.19,218.35 113.45,218.08 113.45,217.81 112.82,217.17 112.82,216.9 113.09,216.63 113.36,216.63 113.99,217.27 114.26,217.27 114.53,217 114.53,216.73 113.9,216.09 113.9,215.83 114.17,215.56 114.44,215.56 115.07,216.19 115.34,216.19 115.61,215.92 115.61,215.65 114.97,215.02 114.97,214.75 115.24,214.48 115.51,214.48 116.15,215.11 116.42,215.11 116.69,214.84 116.69,214.58 116.05,213.94 116.05,213.67 116.34,213.38 116.61,213.38 116.7,213.47 116.97,213.47 117.23,213.2 117.23,212.93 117.15,212.84 117.15,212.57 126.51,203.21 151.38,203.21 153.14,201.45 154.17,201.45 154.67,201.45 160.65,195.46 162.29,195.46 v5(162.7,195.06)
  BOTTOM w0.14: v5(162.7,195.06) 162.7,195.4 162.17,195.92 v3(162.12,195.92)
M_DATA_B3: length 119.8
  TOP w0.14: v5(81.9,202.26) CPU1.AH35 ; v5(164.12,195.02) 162.95,193.85 DIMM2.17
  L3 w0.191: v5(164.12,195.02) 163.27,195.87 160.82,195.87 154.84,201.85 154,201.85 153.31,201.85 151.55,203.62 151.21,203.62 126.68,203.62 121.24,209.06 121.24,209.33 121.87,209.97 121.87,210.24 121.59,210.52 121.32,210.52 120.68,209.89 120.41,209.89 120.14,210.16 120.14,210.43 120.78,211.06 120.78,211.33 120.51,211.6 120.24,211.6 119.6,210.96 119.33,210.96 119.06,211.23 119.06,211.5 119.7,212.14 119.7,212.41 119.43,212.68 119.16,212.68 118.52,212.04 118.25,212.04 117.99,212.31 117.99,212.58 118.62,213.22 118.62,213.49 118.27,213.84 117.74,213.84 117.46,214.12 117.46,214.65 112.01,220.1 90.24,220.1 82,211.87 82,208.29 81.48,207.76 81.48,202.68 v5(81.9,202.26)
  BOTTOM w0.14: v5(164.12,195.02) v3(164.12,195.87)
M_DATA_B4: length 121.8
  TOP w0.14: v5(78.24,201.39) 78.24,201.35 CPU1.AD34 ; v5(167.12,197.83) 167.19,197.75 DIMM2.4
  L3 w0.127: 75.7,204.17 77.19,202.68 77.47,202.68 77.79,202.36 77.79,201.83 v5(78.24,201.39)
  L3 w0.191: v5(167.12,197.83) 167.12,199.53 159.35,207.3 130.02,207.3 113.86,223.46 88.65,223.46 75.7,210.5 75.7,204.17
  BOTTOM w0.14: v5(167.12,197.83) 167.96,197.83 v3(167.96,197.83)
M_DATA_B5: length 121
  TOP w0.14: DIMM2.6 166.52,197.15 v5(165.67,198) ; v2(78.24,202.26) 78.7,201.8 CPU1.AD35
  L3 w0.102: v2(78.24,202.26) 77.8,202.69 77.8,203.33 77.52,203.61 76.87,203.61 76.53,203.95
  L3 w0.191: 76.53,203.95 76.53,210.76 88.82,223.05 113.45,223.05 129.63,206.87 159.1,206.87 162.22,203.74 162.22,200.29 163.53,198.99 164.68,198.99 v5(165.67,198)
  BOTTOM w0.14: v5(165.67,198) v3(165.67,198.82)
M_DATA_B6: length 121.8
  TOP w0.14: v5(166.44,195.06) 166.44,194.83 167.12,194.15 DIMM2.16 ; v5(80.98,200.46) 81.41,200.88 CPU1.AG34
  L3 w0.102: 80.54,205.43 80.54,204.83 80.36,204.65 80.36,201.76 80.98,201.14 v5(80.98,200.46)
  L3 w0.191: v5(166.44,195.06) 165.55,195.95 164.92,195.95 164.18,196.68 161.41,196.68 160.22,197.88 160.22,198.68 156.13,202.77 153.55,202.77 151.55,204.76 128.62,204.76 127.69,205.69 127.42,205.69 126.72,204.99 126.45,204.99 126.18,205.26 126.18,205.53 126.88,206.23 126.88,206.5 126.61,206.77 126.34,206.77 125.64,206.07 125.38,206.07 125.11,206.34 125.11,206.61 125.8,207.31 125.8,207.58 112.46,220.92 89.9,220.92 89.43,220.44 80.54,211.55 80.54,205.43
  BOTTOM w0.14: v3(167.84,195.29) 166.66,195.29 v5(166.44,195.06)
M_DATA_B7: length 120.8
  TOP w0.14: v5(81.9,201.35) 81.89,201.35 CPU1.AG35 ; DIMM2.18 166.41,193.55 v5(164.91,195.06)
  L3 w0.102: v5(81.9,201.35) 81.32,201.35 80.56,202.1 80.56,204.38 80.82,204.64
  L3 w0.191: v5(164.91,195.06) 163.69,196.28 161.25,196.28 159.81,197.71 159.81,198.51 155.96,202.36 153.38,202.36 151.71,204.02 151.04,204.02 126.85,204.02 124.29,206.58 124.29,206.85 124.54,207.1 124.54,207.42 124.32,207.64 124,207.64 123.75,207.39 123.48,207.39 123.21,207.66 123.21,207.93 123.85,208.57 123.85,208.84 123.58,209.11 123.31,209.11 122.67,208.47 122.4,208.47 122.13,208.74 122.13,209.01 122.77,209.64 122.77,209.91 112.18,220.51 90.07,220.51 89.83,220.27 89.83,220.27 81.6,212.03 81.6,208.51 80.95,207.87 80.95,204.77 80.82,204.64
  BOTTOM w0.14: v3(164.13,194.19) 164.91,194.97 v5(164.91,195.06)
M_DATA_B8: length 112.5
  TOP w0.14: CPU1.AL34 85.1,200.89 v5(84.61,201.38) ; v5(162.76,193.28) 162.76,193.25 162.15,192.65 DIMM2.21
  L3 w0.102: 84.2,206.55 84.2,201.78 v5(84.61,201.38)
  L3 w0.191: 84.2,206.55 84.21,206.56 84.21,211.42 90.96,218.17 109.37,218.17 126.47,201.08 136.19,201.08 136.9,201.79 137.75,201.79 137.94,201.6 137.94,200.31 138.16,200.09 138.48,200.09 138.7,200.31 138.7,201.6 138.89,201.79 139.27,201.79 139.46,201.6 139.46,200.31 139.69,200.09 140,200.09 140.23,200.31 140.23,201.6 140.42,201.79 150,201.79 151.52,200.27 151.52,200.27 151.99,199.8 153.07,199.8 153.07,199.79 154.42,199.79 160.63,193.58 161.44,193.58 161.46,193.61 162.43,193.61 v5(162.76,193.28)
  BOTTOM w0.14: v3(162.35,194.07) 162.76,193.66 v5(162.76,193.28)
M_DATA_B9: length 111.8
  TOP w0.14: v5(164.88,191.56) 164.38,192.05 DIMM2.23 ; v5(84.61,202.26) 85.07,201.8 CPU1.AL35
  L3 w0.102: v5(84.61,202.26) 84.61,202.34 84.46,202.49 84.46,206.3 84.62,206.46 84.62,206.49
  L3 w0.191: v5(164.88,191.56) 163.79,192.65 161,192.65 154.55,199.1 145.87,199.1 145.68,199.29 145.68,200.46 145.49,200.65 145.11,200.65 144.92,200.46 144.92,199.29 144.73,199.1 133.7,199.1 132.15,200.65 126.18,200.65 109.06,217.77 91.13,217.77 84.62,211.25 84.62,206.49
  BOTTOM w0.14: v5(84.61,202.26) 84.68,202.33 v3(84.68,203.19)
M_DATA_B10: length 115.2
  TOP w0.14: CPU1.AK31 84.65,198.61 v5(84.65,198.61) ; DIMM2.33 162.1,189.05 v5(162.65,189.6)
  L3 w0.102: 86.88,206.17 86.88,203.6 86.03,202.75 86.03,199.41 85.61,199 85.29,199 84.91,198.61 v5(84.65,198.61)
  L3 w0.191: 86.88,206.17 87.19,206.49 87.19,207.12 88.5,208.43 88.57,208.43 88.83,208.7 95.67,208.7 96.64,209.66 98.02,209.66 98.22,209.85 98.22,210.51 98.41,210.7 98.79,210.7 98.98,210.51 98.98,209.85 99.17,209.66 99.55,209.66 99.74,209.85 99.74,210.51 99.93,210.7 100.31,210.7 100.5,210.51 100.5,209.85 100.69,209.66 101.07,209.66 101.26,209.85 101.26,210.51 101.45,210.7 101.83,210.7 102.03,210.51 102.03,209.85 102.22,209.66 102.6,209.66 102.79,209.85 102.79,210.51 102.98,210.7 103.36,210.7 103.55,210.51 103.55,209.85 103.74,209.66 104.12,209.66 104.31,209.85 104.31,210.51 104.5,210.7 104.88,210.7 105.07,210.51 105.07,209.85 105.26,209.66 105.64,209.66 105.84,209.85 105.84,210.51 106.03,210.7 106.41,210.7 106.6,210.51 106.6,209.85 106.79,209.66 107.17,209.66 107.36,209.85 107.36,210.51 107.55,210.7 107.93,210.7 108.12,210.51 108.12,209.85 108.31,209.66 108.69,209.66 108.88,209.85 108.88,210.51 109.07,210.7 109.45,210.7 109.65,210.51 109.65,209.85 109.84,209.66 110.22,209.66 110.41,209.85 110.41,210.51 110.6,210.7 110.98,210.7 111.17,210.51 111.17,209.85 111.36,209.66 111.74,209.66 111.93,209.85 111.93,210.51 112.12,210.7 112.5,210.7 112.69,210.51 112.69,209.85 112.88,209.66 114.06,209.66 127.98,195.74 154.8,195.74 154.81,195.73 160.44,190.11 160.49,190.05 162.2,190.05 v5(162.65,189.6)
  BOTTOM w0.14: v3(162.32,190.46) 162.32,190.44 162.65,190.11 v5(162.65,189.6)
M_DATA_B11: length 114.9
  TOP w0.14: v5(85.54,198.56) 85.13,198.14 CPU1.AL31 ; DIMM2.35 161.49,188.45 161.62,188.58 162.25,188.58 162.5,188.83 163.4,188.83 v5(164.14,189.57)
  L3 w0.102: 88.08,205.73 87.88,205.52 87.88,203.95 86.88,202.95 86.88,199.34 86.64,199.11 86.09,199.11 v5(85.54,198.56)
  L3 w0.191: 88.08,205.73 90.65,208.29 96.85,208.29 97.04,208.48 97.04,209.02 97.23,209.21 97.61,209.21 97.8,209.02 97.8,208.48 97.99,208.29 98.37,208.29 98.56,208.48 98.56,209.02 98.75,209.21 99.13,209.21 99.32,209.02 99.32,208.48 99.51,208.29 99.9,208.29 100.09,208.48 100.09,209.02 100.28,209.21 100.66,209.21 100.85,209.02 100.85,208.48 101.04,208.29 101.42,208.29 101.61,208.48 101.61,209.02 101.8,209.21 102.18,209.21 102.37,209.02 102.37,208.48 102.56,208.29 102.94,208.29 103.13,208.48 103.13,209.02 103.32,209.21 103.71,209.21 103.9,209.02 103.9,208.48 104.09,208.29 104.47,208.29 104.66,208.48 104.66,209.02 104.85,209.21 105.23,209.21 105.42,209.02 105.42,208.48 105.61,208.29 105.99,208.29 106.18,208.48 106.18,209.02 106.37,209.21 106.75,209.21 106.94,209.02 106.94,208.48 107.13,208.29 107.52,208.29 107.71,208.48 107.71,209.02 107.9,209.21 108.28,209.21 108.47,209.02 108.47,208.48 108.66,208.29 109.04,208.29 109.23,208.48 109.23,209.02 109.42,209.21 109.8,209.21 109.99,209.02 109.99,208.48 110.18,208.29 110.56,208.29 110.75,208.48 110.75,209.02 110.94,209.21 111.33,209.21 111.52,209.02 111.52,208.48 111.71,208.29 112.09,208.29 112.28,208.48 112.28,209.02 112.47,209.21 112.85,209.21 113.04,209.02 113.04,208.48 113.23,208.29 114.85,208.29 127.81,195.34 154.63,195.34 160.77,189.2 160.91,189.05 163.62,189.05 v5(164.14,189.57)
  BOTTOM w0.14: v5(164.14,189.57) 164.14,189.61 163.62,190.13 v3(163.62,190.44)
M_DATA_B12: length 113.1
  TOP w0.14: CPU1.AK34 84.16,200.88 v5(83.75,200.47) ; v5(166.48,192.92) 167.05,192.35 DIMM2.22
  L3 w0.102: v5(83.75,200.47) 83.25,200.97 83.25,201.66 83,201.92
  L3 w0.191: v5(166.48,192.92) 164.98,194.42 161.11,194.42 154.92,200.61 154.42,200.61 152.33,200.61 150.34,202.6 126.23,202.6 109.85,218.98 90.63,218.98 82.87,211.23 82.87,206.77 82.34,206.24 82.34,202.9 83,202.25 83,201.92
  BOTTOM w0.14: v3(166.76,193.7) 166.48,193.42 v5(166.48,192.92)
M_DATA_B13: length 112.9
  TOP w0.14: v5(83.73,201.35) 83.75,201.35 84.18,201.78 CPU1.AK35 ; v5(165.06,192.9) 166.21,191.75 DIMM2.24
  L3 w0.102: 83.3,205.22 83.3,202.1 83.73,201.66 v5(83.73,201.35)
  L3 w0.191: 83.3,205.22 83.3,207.33 83.29,207.33 83.29,207.39 83.29,207.39 83.29,207.77 83.3,207.77 83.3,211.08 90.8,218.58 109.54,218.58 126.61,201.51 132.5,201.51 133.19,202.2 134.21,202.2 134.4,202 134.4,201.67 134.59,201.48 134.98,201.48 135.17,201.67 135.17,202 135.36,202.2 150.17,202.2 151.92,200.44 152.16,200.2 153.24,200.2 154.69,200.2 160.88,194.02 160.94,194.02 163.94,194.02 v5(165.06,192.9)
  BOTTOM w0.14: v3(165.5,193.89) 165.06,193.45 v5(165.06,192.9)
M_DATA_B14: length 114.4
  TOP w0.14: v5(166.43,189.34) 167.02,188.75 DIMM2.34 ; v5(83.73,198.6) CPU1.AK32
  L3 w0.102: 86.13,207.33 85.97,207.17 85.97,205.84 85.61,205.47 85.47,205.47 85.13,205.13 85.13,202.96 85.54,202.55 85.54,200.07 85.15,199.68 85.15,199.45 84.78,199.08 84.21,199.08 v5(83.73,198.6)
  L3 w0.191: 86.13,207.33 88.31,209.51 95.04,209.51 98.24,212.71 98.96,212.71 99.15,212.9 99.15,213.23 99.34,213.42 99.72,213.42 99.91,213.23 99.91,212.9 100.1,212.71 100.48,212.71 100.67,212.9 100.67,213.23 100.87,213.42 101.25,213.42 101.44,213.23 101.44,212.9 101.63,212.71 102.01,212.71 102.2,212.9 102.2,213.23 102.39,213.42 102.77,213.42 102.96,213.23 102.96,212.9 103.15,212.71 103.53,212.71 103.72,212.9 103.72,213.23 103.91,213.42 104.29,213.42 104.48,213.23 104.48,212.9 104.68,212.71 105.06,212.71 105.25,212.9 105.25,213.23 105.44,213.42 105.82,213.42 106.01,213.23 106.01,212.9 106.2,212.71 106.58,212.71 106.77,212.9 106.77,213.23 106.96,213.42 107.34,213.42 107.53,213.23 107.53,212.9 107.72,212.71 108.1,212.71 108.29,212.9 108.29,213.23 108.49,213.42 108.87,213.42 109.06,213.23 109.06,212.9 109.25,212.71 109.63,212.71 109.82,212.9 109.82,213.23 110.01,213.42 110.39,213.42 110.58,213.23 110.58,212.9 110.77,212.71 112.18,212.71 127.68,197.21 154.51,197.21 159.64,192.08 160.86,190.87 164.91,190.87 v5(166.43,189.34)
  BOTTOM w0.14: v5(166.43,189.34) v3(166.43,190.16)
M_DATA_B15: length 114.1
  TOP w0.14: DIMM2.36 166.95,188.15 166.52,188.58 165.64,188.58 164.96,189.27 v5(164.96,189.29) ; CPU1.AL32 v5(85.56,199.51)
  L3 w0.102: 86.19,205.33 86.05,205.19 86.05,203.06 85.79,202.81 85.79,199.75 v5(85.56,199.51)
  L3 w0.191: v5(164.96,189.29) 164.96,189.43 163.92,190.46 160.69,190.46 159.52,191.63 154.38,196.77 127.54,196.77 113.07,211.24 111.59,211.24 111.4,211.43 111.4,211.89 111.21,212.08 110.83,212.08 110.64,211.89 110.64,211.43 110.45,211.24 110.07,211.24 109.88,211.43 109.88,211.89 109.69,212.08 109.31,212.08 109.12,211.89 109.12,211.43 108.93,211.24 108.55,211.24 108.36,211.43 108.36,211.89 108.16,212.08 107.78,212.08 107.59,211.89 107.59,211.43 107.4,211.24 107.02,211.24 106.83,211.43 106.83,211.89 106.64,212.08 106.26,212.08 106.07,211.89 106.07,211.43 105.88,211.24 105.5,211.24 105.31,211.43 105.31,211.89 105.12,212.08 104.74,212.08 104.55,211.89 104.55,211.43 104.35,211.24 103.97,211.24 103.78,211.43 103.78,211.89 103.59,212.08 103.21,212.08 103.02,211.89 103.02,211.43 102.83,211.24 102.45,211.24 102.26,211.43 102.26,211.89 102.07,212.08 101.69,212.08 101.5,211.89 101.5,211.43 101.31,211.24 100.93,211.24 100.74,211.43 100.74,211.89 100.54,212.08 100.16,212.08 99.97,211.89 99.97,211.43 99.78,211.24 99.4,211.24 99.21,211.43 99.21,211.89 99.02,212.08 98.64,212.08 98.45,211.89 98.45,211.43 98.26,211.24 97.45,211.24 95.32,209.1 88.66,209.1 86.88,207.32 86.88,206.68 86.43,206.23 86.43,205.57 86.19,205.33
  BOTTOM w0.14: v3(164.92,190.26) 164.96,190.22 v5(164.96,189.29)
M_DATA_B16: length 94.6
  TOP w0.14: DIMM2.39 161.93,187.25 v5(162.76,188.07) ; CPU1.AP35 v5(88.3,202.26)
  L3 w0.102: 90.49,204.52 90.02,204.52 89.67,204.17 89.67,203.89 89.37,203.59 89.03,203.59 88.73,203.29 88.73,202.99 88.3,202.56 v5(88.3,202.26)
  L3 w0.191: v5(162.76,188.07) 162.28,187.6 160.95,187.6 156.25,192.29 155.11,192.29 153.44,193.96 135.87,193.96 135.68,193.77 135.68,193.46 135.49,193.27 135.11,193.27 134.92,193.46 134.92,193.77 134.73,193.96 134.35,193.96 134.16,193.77 134.16,193.46 133.97,193.27 133.58,193.27 133.39,193.46 133.39,193.77 133.2,193.96 132.82,193.96 132.63,193.77 132.63,193.46 132.44,193.27 132.06,193.27 131.87,193.46 131.87,193.77 131.68,193.96 131.3,193.96 131.11,193.77 131.11,193.46 130.92,193.27 130.54,193.27 130.35,193.46 130.35,193.77 130.16,193.96 129.77,193.96 129.58,193.77 129.58,193.46 129.39,193.27 129.01,193.27 128.82,193.46 128.82,193.77 128.63,193.96 127.67,193.96 114.71,206.92 94.07,206.92 93.01,205.85 91.78,205.85 90.49,204.56 90.49,204.52
  BOTTOM w0.14: v5(162.76,188.07) 162.71,188.07 v3(161.73,187.1)
M_DATA_B17: length 96.2
  TOP w0.14: CPU1.AN34 v5(87.38,201.34) ; v5(164.28,188.07) 162.86,186.65 DIMM2.41
  L3 w0.102: v5(87.38,201.34) 87.87,201.82 88.44,201.82 88.76,202.15 88.76,202.34 89.12,202.7 89.39,202.7 90.71,204.02
  L3 w0.191: 90.71,204.02 91.26,204.56 91.26,204.91 91.9,205.56 93.13,205.56 94.08,206.51 114.54,206.51 128.19,192.86 137.18,192.86 137.37,193.05 137.37,193.34 137.56,193.53 137.94,193.53 138.13,193.34 138.13,193.05 138.32,192.86 138.7,192.86 138.89,193.05 138.89,193.34 139.08,193.53 139.46,193.53 139.65,193.34 139.65,193.05 139.84,192.86 140.22,192.86 140.41,193.05 140.41,193.34 140.61,193.53 153.23,193.53 155.01,191.76 156.15,191.76 160.72,187.19 163.4,187.19 v5(164.28,188.07)
  BOTTOM w0.14: v3(86.48,201.41) 86.53,201.41 86.6,201.34 v5(87.38,201.34)
M_DATA_B18: length 98.3
  TOP w0.14: v5(161.91,183.7) 161.86,183.65 DIMM2.51 ; CPU1.AN31 86.93,198.17 v5(86.47,198.62)
  L3 w0.102: v5(86.47,198.62) 86.78,198.62 87.18,198.22 87.52,198.22 88.09,198.79 88.44,198.79 88.86,199.21 89.39,199.21 89.4,199.22 90.3,199.22 92.09,201.01 92.76,201.01
  L3 w0.191: 92.76,201.01 93.5,201.01 95.13,202.65 112.65,202.65 121.54,193.76 121.81,193.76 122.31,194.27 122.63,194.27 122.85,194.04 122.85,193.73 122.34,193.22 122.34,192.95 122.63,192.66 122.9,192.66 123.45,193.21 123.72,193.21 123.99,192.94 123.99,192.68 123.44,192.12 123.44,191.85 123.71,191.58 123.98,191.58 124.53,192.14 124.8,192.14 125.07,191.87 125.07,191.6 124.52,191.05 124.52,190.78 124.79,190.51 125.06,190.51 125.61,191.06 125.88,191.06 126.15,190.79 126.15,190.52 125.6,189.97 125.6,189.7 125.95,189.34 127.24,189.34 127.43,189.53 127.43,189.63 127.62,189.82 128,189.82 128.19,189.63 128.19,189.53 128.38,189.34 128.76,189.34 128.95,189.53 128.95,189.63 129.14,189.82 129.52,189.82 129.71,189.63 129.71,189.53 129.9,189.34 130.28,189.34 130.47,189.53 130.47,189.63 130.66,189.82 131.05,189.82 131.24,189.63 131.24,189.53 131.43,189.34 131.81,189.34 132,189.53 132,189.63 132.19,189.82 132.57,189.82 132.76,189.63 132.76,189.53 132.95,189.34 133.33,189.34 133.52,189.53 133.52,189.63 133.71,189.82 134.09,189.82 134.28,189.63 134.28,189.53 134.47,189.34 146.3,189.34 146.47,189.17 152.93,189.17 158.4,183.7 v5(161.91,183.7)
  BOTTOM w0.14: v5(161.91,183.7) v3(161.03,183.7)
M_DATA_B19: length 97.8
  TOP w0.14: v5(87.35,198.63) 87.84,198.14 CPU1.AP31 ; DIMM2.53 162.79,183.05 163.33,183.6 v5(163.33,183.7)
  L3 w0.102: v5(87.35,198.63) 87.72,199 88.36,199 88.71,199.34 88.71,199.68 89.12,200.09 90.72,200.09 91.97,201.33 92.42,201.33
  L3 w0.191: v5(163.33,183.7) 163.3,183.7 162.6,184.39 158.29,184.39 152.45,190.23 127.29,190.23 122.61,194.9 122.34,194.9 122.13,194.69 121.82,194.69 121.6,194.92 121.6,195.23 121.8,195.44 121.8,195.71 121.53,195.98 121.26,195.98 120.71,195.43 120.44,195.43 120.17,195.7 120.17,195.97 120.72,196.52 120.72,196.79 120.46,197.06 120.19,197.06 119.63,196.51 119.36,196.51 119.09,196.77 119.09,197.04 119.65,197.6 119.65,197.87 119.38,198.14 119.11,198.14 118.56,197.58 118.29,197.58 118.02,197.85 118.02,198.12 118.57,198.67 118.57,198.94 118.3,199.21 118.03,199.21 117.48,198.66 117.21,198.66 112.82,203.05 95.13,203.05 93.41,201.33 92.42,201.33
  BOTTOM w0.14: v5(163.33,183.7) v3(163.33,184.54)
M_DATA_B20: length 96.5
  TOP w0.14: v5(166.48,187.82) 166.48,187.57 167.1,186.95 DIMM2.40 ; CPU1.AN35 v5(87.38,202.26)
  L3 w0.102: 88.78,205.2 88.78,203.97 88.47,203.66 88.14,203.66 87.78,203.3 87.78,202.65 v5(87.38,202.26)
  L3 w0.191: 88.78,205.2 88.78,205.86 90.64,207.73 114.48,207.73 115.63,206.57 127.68,194.52 146.15,194.52 146.54,194.91 154.48,194.91 160.74,188.65 165.86,188.65 166.48,188.03 v5(166.48,187.82)
  BOTTOM w0.14: v3(167.99,187.82) 167.81,188 166.66,188 v5(166.48,187.82)
M_DATA_B21: length 95.9
  TOP w0.14: v5(88.27,201.35) 87.84,200.92 CPU1.AP34 ; v5(165.78,188.05) 165.8,188.03 165.8,187.57 167.02,186.35 DIMM2.42
  L3 w0.102: 91.75,203.83 91.09,203.83 89.73,202.47 89.73,202.16 89.4,201.82 89.07,201.82 88.6,201.35 v5(88.27,201.35)
  L3 w0.191: 91.75,203.83 92.46,204.53 93.29,204.53 94.37,205.61 114.87,205.61 128.02,192.46 141.17,192.46 141.51,192.8 141.97,192.8 142.32,192.46 142.7,192.46 142.89,192.65 142.89,192.89 143.08,193.08 143.46,193.08 143.65,192.89 143.65,192.65 143.84,192.46 144.22,192.46 144.41,192.65 144.41,192.89 144.6,193.08 144.98,193.08 145.17,192.89 145.17,192.65 145.36,192.46 145.74,192.46 145.93,192.65 145.93,192.89 146.13,193.08 153.04,193.08 154.85,191.27 155.94,191.27 160.43,186.78 164.52,186.78 v5(165.78,188.05)
  BOTTOM w0.14: v3(89.02,200.57) 88.27,201.32 v5(88.27,201.35)
M_DATA_B22: length 97.8
  TOP w0.14: DIMM2.50 167.1,183.95 v5(166.48,184.57) ; CPU1.AN32 v5(87.38,199.51)
  L3 w0.102: 93.62,202.45 93.62,202.44 93.09,201.92 91.97,201.92 90.55,200.49 88.88,200.49 88.38,200 88.19,200 87.71,199.51 v5(87.38,199.51)
  L3 w0.191: 93.62,202.45 94.92,203.75 95.51,203.75 96.08,204.33 96.55,204.33 96.75,204.14 96.75,204.09 96.94,203.9 97.32,203.9 97.51,204.09 97.51,204.14 97.7,204.33 98.08,204.33 98.27,204.14 98.27,204.09 98.46,203.9 98.84,203.9 99.03,204.09 99.03,204.14 99.22,204.33 99.6,204.33 99.79,204.14 99.79,204.09 99.98,203.9 100.36,203.9 100.56,204.09 100.56,204.14 100.75,204.33 101.13,204.33 101.32,204.14 101.32,204.09 101.51,203.9 101.89,203.9 102.08,204.09 102.08,204.14 102.27,204.33 102.65,204.33 102.84,204.14 102.84,204.09 103.03,203.9 103.41,203.9 103.6,204.09 103.6,204.14 103.79,204.33 104.17,204.33 104.37,204.14 104.37,204.09 104.56,203.9 104.94,203.9 105.13,204.09 105.13,204.14 105.32,204.33 105.7,204.33 105.89,204.14 105.89,204.09 106.08,203.9 106.46,203.9 106.65,204.09 106.65,204.14 106.84,204.33 107.22,204.33 107.41,204.14 107.41,204.09 107.6,203.9 107.98,203.9 108.18,204.09 108.18,204.14 108.37,204.33 108.75,204.33 108.94,204.14 108.94,204.09 109.13,203.9 109.51,203.9 109.7,204.09 109.7,204.14 109.89,204.33 110.27,204.33 110.46,204.14 110.46,204.09 110.65,203.9 111.03,203.9 111.22,204.09 111.22,204.14 111.41,204.33 111.79,204.33 111.99,204.14 111.99,204.09 112.18,203.9 112.56,203.9 112.75,204.09 112.75,204.14 112.94,204.33 114.34,204.33 127.49,191.17 152.65,191.17 158.62,185.2 162.94,185.2 163.27,184.87 166.18,184.87 v5(166.48,184.57)
  BOTTOM w0.14: v5(166.48,184.57) 167.31,184.57 v3(167.33,184.59)
M_DATA_B23: length 97.6
  TOP w0.14: v5(164.79,183.7) 164.79,183.6 165.03,183.35 DIMM2.52 ; CPU1.AP32 v5(88.3,199.51)
  L3 w0.102: 93.25,201.63 91.97,201.63 90.63,200.29 89.03,200.29 88.3,199.56 v5(88.3,199.51)
  L3 w0.191: v5(164.79,183.7) 164.72,183.7 164.15,184.26 163.31,184.26 162.77,184.8 158.45,184.8 152.62,190.63 127.46,190.63 117.94,200.15 117.67,200.15 117.12,199.59 116.85,199.59 116.58,199.86 116.58,200.13 117.13,200.69 117.13,200.95 116.86,201.22 116.59,201.22 116.04,200.67 115.77,200.67 115.5,200.94 115.5,201.21 116.06,201.76 116.06,202.03 115.79,202.3 115.52,202.3 114.96,201.75 114.69,201.75 114.43,202.02 114.43,202.29 114.98,202.84 114.98,203.11 114.63,203.46 95.08,203.46 93.25,201.63
  BOTTOM w0.14: v5(164.79,183.7) 164.89,183.8 v3(164.89,184.57)
M_DATA_B24: length 96.6
  TOP w0.14: v5(162.73,181.98) 162.21,181.46 161.72,181.46 161.33,181.85 DIMM2.57 ; CPU1.AM29 86.01,196.36 v5(85.56,196.81)
  L3 w0.102: v5(85.56,196.81) 86.43,196.81 86.92,197.31 88.5,197.31 89.19,197.99 89.58,197.99 90.2,198.61 90.59,198.61 92.16,200.17 93.28,200.17 93.31,200.14 93.89,200.14
  L3 w0.191: 93.89,200.14 94.99,201.24 112.01,201.24 125.31,187.95 130.8,187.95 130.99,187.76 130.99,187.58 131.18,187.39 131.56,187.39 131.75,187.58 131.75,187.76 131.94,187.95 132.32,187.95 132.51,187.76 132.51,187.58 132.7,187.39 133.08,187.39 133.27,187.58 133.27,187.76 133.46,187.95 133.84,187.95 134.03,187.76 134.03,187.58 134.23,187.39 134.61,187.39 134.8,187.58 134.8,187.76 134.99,187.95 135.37,187.95 135.56,187.76 135.56,187.58 135.75,187.39 136.13,187.39 136.32,187.58 136.32,187.76 136.51,187.95 136.89,187.95 137.08,187.76 137.08,187.58 137.27,187.39 137.65,187.39 137.84,187.58 137.84,187.76 138.04,187.95 138.42,187.95 138.61,187.76 138.61,187.58 138.8,187.39 139.18,187.39 139.37,187.58 139.37,187.76 139.56,187.95 139.94,187.95 140.13,187.76 140.13,187.58 140.32,187.39 140.7,187.39 140.89,187.58 140.89,187.76 141.08,187.95 141.46,187.95 141.65,187.76 141.65,187.58 141.85,187.39 145.92,187.39 146.47,187.95 148.02,187.95 148.82,187.15 152.77,187.15 157.51,182.41 162.3,182.41 v5(162.73,181.98)
  BOTTOM w0.14: v5(162.73,181.98) 162.73,181.62 v3(162.27,181.16)
M_DATA_B25: length 96.8
  TOP w0.14: v5(164.15,181.98) 163.28,181.1 161.58,181.1 161.43,181.25 DIMM2.59 ; CPU1.AM28 85.98,195.4 v5(85.52,195.86)
  L3 w0.102: 94.15,199.88 93.26,199.88 93.17,199.97 92.26,199.97 90.7,198.41 90.64,198.41 90.64,198.4 90.28,198.4 89.66,197.79 89.27,197.79 88.55,197.06 86.97,197.06 86.51,196.61 86.26,196.61 v5(85.52,195.86)
  L3 w0.191: 94.15,199.88 95.11,200.84 111.84,200.84 125.7,186.98 126.15,186.98 126.34,187.17 126.34,187.35 126.53,187.54 126.91,187.54 127.11,187.35 127.11,187.17 127.3,186.98 127.68,186.98 127.87,187.17 127.87,187.35 128.06,187.54 128.44,187.54 128.63,187.35 128.63,187.17 128.82,186.98 129.2,186.98 129.39,187.17 129.39,187.35 129.58,187.54 129.96,187.54 130.15,187.35 130.15,187.17 130.34,186.98 146.19,186.98 146.63,186.55 149.68,186.55 150.18,186.04 153.1,186.04 157.69,181.46 163.63,181.46 v5(164.15,181.98)
  BOTTOM w0.14: v3(163.92,182.87) 164.15,182.64 v5(164.15,181.98)
M_DATA_B26: length 93.5
  TOP w0.14: v5(162.45,179.18) 162.12,178.85 DIMM2.67 ; v5(89.17,195.82) 88.76,196.24 CPU1.AR29
  L3 w0.191: v5(162.45,179.18) 162.27,179.36 156.31,179.36 152.94,182.74 143.75,182.74 142.81,182.74 142.2,183.35 142.2,183.62 142.66,184.08 142.66,184.35 142.39,184.62 142.12,184.62 141.66,184.16 141.39,184.16 140.66,184.89 124.82,184.89 123.68,186.02 123.41,186.02 123.28,185.89 123.01,185.89 122.74,186.16 122.74,186.43 122.87,186.56 122.87,186.83 122.6,187.1 122.34,187.1 122.2,186.97 121.93,186.97 121.66,187.24 121.66,187.5 121.8,187.64 121.8,187.91 121.53,188.18 121.26,188.18 121.12,188.04 120.85,188.04 120.58,188.31 120.58,188.58 120.72,188.72 120.72,188.99 120.45,189.26 120.18,189.26 120.04,189.12 119.77,189.12 119.5,189.39 119.5,189.66 119.64,189.8 119.64,190.07 119.37,190.34 119.1,190.34 118.96,190.2 118.69,190.2 118.43,190.47 118.43,190.74 118.56,190.88 118.56,191.14 118.29,191.41 118.02,191.41 117.89,191.28 117.62,191.28 117.35,191.55 117.35,191.82 117.48,191.95 117.48,192.22 117.21,192.49 116.95,192.49 116.81,192.36 116.54,192.36 116.27,192.62 116.27,192.89 116.41,193.03 116.41,193.3 116.14,193.57 115.87,193.57 115.73,193.43 115.46,193.43 115.19,193.7 115.19,193.97 115.33,194.11 115.33,194.38 110.98,198.72 96.8,198.72 96.53,198.46 93.76,198.46 93.5,198.2 92.11,198.2 91.17,197.26 90.91,197.26 89.48,195.82 v5(89.17,195.82)
  BOTTOM w0.14: v5(162.45,179.18) v3(161.59,179.18)
M_DATA_B27: length 93.7
  TOP w0.14: v5(88.31,194.88) 88.76,195.33 CPU1.AR28 ; v5(163.9,179.18) 162.97,178.25 DIMM2.69
  L3 w0.102: 91.46,196.99 91.46,196.58 91.21,196.33 90.87,196.33 89.91,195.37 88.8,195.37 v5(88.31,194.88)
  L3 w0.191: 91.46,196.99 91.72,197.25 92.1,197.25 92.11,197.24 93.23,197.24 94.16,198.16 96.81,198.16 96.96,198.32 110,198.32 110.42,197.9 110.69,197.9 110.83,198.04 111.1,198.04 111.37,197.77 111.37,197.5 111.23,197.36 111.23,197.09 111.5,196.82 111.77,196.82 111.9,196.96 112.17,196.96 112.44,196.69 112.44,196.42 112.31,196.28 112.31,196.01 112.58,195.74 112.85,195.74 112.98,195.88 113.25,195.88 113.52,195.61 113.52,195.34 113.38,195.2 113.38,194.93 113.65,194.66 113.92,194.66 114.06,194.8 114.33,194.8 114.6,194.53 114.6,194.26 114.46,194.13 114.46,193.86 123.42,184.9 123.42,184.89 123.66,184.66 123.67,184.66 123.85,184.48 124.86,184.48 140.47,184.48 142.61,182.33 152.63,182.33 156.25,178.71 163.42,178.71 v5(163.9,179.18)
  BOTTOM w0.14: v5(163.9,179.18) v3(163.9,179.97)
M_DATA_B28: length 98
  TOP w0.14: CPU1.AL29 v5(84.66,196.75) ; DIMM2.56 167.58,182.15 167.38,181.95 166.64,181.95 166.48,182.11 v5(166.48,182.63)
  L3 w0.102: v5(84.66,196.75) 84.66,197.37 85.41,198.12 86.87,198.12 86.97,198.02 87.6,198.02 88.17,198.59 88.52,198.59 88.94,199.01 89.47,199.01 89.48,199.01 90.38,199.01 92.09,200.72 92.88,200.72
  L3 w0.191: v5(166.48,182.63) 165.89,183.22 157.85,183.22 152.31,188.76 125.64,188.76 112.35,202.06 94.96,202.06 93.62,200.72 92.88,200.72
  BOTTOM w0.14: v3(168.06,183.04) 167.89,183.22 166.77,183.22 166.48,182.93 v5(166.48,182.63)
M_DATA_B29: length 98.2
  TOP w0.14: v5(165.06,182.59) 166.09,181.55 DIMM2.58 ; v5(84.64,195.88) 85.1,195.42 CPU1.AL28
  L3 w0.102: v5(84.64,195.88) 85.09,196.33 85.09,196.92 85.44,197.26 86.59,197.26 87.05,197.73 87.6,197.73 88.07,198.19 89.39,198.19 90.01,198.81 90.47,198.81 92.05,200.39 93.43,200.39
  L3 w0.191: v5(165.06,182.59) 164.83,182.82 157.68,182.82 152.14,188.35 145.11,188.35 144.92,188.16 144.92,187.98 144.73,187.79 144.35,187.79 144.16,187.98 144.16,188.16 143.97,188.35 143.59,188.35 143.4,188.16 143.4,187.98 143.21,187.79 142.83,187.79 142.64,187.98 142.64,188.16 142.44,188.35 125.47,188.35 112.18,201.65 94.96,201.65 93.7,200.39 93.43,200.39
  BOTTOM w0.14: v5(165.06,182.59) 165.06,182.83 v3(165.7,183.48)
M_DATA_B30: length 94.3
  TOP w0.14: v5(165.31,179.05) 166.44,179.05 166.95,178.55 DIMM2.68 ; CPU1.AP29 88.28,195.87 v5(88.28,195.82)
  L3 w0.102: v5(88.28,195.82) 88.72,196.25 89.3,196.25 89.93,196.89 90.04,196.89 90.65,197.5 91.06,197.5 92.01,198.45 93.4,198.45 93.65,198.7 94.87,198.7 95.32,199.15
  L3 w0.191: v5(165.31,179.05) 165.3,179.07 165.3,179.17 164.7,179.77 156.48,179.77 153.1,183.15 145.86,183.15 144.81,184.2 144.55,184.2 143.78,183.43 143.47,183.43 143.24,183.66 143.24,183.97 144.01,184.73 144.01,185 143.72,185.29 125,185.29 111.14,199.15 95.32,199.15
  BOTTOM w0.14: v5(165.31,179.05) v3(165.31,178.24)
M_DATA_B31: length 95.1
  TOP w0.14: DIMM2.70 v5(166.69,177.95) ; CPU1.AP28 v5(87.38,194.94)
  L3 w0.102: v5(87.38,194.94) 87.81,195.37 87.81,195.92 88.34,196.46 89.19,196.46 89.87,197.13
  L3 w0.191: v5(166.69,177.95) 166.69,179.36 165.88,180.17 156.65,180.17 152.58,184.24 145.35,184.24 143.9,185.7 125.16,185.7 111.31,199.55 95.19,199.55 94.59,198.95 93.55,198.95 93.3,198.7 91.91,198.7 90.96,197.75 90.55,197.75 89.93,197.13 89.87,197.13
  BOTTOM w0.14: v5(166.69,177.95) v3(167.86,177.95)
M_DATA_B32: length 98.2
  TOP w0.14: CPU1.AR12 88.34,180.35 v5(88.28,180.35) ; v5(162.98,157.87) 162.68,158.18 161.84,158.18 161.51,157.85 DIMM2.129
  L3 w0.102: 93.58,179.74 93.5,179.81 88.81,179.81 v5(88.28,180.35)
  L3 w0.191: v5(162.98,157.87) 160.63,157.87 153.93,151.17 145.87,151.17 145.68,151.36 145.68,151.78 145.49,151.97 145.11,151.97 144.92,151.78 144.92,151.36 144.73,151.17 144.35,151.17 144.16,151.36 144.16,151.78 143.97,151.97 143.59,151.97 143.4,151.78 143.4,151.36 143.2,151.17 142.82,151.17 142.63,151.36 142.63,151.78 142.44,151.97 142.06,151.97 141.87,151.78 141.87,151.36 141.68,151.17 140.98,151.17 129.75,162.39 129.1,162.39 128.91,162.58 128.91,162.81 128.72,163 128.34,163 128.15,162.81 128.15,162.58 127.96,162.39 115.84,162.39 98.6,179.63 93.69,179.63 93.58,179.74
  BOTTOM w0.14: v5(162.98,157.87) 162.2,157.87 v3(162.1,157.97)
M_DATA_B33: length 98.3
  TOP w0.14: v5(87.43,180.28) 87.84,180.7 CPU1.AP12 ; DIMM2.131 163.76,157.25 v5(164.43,157.92)
  L3 w0.102: v5(87.43,180.28) 87.74,180.28 88.58,179.44 91.01,179.44 91.5,178.95 94.76,178.95 94.98,179.18 95.12,179.18
  L3 w0.191: 95.12,179.18 97.08,179.18 97.82,179.18 98.48,179.18 115.67,161.99 129.58,161.99 140.81,150.76 154.1,150.76 160.72,157.38 163.89,157.38 v5(164.43,157.92)
  BOTTOM w0.14: v5(164.43,157.92) 164.43,158.15 164.94,158.66 v3(164.94,158.74)
M_DATA_B34: length 103.7
  TOP w0.14: v5(161.93,154.19) 161.87,154.25 DIMM2.141 ; v5(84.64,181.22) CPU1.AL13
  L3 w0.102: v5(84.64,181.22) 84.64,180.92 85.12,180.44 85.12,179.92 86.86,178.18 87.9,178.18 88.12,178.4 90.62,178.4 91.15,177.87 95.06,177.87 95.19,177.74
  L3 w0.191: v5(161.93,154.19) 160.49,154.19 157.47,151.17 154.97,148.67 154.96,148.67 154.66,148.36 153.58,147.28 141.08,147.28 128.48,159.88 122.12,159.88 121.93,159.69 121.93,159.13 121.73,158.94 121.35,158.94 121.16,159.13 121.16,159.69 120.97,159.88 120.59,159.88 120.4,159.69 120.4,159.13 120.21,158.94 119.83,158.94 119.64,159.13 119.64,159.69 119.45,159.88 119.07,159.88 118.88,159.69 118.88,159.13 118.69,158.94 118.31,158.94 118.12,159.13 118.12,159.69 117.92,159.88 117.54,159.88 117.35,159.69 117.35,159.13 117.16,158.94 116.78,158.94 116.59,159.13 116.59,159.69 116.4,159.88 114.81,159.88 112.25,162.44 112.25,162.44 97.61,177.08 96.8,177.08 96.69,177.2 96.68,177.2 96.64,177.24 95.69,177.24 95.19,177.74
  BOTTOM w0.14: v5(161.93,154.19) v3(161,154.19)
M_DATA_B35: length 103.6
  TOP w0.14: DIMM2.143 162.87,153.65 v5(163.38,154.16) ; CPU1.AL12 v2(84.64,180.31)
  L3 w0.102: 94.82,177.59 94.75,177.66 91.07,177.66 90.53,178.19 88.29,178.19 88.08,177.98 86.78,177.98 84.64,180.11 v2(84.64,180.31)
  L3 w0.191: v5(163.38,154.16) 162.82,153.61 160.48,153.61 154.59,147.72 153.8,146.93 153.75,146.87 141.25,146.87 140.91,146.87 140.86,146.93 140.86,146.93 140.62,147.16 129.34,158.44 125.48,158.44 125.29,158.63 125.29,159.21 125.1,159.4 124.72,159.4 124.53,159.21 124.53,158.63 124.34,158.44 123.96,158.44 123.77,158.63 123.77,159.21 123.58,159.4 123.19,159.4 123,159.21 123,158.63 122.81,158.44 115.67,158.44 111.84,162.27 97.44,176.68 96.8,176.68 96.69,176.79 96.68,176.79 96.64,176.83 95.58,176.83 94.82,177.59
  BOTTOM w0.14: v5(163.38,154.16) 163.84,154.62 v3(164.18,154.62)
M_DATA_B36: length 100
  TOP w0.14: CPU1.AR13 88.76,181.65 v5(88.35,181.24) ; v5(166.43,158.13) 167.01,157.55 DIMM2.130
  L3 w0.102: v5(88.35,181.24) 88.67,181.24 88.99,181.57 89.35,181.57 89.96,180.96 93.06,180.96 93.16,180.86 94.73,180.86
  L3 w0.191: 94.73,180.86 94.99,180.61 98.77,180.61 115.56,163.82 116.72,163.82 116.91,163.63 116.91,163.4 117.1,163.21 117.48,163.21 117.67,163.4 117.67,163.63 117.86,163.82 118.24,163.82 118.44,163.63 118.44,163.4 118.63,163.21 119.01,163.21 119.2,163.4 119.2,163.63 119.39,163.82 119.77,163.82 119.96,163.63 119.96,163.4 120.15,163.21 120.53,163.21 120.72,163.4 120.72,163.63 120.91,163.82 121.29,163.82 121.48,163.63 121.48,163.4 121.67,163.21 122.05,163.21 122.25,163.4 122.25,163.63 122.44,163.82 129.68,163.82 140.71,152.79 154.39,152.79 160.41,158.81 165.75,158.81 v5(166.43,158.13)
  BOTTOM w0.14: v5(88.35,181.24) 88.35,181.74 v3(88.69,182.08)
M_DATA_B37: length 101.1
  TOP w0.14: CPU1.AP13 87.84,181.67 87.38,181.2 v5(87.4,181.2) ; v5(167.12,156.93) 167.24,156.93 167.26,156.95 DIMM2.132
  L3 w0.102: v5(87.4,181.2) 87.72,181.2 88.17,180.76 92.98,180.76 93.82,179.91 94.99,179.91 95.04,179.96
  L3 w0.191: 95.04,179.96 95.12,180.04 98.43,180.04 98.77,180.04 116,162.8 122.71,162.8 122.9,162.99 122.9,163.22 123.09,163.41 123.47,163.41 123.66,163.22 123.66,162.99 123.85,162.8 124.23,162.8 124.42,162.99 124.42,163.22 124.61,163.41 124.99,163.41 125.18,163.22 125.18,162.99 125.37,162.8 125.76,162.8 125.95,162.99 125.95,163.22 126.14,163.41 126.52,163.41 126.71,163.22 126.71,162.99 126.9,162.8 127.28,162.8 127.47,162.99 127.47,163.22 127.66,163.41 129.51,163.41 140.54,152.38 154.56,152.38 160.58,158.4 165.35,158.4 166.11,157.64 166.41,157.64 v5(167.12,156.93)
  BOTTOM w0.14: v3(87.27,182.15) 87.27,181.34 v5(87.4,181.2)
M_DATA_B38: length 102.6
  TOP w0.14: DIMM2.140 167.5,154.55 v5(167.17,154.22) ; CPU1.AM13 v5(85.56,181.22)
  L3 w0.102: v5(85.56,181.22) 85.56,180.92 85.99,180.49 85.99,179.63 87.03,178.59 87.73,178.59 87.94,178.8 90.79,178.8 91.31,178.27 95.74,178.27 95.75,178.27
  L3 w0.191: v5(167.17,154.22) 166.28,155.1 160.25,155.1 156.66,151.51 154,148.86 146.09,148.86 145.43,148.2 141.32,148.2 128.81,160.7 115.14,160.7 113.06,162.78 97.94,177.9 97.61,177.9 96.76,177.9 96.56,178.1 96.52,178.1 96.35,178.27 95.75,178.27
  BOTTOM w0.14: v3(168.06,154.24) 168.04,154.22 v5(167.17,154.22)
M_DATA_B39: length 102
  TOP w0.14: v5(165.67,154.16) 166.15,153.68 167.37,153.68 167.64,153.95 DIMM2.142 ; CPU1.AM12 v5(85.56,180.31)
  L3 w0.102: v5(85.56,180.31) 85.56,179.78 86.94,178.39 87.82,178.39 88.03,178.6 90.7,178.6 91.23,178.07 95.43,178.07 95.63,177.87
  L3 w0.191: v5(165.67,154.16) 165.64,154.16 165.12,154.69 160.41,154.69 157.06,151.34 154.17,148.45 153.83,148.45 146.47,148.45 145.76,147.74 141.2,147.74 128.65,160.29 114.98,160.29 112.65,162.61 97.78,177.49 96.8,177.49 96.69,177.6 96.64,177.6 96.44,177.81 96.4,177.81 96.34,177.87 95.63,177.87
  BOTTOM w0.14: v3(165.63,153.33) 165.67,153.37 v5(165.67,154.16)
M_DATA_B40: length 104
  TOP w0.14: CPU1.AP9 86.95,175.82 v5(87.41,176.28) ; DIMM2.147 162.81,152.45 v5(163.38,151.88)
  L3 w0.102: 93.78,176.61 93.6,176.79 90.43,176.79 90.33,176.69 89.06,176.69 88.73,176.35 88.73,176.16 88.42,175.85 88.03,175.85 87.6,176.28 v5(87.41,176.28)
  L3 w0.191: 93.78,176.61 95.34,175.04 96.11,175.04 115.64,155.51 127.93,155.51 134.26,149.18 134.53,149.18 135.01,149.66 135.28,149.66 135.55,149.39 135.55,149.12 135.07,148.64 135.07,148.37 135.34,148.1 135.61,148.1 136.09,148.58 136.36,148.58 136.63,148.31 136.63,148.04 136.15,147.56 136.15,147.29 136.42,147.02 136.69,147.02 137.17,147.5 137.44,147.5 137.71,147.23 137.71,146.97 137.23,146.49 137.23,146.22 137.5,145.95 137.77,145.95 137.85,146.03 138.16,146.03 138.38,145.8 138.38,145.49 138.3,145.41 138.3,145.14 139.64,143.8 140.84,143.8 141.18,143.8 142.91,143.8 153.29,143.8 160.89,151.4 162.9,151.4 v5(163.38,151.88)
  BOTTOM w0.14: v3(163.31,152.72) 163.31,151.95 v5(163.38,151.88)
M_DATA_B41: length 102.4
  TOP w0.14: CPU1.AR9 87.84,175.85 v5(88.25,176.26) ; v5(161.93,151.9) 161.88,151.85 DIMM2.149
  L3 w0.102: 94.13,176.8 93.87,177.05 90.81,177.05 90.28,177.58 89.04,177.58 88.67,177.21 88.67,177 88.25,176.57 v5(88.25,176.26)
  L3 w0.191: v5(161.93,151.9) 160.5,151.9 154.31,145.71 152.8,144.21 143.08,144.21 141.32,144.21 134.92,150.6 134.65,150.6 134.37,150.33 134.06,150.33 133.83,150.55 133.83,150.87 134.11,151.14 134.11,151.41 133.84,151.68 133.57,151.68 133.09,151.2 132.82,151.2 132.55,151.47 132.55,151.74 133.03,152.22 133.03,152.49 132.76,152.76 132.5,152.76 132.01,152.28 131.74,152.28 131.47,152.55 131.47,152.82 131.96,153.3 131.96,153.57 131.69,153.84 131.42,153.84 130.93,153.35 130.66,153.35 130.39,153.62 130.39,153.89 130.88,154.38 130.88,154.65 130.61,154.92 130.34,154.92 129.86,154.43 129.59,154.43 129.32,154.7 129.32,154.97 129.8,155.46 129.8,155.73 129.43,156.09 115.63,156.09 97.14,174.59 97.12,174.59 96.37,175.34 95.58,175.34 94.13,176.8
  BOTTOM w0.14: v3(161.08,151.95) 161.88,151.95 v5(161.93,151.9)
M_DATA_B42: length 102.3
  TOP w0.14: DIMM2.157 162.61,149.45 v5(164.07,147.99) ; CPU1.AP7 86.95,174 v5(87.39,174.44)
  L3 w0.102: v5(87.39,174.44) 87.05,174.1 87.05,173.37 87.34,173.09 88.41,173.09 88.66,172.83 88.66,172.55 89.02,172.2 89.4,172.2 89.48,172.12
  L3 w0.191: 89.48,172.12 89.65,171.94 89.65,171.56 89.96,171.26 92.22,171.26 93.52,169.96 97.75,169.96 114.34,153.38 127.09,153.38 139.77,140.7 145.31,140.7 146.04,139.97 152.52,139.97 161.39,148.85 163.21,148.85 v5(164.07,147.99)
  BOTTOM w0.14: v5(164.07,147.99) 164.07,148.86 v3(164,148.93)
M_DATA_B43: length 101.9
  TOP w0.14: DIMM2.159 161.76,148.85 v5(162.65,147.97) ; v5(87.46,172.62) 87,173.08 CPU1.AP6
  L3 w0.102: 89.32,170.88 88.77,171.44 88.77,171.97 88.53,172.21 87.87,172.21 v5(87.46,172.62)
  L3 w0.191: v5(162.65,147.97) 162.62,147.97 162.14,148.44 161.56,148.44 152.68,139.56 145.87,139.56 145.13,140.3 140.9,140.3 140.9,140.3 139.57,140.3 126.89,152.97 121.01,152.97 120.82,152.78 120.82,152.45 120.63,152.26 120.25,152.26 120.06,152.45 120.06,152.78 119.87,152.97 119.49,152.97 119.29,152.78 119.29,152.45 119.1,152.26 118.72,152.26 118.53,152.45 118.53,152.78 118.34,152.97 117.96,152.97 117.77,152.78 117.77,152.45 117.58,152.26 117.2,152.26 117.01,152.45 117.01,152.78 116.82,152.97 116.44,152.97 116.25,152.78 116.25,152.45 116.06,152.26 115.68,152.26 115.48,152.45 115.48,152.78 115.29,152.97 114.17,152.97 98.07,169.07 90.16,169.07 89.4,169.84 89.4,170.8 89.32,170.88
  BOTTOM w0.14: v3(162.45,148.93) 162.45,148.16 v5(162.65,147.97)
M_DATA_B44: length 104.4
  TOP w0.14: CPU1.AP10 86.96,176.74 v5(87.36,177.15) ; v5(165.06,151.88) 165.93,152.75 DIMM2.146
  L3 w0.102: v5(87.36,177.15) 87.99,177.78 88.17,177.78 88.38,177.99 90.45,177.99 90.98,177.46 94.51,177.46 95.79,176.17
  L3 w0.191: v5(165.06,151.88) 165.06,152.16 164.43,152.79 160.23,152.79 154.76,147.31 154.76,147.31 154.45,147 153.2,145.75 148.79,145.75 148.6,145.57 148.34,145.57 148.25,145.47 146.6,145.47 146.02,146.06 140.62,146.06 129.38,157.3 129.14,157.54 128.82,157.54 123.53,157.54 123.34,157.35 123.34,157.12 123.15,156.93 122.77,156.93 122.58,157.12 122.58,157.35 122.39,157.54 122.01,157.54 121.82,157.35 121.82,157.12 121.63,156.93 121.25,156.93 121.06,157.12 121.06,157.35 120.87,157.54 120.48,157.54 120.29,157.35 120.29,157.12 120.1,156.93 119.72,156.93 119.53,157.12 119.53,157.35 119.34,157.54 118.96,157.54 118.77,157.35 118.77,157.12 118.58,156.93 118.2,156.93 118.01,157.12 118.01,157.35 117.82,157.54 117.44,157.54 117.25,157.35 117.25,157.12 117.06,156.93 116.67,156.93 116.48,157.12 116.48,157.35 116.29,157.54 115.34,157.54 96.71,176.17 95.79,176.17
  BOTTOM w0.14: v3(164.53,151.17) 164.53,151.36 v5(165.06,151.88)
M_DATA_B45: length 103.9
  TOP w0.14: DIMM2.148 167.66,152.15 167.48,152.33 166.93,152.33 v5(166.48,151.88) ; CPU1.AR10 v5(88.27,177.16)
  L3 w0.102: v5(88.27,177.16) 88.89,177.79 90.36,177.79 90.9,177.25 94.26,177.25 94.5,177.02
  L3 w0.191: 94.5,177.02 95.75,175.77 96.54,175.77 115.78,156.53 123.75,156.53 123.94,156.72 123.94,156.95 124.13,157.14 124.51,157.14 124.7,156.95 124.7,156.72 124.89,156.53 125.28,156.53 125.47,156.72 125.47,156.95 125.66,157.14 126.04,157.14 126.23,156.95 126.23,156.72 126.42,156.53 126.8,156.53 126.99,156.72 126.99,156.95 127.18,157.14 127.56,157.14 127.75,156.95 127.75,156.72 127.94,156.53 129.58,156.53 140.48,145.63 142.34,145.63 142.54,145.44 142.54,145.21 142.73,145.02 143.11,145.02 143.3,145.21 143.3,145.44 143.49,145.63 143.87,145.63 144.06,145.44 144.06,145.21 144.25,145.02 144.63,145.02 144.82,145.21 144.82,145.44 145.01,145.63 145.74,145.63 146.3,145.07 148.42,145.07 148.51,145.16 148.77,145.16 148.96,145.34 153.37,145.34 154.14,146.12 160.4,152.38 164.27,152.38 164.58,152.07 164.58,151.68 164.86,151.4 166,151.4 v5(166.48,151.88)
  BOTTOM w0.14: v3(167.1,152.74) 167.1,152.5 v5(166.48,151.88)
M_DATA_B46: length 101.2
  TOP w0.14: DIMM2.158 166.7,149.15 v5(165.52,147.97) ; CPU1.AR7 87.84,173.92 v5(88.23,173.53)
  L3 w0.102: 89.71,172.83 89.45,173.09 88.82,173.09 88.37,173.53 v5(88.23,173.53)
  L3 w0.191: v5(165.52,147.97) 165.01,148.47 164.2,148.47 163.42,149.26 161.23,149.26 152.35,140.38 146.22,140.38 145.49,141.11 143.38,141.11 143.19,141.3 143.19,141.35 143,141.54 142.62,141.54 142.43,141.35 142.43,141.3 142.24,141.11 141.86,141.11 141.67,141.3 141.67,141.35 141.48,141.54 141.1,141.54 140.91,141.35 140.91,141.3 140.72,141.11 139.95,141.11 127.27,153.78 114.51,153.78 95.99,172.3 90.24,172.3 89.71,172.83
  BOTTOM w0.14: v5(165.52,147.97) 165.74,147.74 v3(166.31,147.74)
M_DATA_B47: length 100.5
  TOP w0.14: DIMM2.160 166.96,148.55 v5(166.91,148.5) ; v5(87.46,173.54) 87.84,173.16 CPU1.AR6
  L3 w0.102: v5(87.46,173.54) 87.9,173.98 89.38,173.98 89.65,173.7 89.65,173.37 89.93,173.09
  L3 w0.191: 89.93,173.09 90.32,172.71 96.16,172.71 114.67,154.19 127.44,154.19 139.68,141.95 148.84,141.95 149.42,141.37 152.76,141.37 161.06,149.66 163.59,149.66 164.37,148.88 166.53,148.88 v5(166.91,148.5)
  BOTTOM w0.14: v3(167.68,148.78) 167.4,148.5 v5(166.91,148.5)
M_DATA_B48: length 112.6
  TOP w0.14: CPU1.AM9 85.06,175.82 v2(84.6,176.29) ; DIMM2.163 161.61,147.65 162.14,147.13 163.05,147.13 v5(163.74,146.44)
  L3 w0.102: 86.12,168.59 85.97,168.74 85.97,171.83 85.59,172.21 85.59,174.2 85.21,174.58 85.21,175.67 84.6,176.28 v2(84.6,176.29)
  L3 w0.191: 86.12,168.59 90.1,164.62 98.66,164.62 107.08,156.2 107.35,156.2 107.63,156.48 107.9,156.48 108.17,156.21 108.17,155.94 107.89,155.66 107.89,155.39 108.16,155.12 108.43,155.12 108.71,155.4 108.98,155.4 109.25,155.13 109.25,154.86 108.97,154.58 108.97,154.31 109.24,154.04 109.51,154.04 109.79,154.32 110.06,154.32 110.33,154.05 110.33,153.78 110.04,153.5 110.04,153.23 110.31,152.96 110.58,152.96 110.72,153.1 111.04,153.1 111.26,152.88 111.26,152.56 111.12,152.42 111.12,152.15 112.95,150.33 126.4,150.33 139.38,137.35 144.46,137.35 145.14,136.67 152.19,136.67 161.43,145.91 163.21,145.91 v5(163.74,146.44)
  BOTTOM w0.14: v3(163.42,147.18) 163.74,146.86 v5(163.74,146.44)
M_DATA_B49: length 114
  TOP w0.14: CPU1.AL9 83.69,176.32 v5(83.69,176.34) ; DIMM2.165 161.59,147.05 162.15,146.49 v5(162.29,146.49)
  L3 w0.102: v5(83.69,176.34) 84.07,176.72 84.78,176.72 85.11,176.39 85.11,176.08 85.41,175.78 85.41,174.66 85.79,174.28 85.79,172.64 86.26,172.17 86.26,171.68 86.89,171.06 86.89,169.72 87.16,169.45 87.16,168.52
  L3 w0.191: 87.16,168.52 90.65,165.02 98.78,165.02 99.93,165.02 100.22,164.73 100.22,164.47 99.94,164.18 99.94,163.92 100.21,163.65 100.47,163.65 100.76,163.93 101.03,163.93 101.29,163.66 101.29,163.39 101.01,163.11 101.01,162.84 101.28,162.57 101.55,162.57 101.83,162.85 102.1,162.85 102.37,162.58 102.37,162.31 102.09,162.03 102.09,161.76 102.36,161.49 102.63,161.49 102.91,161.77 103.18,161.77 103.45,161.5 103.45,161.23 103.17,160.95 103.17,160.68 103.44,160.41 103.71,160.41 103.99,160.69 104.26,160.69 104.53,160.42 104.53,160.15 104.25,159.87 104.25,159.6 104.52,159.33 104.79,159.33 105.07,159.61 105.34,159.61 105.61,159.34 105.61,159.08 105.33,158.79 105.33,158.53 105.6,158.26 105.86,158.26 106.15,158.54 106.42,158.54 106.68,158.27 106.68,158 106.4,157.72 106.4,157.45 106.67,157.18 106.94,157.18 107.22,157.46 107.49,157.46 114.22,150.74 126.57,150.74 139.23,138.07 144.47,138.07 145.47,137.08 152.02,137.08 161.44,146.49 v5(162.29,146.49)
  BOTTOM w0.14: v3(161.36,146.44) 162.24,146.44 v5(162.29,146.49)
M_DATA_B50: length 111.9
  TOP w0.14: v5(83.72,173.59) 84.18,173.13 CPU1.AL6 ; DIMM2.175 163.14,144.05 163.48,143.71 v5(163.48,142.81)
  L3 w0.102: 83.38,172.17 83.33,172.22 83.33,172.95 83.72,173.34 v5(83.72,173.59)
  L3 w0.191: v5(163.48,142.81) 162.98,143.31 161.84,143.31 160.59,142.06 160.59,141.06 154.1,134.57 145.45,134.57 145.41,134.54 142.58,134.54 141.88,135.24 138.47,135.24 134.05,139.66 133.79,139.66 133.62,139.49 133.35,139.49 133.08,139.76 133.08,140.03 133.25,140.2 133.25,140.47 132.98,140.74 132.71,140.74 132.54,140.57 132.27,140.57 132,140.84 132,141.11 132.17,141.28 132.17,141.55 126.41,147.31 113,147.31 97.78,162.52 88.25,162.52 88.01,162.76 87.78,163 83.56,167.21 83.56,169.3 83.67,169.41 83.67,171.88 83.38,172.17
  BOTTOM w0.14: v5(163.48,142.81) 163.29,143.01 v3(163.29,143.7)
M_DATA_B51: length 113
  TOP w0.14: v5(83.68,174.46) 84.14,174 CPU1.AL7 ; DIMM2.177 161.42,143.45 v5(162.04,142.84)
  L3 w0.102: 83.38,171.18 83.38,171.82 83.13,172.07 83.13,173.09 83.27,173.23 83.27,174.05 v5(83.68,174.46)
  L3 w0.191: 83.38,171.18 83.38,169.53 83.27,169.42 83.27,167.74 83.27,167.74 83.27,167.25 83.27,166.93 88.08,162.11 97.58,162.11 112.79,146.9 125.37,146.9 125.97,146.29 126.24,146.29 126.41,146.46 126.68,146.46 126.95,146.19 126.95,145.92 126.78,145.75 126.78,145.48 127.05,145.21 127.32,145.21 127.49,145.38 127.76,145.38 128.03,145.11 128.03,144.84 127.86,144.68 127.86,144.41 128.13,144.14 128.4,144.14 128.57,144.3 128.84,144.3 129.11,144.03 129.11,143.76 128.94,143.6 128.94,143.33 129.21,143.06 129.48,143.06 129.65,143.23 129.91,143.23 130.18,142.96 130.18,142.69 130.02,142.52 130.02,142.25 130.29,141.98 130.56,141.98 130.72,142.15 130.99,142.15 131.26,141.88 131.26,141.61 131.09,141.44 131.09,141.17 137.43,134.83 141.55,134.83 143.74,132.64 152.74,132.64 161.08,140.98 161.08,141.88 v5(162.04,142.84)
  BOTTOM w0.14: v3(161.16,142.86) 162.01,142.86 v5(162.04,142.84)
M_DATA_B52: length 113
  TOP w0.14: v5(165.16,146.39) 166.12,147.35 DIMM2.164 ; v2(85.54,176.26) 85.54,176.3 CPU1.AM10
  L3 w0.102: v2(85.54,176.26) 85.69,176.11 85.69,174.79 86,174.48 86,173.33 86.34,172.99 86.6,172.99 86.84,172.75 86.84,171.66 87.29,171.21 87.49,171.21 87.72,170.97 87.72,170.6 87.75,170.57
  L3 w0.191: v5(165.16,146.39) 164.58,146.98 161.28,146.98 152.4,138.09 149.49,138.09 148.84,138.75 139.14,138.75 127.89,149.99 126.74,151.14 114.39,151.14 99.99,165.54 98.31,165.54 98.12,165.73 98.12,166.19 97.93,166.38 97.55,166.38 97.36,166.19 97.36,165.73 97.17,165.54 96.79,165.54 96.6,165.73 96.6,166.19 96.41,166.38 96.03,166.38 95.84,166.19 95.84,165.73 95.65,165.54 95.27,165.54 95.08,165.73 95.08,166.19 94.89,166.38 94.5,166.38 94.31,166.19 94.31,165.73 94.12,165.54 93.74,165.54 93.55,165.73 93.55,166.19 93.36,166.38 92.98,166.38 92.79,166.19 92.79,165.73 92.6,165.54 92.02,165.54 89.18,168.38 88.29,168.38 87.77,168.9 87.77,170.55 87.75,170.57
  BOTTOM w0.14: v3(164.99,147.2) 164.99,146.56 v5(165.16,146.39)
M_DATA_B53: length 114
  TOP w0.14: DIMM2.166 167.52,146.75 v5(167.14,146.37) ; CPU1.AL10 84.18,176.81 v2(84.63,177.25)
  L3 w0.102: v2(84.63,177.25) 84.91,176.97 85.44,176.97 85.97,176.44 85.97,175.36 86.45,174.89 86.64,174.89 86.9,174.62 86.9,174.29 86.85,174.23 86.85,173.03 87.04,172.84 87.04,172.35 87.19,172.2 87.47,172.2 87.93,171.74 87.93,171.52 88.17,171.28 88.49,171.28 88.97,170.8 88.97,170.5
  L3 w0.191: 88.97,170.5 88.97,169.84 90.04,168.77 90.32,168.77 91.92,167.17 93.61,167.17 93.8,167.36 93.8,168.2 93.99,168.39 94.37,168.39 94.56,168.2 94.56,167.36 94.75,167.17 95.13,167.17 95.32,167.36 95.32,168.2 95.51,168.39 95.89,168.39 96.08,168.2 96.08,167.36 96.28,167.17 96.66,167.17 96.85,167.36 96.85,168.2 97.04,168.39 97.42,168.39 97.61,168.2 97.61,167.36 97.8,167.17 98.95,167.17 114.57,151.55 126.91,151.55 127.82,150.63 127.82,150.63 128.06,150.4 128.3,150.16 139.3,139.15 152.88,139.15 161.11,147.38 166.13,147.38 v5(167.14,146.37)
  BOTTOM w0.14: v3(168.01,146.32) 167.19,146.32 v5(167.14,146.37)
M_DATA_B54: length 110.7
  TOP w0.14: CPU1.AM6 84.63,172.62 v5(84.6,172.62) ; v5(164.92,143.12) 164.92,143.8 165.46,144.35 DIMM2.174
  L3 w0.102: v5(84.6,172.62) 84.24,172.25 84.24,168.62 84.14,168.52
  L3 w0.191: 84.14,168.52 84.14,167.78 88.59,163.33 98.13,163.33 113.33,148.13 126.75,148.13 138.82,136.07 142.5,136.07 143.22,135.35 144.83,135.35 144.87,135.39 153.76,135.39 159.7,141.32 159.7,142.32 161.5,144.13 164.62,144.13 164.92,143.83 v5(164.92,143.12)
  BOTTOM w0.14: v5(164.92,143.12) 165.12,143.32 v3(165.12,144.11)
