# Allegro board 14058-1.0623WZS1658.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDSP_B_TX_DP_0: length 307.3
  TOP w0.102: v2(167.04,53.04) 166.74,52.74 166.74,52.46 C12212.1 ; v2(48.62,186.75) 48.9,186.47 48.9,185.61 49.48,185.03 56.11,185.03 58.04,186.95 58.43,186.95 CPU1.C21
  L4 w0.127: v2(167.04,53.04) 167.04,52.93 161.47,47.36 161.31,47.2 158.85,47.2 158.49,46.85 155.92,46.85 155.24,46.16 155.24,46.16 154.4,45.32 154.18,45.32 145.14,45.33 144.41,44.6 130.65,44.6 129.11,43.06 120.98,43.06 119.4,44.65 110.8,44.65 104.24,51.21 98.53,51.21 98.07,50.75 80.68,50.75 79.56,51.87 66.6,51.87 64.92,53.55 38.78,53.55 38.27,54.06 35.61,54.06 19.55,70.12 19.55,84.77 24.68,89.9 24.68,103.72 25.46,104.49 25.46,108.57 25.84,108.95 25.84,121.74 30.85,126.76 30.85,130.16 34.37,133.68 34.37,138.76 37.41,141.79 37.41,146.2 47,155.78 47,171.89 45.15,173.74 45.15,181.81 48.62,185.28 v2(48.62,186.75)
  BOTTOM w0.102: v3(167.18,52.45) v2(167.04,53.04)
DDSP_B_TX_DP_1: length 300.6
  TOP w0.102: C12210.1 162.93,52.46 162.93,52.74 v2(163.23,53.04) ; v2(51.02,186.77) 51.31,186.47 51.31,186.1 51.63,185.79 55.15,185.79 57.41,188.04 59.16,188.04 CPU1.D22
  L4 w0.127: v2(51.02,186.77) 51.02,186.48 50.53,185.98 50.42,185.98 45.93,181.49 45.93,174.06 47.81,172.18 47.81,155.5 38.18,145.87 38.18,141.45 35.15,138.42 35.15,133.36 31.63,129.84 31.63,126.41 27.96,122.74 27.96,118.1 26.61,116.76 26.61,108.49 26.23,108.11 26.23,104 25.46,103.22 25.46,89.52 20.33,84.39 20.33,70.44 35.85,54.91 38.85,54.91 39.44,54.33 65.24,54.33 66.93,52.64 80.19,52.64 80.85,51.98 104.56,51.98 111.12,45.43 119.73,45.43 121.32,43.84 128.79,43.84 130.56,45.61 137.07,45.61 138.32,46.86 154.84,46.86 155.53,47.55 157.87,49.88 160.58,49.88 160.74,50.04 162.95,52.25 162.95,52.77 v2(163.23,53.04)
  BOTTOM w0.102: v3(163.56,52.54) v2(163.23,53.04)
DDSP_B_TX_DP_2: length 297.7
  TOP w0.102: CPU1.B23 57.27,188.63 56.08,187.44 52.47,187.44 51.41,188.5 51.41,188.93 v2(51.12,189.22) ; C12208.1 159.12,52.46 159.12,52.74 v2(159.42,53.04)
  L4 w0.127: v2(159.42,53.04) 159.14,52.77 159.14,52.26 154.76,47.87 154.52,47.64 137.79,47.64 136.58,46.43 130.29,46.43 128.47,44.61 121.66,44.61 120.06,46.21 111.43,46.21 104.89,52.75 81.48,52.75 80.82,53.41 70.77,53.41 69.08,55.11 39.76,55.11 39.18,55.69 36.17,55.69 21.25,70.61 21.25,84.16 26.23,89.14 26.23,102.8 27.01,103.57 27.01,107.56 27.39,107.94 27.39,116.43 28.73,117.78 28.73,121.36 32.4,125.03 32.4,129.52 35.92,133.04 35.92,135.73 38.96,138.76 38.96,144.66 48.58,154.29 48.58,172.5 46.7,174.38 46.7,181.17 50.74,185.21 51.95,185.21 53.14,186.41 53.14,187.07 52.53,187.68 52.03,187.68 51.36,188.34 51.36,188.97 v2(51.12,189.22)
  BOTTOM w0.102: v3(159.59,53.62) v2(159.42,53.04)
DDSP_B_TX_DP_3: length 292.1
  TOP w0.102: CPU1.C23 58.58,188.72 58.35,188.96 56.34,188.96 55.49,188.11 54.08,188.11 53.79,188.4 53.79,188.98 v2(53.51,189.27) ; C12214.1 155.17,52.47 155.17,52.67 155.25,52.74 156.1,52.74 156.61,52.23 157.3,52.23 v2(157.6,51.93)
  L4 w0.127: v2(157.6,51.93) 157.22,52.31 156.96,52.31 153.22,48.57 153.06,48.41 135.53,48.41 134.32,47.2 129.97,47.2 128.27,45.5 121.89,45.5 120.39,47 112.99,47 112.24,47.75 111.12,47.75 107.87,51 107.87,51.78 106.11,53.53 91.94,53.53 90.99,54.48 85.45,54.48 84.55,55.38 73.99,55.38 73.49,55.88 40.15,55.88 39.57,56.46 36.49,56.46 22.19,70.76 22.19,83.42 27.01,88.24 27.01,102.35 27.78,103.13 27.78,107.23 28.16,107.61 28.16,115.32 32.44,119.6 32.44,123.03 33.19,123.78 33.19,129.21 36.7,132.72 36.7,135.41 39.73,138.44 39.73,144.32 49.36,153.94 49.36,181.61 54.43,186.68 54.43,187.44 53.71,188.15 53.71,189.06 v2(53.51,189.27)
  BOTTOM w0.102: v3(157.28,51.41) v2(157.6,51.93)
DDSP_C_HPD_CONN: length 2.8
  TOP w0.102: TP240.1 122.71,236.25 NGFF1.31
DDSP_C_TX_DN_0_C: length 2.7
  TOP w0.102: NGFF1.32 133.71,236.5 133.9,236.68 134.47,236.68 TP231.1
DDSP_C_TX_DN_1_C: length 4.3
  TOP w0.102: TP233.1 136.26,235.14 133.92,235.14 133.78,235 NGFF1.26
DDSP_C_TX_DN_2_C: length 3.6
  TOP w0.102: TP237.1 122.2,234.89 123.64,234.89 123.78,234.75 NGFF1.25
DDSP_C_TX_DN_3_C: length 4.9
  TOP w0.102: TP239.1 120.85,233.03 122.54,233.03 122.9,233.39 123.64,233.39 123.78,233.25 NGFF1.19
DDSP_C_TX_DP_0_C: length 2.6
  TOP w0.102: NGFF1.34 133.78,237 133.88,236.9 134.62,236.9 TP230.1
DDSP_C_TX_DP_1_C: length 4.3
  TOP w0.102: TP232.1 136.13,235.36 133.92,235.36 133.78,235.5 NGFF1.28
DDSP_C_TX_DP_2_C: length 3.5
  TOP w0.102: NGFF1.27 123.78,235.25 123.64,235.11 122.07,235.11 TP236.1
DDSP_C_TX_DP_3_C: length 5
  TOP w0.102: NGFF1.21 123.78,233.75 123.64,233.61 122.81,233.61 122.45,233.25 120.88,233.25 TP238.1
DET_HDMI#: length 138.1
  TOP w0.102: SCA1.37 43.09,46.46 42.82,46.73 42.82,47.26 43.4,47.84 v2(43.4,48.21) ; v2(108.27,42.2) R7918.2 108.78,42.79 112.1,42.79 Q7903.G ; U5202.2 140.09,12.92 R5216.2 140.09,15.48 R5215.2 139.34,15.54 136.39,12.59 136.39,11.72 135.44,10.77 132.66,10.77 129.74,13.7 v1(129.74,24.6) 129.74,26.76 v2(129.43,27.06)
  L4 w0.127: v2(129.43,27.06) 129.31,27.06 128.07,28.3 122.63,28.3 119.31,31.62 117.97,31.62 117.76,31.62 109.42,39.96 109.42,41.06 v2(108.27,42.2) 108.27,42.51 103.66,47.12 101.4,47.12 100.72,47.8 99.86,47.8 99.2,47.15 64.6,47.15 61.5,50.25 49.79,50.25 48.97,49.44 46.42,49.44 45.43,48.45 45.43,47.84 45.12,47.52 43.67,47.52 43.4,47.79 v2(43.4,48.21)
DET_HDMI_C: length 16.7
  TOP w0.102: v2(139.82,17.61) 139.82,16.76 R5215.1 ; v2(148.02,17.79) 148.02,15.61 149.61,14.02 HDMI2.11
  L3 w0.127: v2(139.82,17.61) 140.63,17.61 141.21,18.19 147.63,18.19 v2(148.02,17.79)
  BOTTOM w0.102: v3(139.82,18.43) v2(139.82,17.61)
DGPU_PWR_EN: length 2.6
  TOP w0.102: Q9632.5 88,130.31 v1(87.93,130.39) 87.89,130.43 R80054.2
DGPU_PWR_EN#: length 11.4
  TOP w0.102: R80055.1 92.06,130.78 92.06,130.59 91.79,130.31 Q9632.2 ; R80055.1 93.34,131.52 93.34,131.29 93.68,130.95 94.23,130.95 94.63,130.54 Q9633.5 Q9633.2 ; R80055.1 91.99,131.79 91.2,132.57 v1(91.2,132.6) 91.15,132.55 Q9632.3
DIMM_CA_CPU_VREF_A: length 45.1
  TOP w0.254: v2(77.16,207) 77.16,206.66 CPU1.AB40
  BOTTOM w0.254: R4.1 107.96,226.05 C3.1 ; C3.1 107.57,224.43 106.62,223.48 95.8,223.48 90.9,218.58 84.93,218.58 v3(82.13,215.78) 78.1,211.75 78.1,207.94 v2(77.16,207) ; C3.1 108.34,224.9 R3.1
DIMM_CA_CPU_VREF_RC: length 3
  BOTTOM w0.254: R5.1 105.54,224.86 105.97,224.44 v3(106.09,224.44) 106.69,225.03 C3.2
DIMM_CA_VREF_A: length 103.5
  TOP w0.254: DIMM1.126 155.17,158.75 v5(155.44,159.02)
  L4 w0.254: v2(111.5,224.6) 112.59,223.51 112.59,220.2 126.43,206.36 145.79,206.36 153.69,198.46 153.69,165.64 155.44,163.9 v5(155.44,159.02)
  BOTTOM w0.254: R83.2 C115.1 154.07,158.62 C114.1 154.94,159.51 v5(155.44,159.02) v3(155.44,158.1) ; v2(111.5,224.6) 110.69,224.6 110.25,225.03 109.99,225.03 R3.2
DIMM_CA_VREF_A_L: length 3.5
  BOTTOM w0.254: R83.1 153.17,156.58 R84.1 R82.2 155.07,156.51 v3(155.36,156.22)
DIMM_CA_VREF_B: length 127.5
  TOP w0.254: DIMM2.126 170.25,158.75 v5(170.37,158.63)
  TOP w0.635: v2(169.23,202.68) 162.42,202.68 156.96,208.14 155.65,208.14 155.65,208.14 125.05,208.14 121.35,211.83 121.35,224.52 v2(119.83,226.05)
  L4 w0.635: v2(169.23,202.68) 169.23,201.43 170.25,200.42 170.25,193.79 172.02,192.02 172.02,160.07 170.68,158.74 170.47,158.74 v5(170.37,158.63)
  BOTTOM w0.635: v2(119.83,226.05) v3(117.8,226.05) R4.2 ; C139.1 C138.1 170.38,157.53 170.38,158.63 v5(170.37,158.63) 169.7,158.63 R94.2
DIMM_CA_VREF_B_L: length 4.2
  BOTTOM w0.635: R93.2 168.1,159.63 167.58,159.1 v3(167.58,158.86) 167.96,158.48 R94.1 168.66,158.14 168.22,157.69 R95.1
DIMM_DQ_CPU_VREF_A: length 100.1
  TOP w0.254: v2(77.16,207.89) 77.67,207.38 77.67,206.49 CPU1.AC40
  L4 w0.254: v2(108.27,226.81) 108.27,223.63 126.18,205.73 143.58,205.73 v2(148.02,201.28)
  BOTTOM w0.254: R79.1 145.36,199.31 C111.1 145.42,200.33 146.37,201.28 v2(148.02,201.28) ; v2(108.27,226.81) C1.1 107.19,227 106.7,227.49 105.17,227.49 103.59,225.92 97.35,225.92 90.62,219.19 84.65,219.19 v3(83.38,217.92) 77.54,212.08 77.54,209.84 77.67,209.71 77.67,208.39 v2(77.16,207.89)
DIMM_DQ_CPU_VREF_A_1: length 3.1
  BOTTOM w0.254: C111.2 145.36,202.17 145.1,202.42 v3(144.98,202.42) 144.72,202.42 144.34,202.04 R80.1
DIMM_DQ_CPU_VREF_B: length 116.3
  TOP w0.305: CPU1.AC39 77.8,205.46 v5(78.24,205.9)
  TOP w0.635: v2(163.01,200.65) 163.01,200.76 156.58,207.2 124.66,207.2 120.41,211.44 120.41,223.11 v2(119.83,223.7)
  BOTTOM w0.635: v5(78.24,205.9) 78.26,205.9 78.94,206.58 78.94,211.31 v3(80.05,212.43) 85.45,217.83 91.29,217.83 95.9,222.44 113.37,222.44 C2.1 v2(119.83,223.7) ; R90.1 C135.1 160.85,200.27 161.42,200.84 162.82,200.84 v2(163.01,200.65)
DIMM_DQ_CPU_VREF_B_1: length 2.4
  BOTTOM w0.254: v3(162.12,200.06) 162.12,199.19 R91.1 161.87,199 161.42,198.55 C135.2
DIMM_DQ_R_VREF_A: length 8.2
  TOP w0.305: DIMM1.1 145.25,199.12 145.76,199.63 v2(146.37,199.63)
  BOTTOM w0.635: C108.1 R77.2 142.27,198.04 142.23,198 v3(142.21,198) ; C108.1 144.4,198.11 R79.2 ; C108.1 C107.1 146.37,199.06 v2(146.37,199.63)
DIMM_DQ_R_VREF_A_L: length 3.4
  BOTTOM w0.254: R77.1 143.45,196.09 R78.1 143.49,196.03 R76.2 v3(142.26,194.97)
DIMM_DQ_R_VREF_B: length 6.1
  TOP w0.305: DIMM2.1 159.11,198.65 v2(158.95,198.49)
  BOTTOM w0.635: v3(158.13,198.49) v2(158.95,198.49) 159.01,198.55 R90.2 159.84,197.66 C133.1 C134.1 159.84,196.65 R88.2
DIMM_DQ_VREF_B: length 3
  BOTTOM w0.508: 160.79,194.8 160.72,194.87 R88.1 v3(158.88,194.87)
  BOTTOM w0.635: R89.1 160.79,194.8 R87.2
DIMM_TMPIN2+: length 261.1
  TOP w0.127: v2(102.43,54.98) 102.6,54.81 U109.86 ; RT1.2 128.85,145.93 128.85,139.76 133.8,134.8 133.8,126.99 v2(133.42,126.61)
  L4 w0.127: v2(190.06,127.24) 190.57,126.73 191.21,126.09 191.21,102.32 190.1,101.21 190.1,84.85 188.29,83.04 184.54,83.04 183.29,81.8 183.29,80.7 182.12,79.53 180.68,79.53 179.55,78.4 179.55,75.13 176.68,72.26 176.68,70.42 174.92,68.67 174.92,62.36 174.31,61.75 174.31,60.42 175.46,59.27 175.46,51.66 173.82,50.02 172.64,50.02 169.78,47.17 169.78,44.86 169.02,44.1 169.02,41.6 168.27,40.85 153.58,40.85 152.65,41.78 145.47,41.78 144.97,42.29 134.96,42.29 132.83,40.16 130.08,40.16 128.77,41.46 120.83,41.46 119.47,40.11 116.05,40.11 113.09,43.07 113.09,44 v2(112.91,44.18)
  BOTTOM w0.127: v2(133.42,126.61) 133.8,126.99 133.8,127.74 135.02,128.95 171.41,128.95 171.42,128.95 178.04,128.95 178.48,128.51 188.39,128.51 189.1,127.8 ; 189.1,127.8 189.66,127.24 v2(190.06,127.24) ; 189.1,127.8 v3(189.3,128) ; v2(112.91,44.18) 113.17,44.44 113.17,44.64 112.62,45.19 111.57,45.19 106.63,50.14 106.63,52.96 106.27,53.33 105.99,53.33 105.23,54.09 105.04,54.09 C12064.1 103.83,53.77 R79622.1 102.62,54.98 v2(102.43,54.98)
DIMM_TMPIN2-: length 257
  TOP w0.127: RT1.1 129.46,146.14 129.1,145.78 129.1,139.86 134.05,134.91 134.05,126.86 v2(134.31,126.61)
  L4 w0.127: v2(113.67,44.02) 113.67,44.11 113.34,43.78 113.34,43.18 116.16,40.36 119.37,40.36 120.72,41.72 128.88,41.72 130.18,40.41 132.72,40.41 134.85,42.54 145.07,42.54 145.58,42.04 152.75,42.04 153.69,41.1 168.16,41.1 168.76,41.71 168.76,44.21 169.53,44.97 169.53,47.27 172.53,50.28 173.72,50.28 175.2,51.76 175.2,59.17 174.06,60.31 174.06,61.86 174.67,62.47 174.67,68.77 176.42,70.53 176.42,72.36 179.29,75.23 179.29,78.51 180.57,79.79 182.02,79.79 183.04,80.81 183.04,81.9 184.43,83.3 188.19,83.3 189.85,84.95 189.85,101.31 190.96,102.43 190.96,125.98 190.85,126.09 190.46,126.48 v2(189.93,126.48)
  BOTTOM w0.127: 187.14,128.26 188.28,128.26 189.93,126.61 v2(189.93,126.48) ; 187.14,128.26 178.38,128.26 177.94,128.69 171.31,128.69 171.31,128.7 135.12,128.7 134.05,127.63 134.05,126.86 v2(134.31,126.61) ; 187.14,128.26 v3(187.14,127.95) ; v2(113.67,44.02) 113.67,44.11 113.42,44.35 113.42,44.75 112.72,45.45 111.68,45.45 106.89,50.24 106.89,53.07 106.38,53.58 106.09,53.58 105.33,54.34 105.03,54.34 C12064.2 103.96,54.66 R79621.2
DISP_UTIL_CPU: length 192.9
  TOP w0.102: v2(43.88,183.12) 45.03,183.12 45.23,182.92 45.36,182.92 45.57,182.71 46.01,182.71 46.21,182.92 47.47,182.92 47.49,182.9 47.93,182.9 47.94,182.92 49.79,182.92 49.87,182.84 50.23,182.84 51.22,181.85 56.2,181.85 56.38,181.67 57.82,181.67 58.21,181.28 58.21,181.16 58.49,180.88 59.01,180.88 CPU1.D14
  L4 w0.127: v2(43.88,183.12) 43.88,163.07 42.03,161.21 41.05,161.21 39.76,159.92 39.76,158.17 37.66,156.08 37.66,153.02 32.64,148 32.64,146.39 31.06,144.81 31.06,142.33 28.61,139.88 28.61,137.42 24.06,132.88 23.21,132.02 23.21,132.02 23.04,131.86 23.04,131.23 23.04,127.53 21.87,126.35 20.71,126.35 19.62,125.26 19.62,113.81 20.31,113.11 20.31,111.9 19.76,111.35 19.76,101.14 17.98,99.36 17.98,93.71 13.14,88.87 13.14,68.83 25.01,56.96 25.01,51.38 25.93,50.47 25.93,32.27 v2(27.22,30.97)
  BOTTOM w0.102: R79778.2 24.8,31.25 v3(25.85,31.25) 26.13,30.97 v2(27.22,30.97)
DMI_IT_MR_DN0: length 135.9
  TOP w0.102: v1(85.29,144.74) 85.67,144.74 ; 85.67,144.74 85.67,142.94 85.46,142.73 85.2,142.73 v2(84.91,143.03) ; 85.67,144.74 85.67,152.58 73.72,164.53 73.72,168.32 73.55,168.49 73.55,170.68 CPU1.Y4 ; v2(128.69,79.35) 128.44,79.59 128.44,79.82 128.53,79.91 129.74,79.91 130.18,79.48 130.97,79.48 U2.C27
  BOTTOM w0.102: v2(84.91,143.03) 85.2,142.73 85.54,142.73 85.88,142.39 85.88,141.07 88.99,137.96 90.93,137.96 92.46,136.42 110.27,136.42 128.39,118.3 128.39,96.72 129.23,95.88 129.23,86.29 125.93,82.99 125.93,80.81 126.1,80.63 128.09,80.63 128.42,80.3 128.42,79.62 v2(128.69,79.35)
DMI_IT_MR_DN1: length 133
  TOP w0.102: v2(127.23,81.29) 127.23,80.82 127.44,80.61 130.05,80.61 130.16,80.5 130.27,80.39 130.38,80.39 130.55,80.22 U2.B28 ; CPU1.AA5 74.47,171.6 74.47,170.13 74.2,169.85 74.2,165.24 87.06,152.37 87.06,142.91 86.85,142.7 86.68,142.7 v2(86.38,142.99)
  BOTTOM w0.102: 127.46,83.64 129.76,85.95 129.76,89.93 129.99,90.16 129.99,101.41 129.22,102.18 129.22,118.36 110.53,137.04 92.96,137.04 91.39,138.61 89.69,138.61 87.28,141.02 87.28,142.44 87.01,142.71 86.67,142.71 v2(86.38,142.99) ; 127.46,83.64 v3(127.68,83.43) ; 127.46,83.64 127.06,83.25 127.06,81.45 v2(127.23,81.29)
DMI_IT_MR_DN2: length 129.4
  TOP w0.102: CPU1.AB3 75.95,170.63 75.86,170.72 75.73,170.72 75.59,170.58 75.59,169.27 75.05,168.74 75.05,165.57 88.54,152.08 88.54,142.87 88.32,142.65 88.13,142.65 v2(87.83,142.35) ; U2.B29 130.53,80.86 128.92,80.86 128.61,81.18 128.32,81.18 v2(127.95,81.56)
  BOTTOM w0.102: 92.79,138.73 94.06,137.46 110.68,137.46 129.62,118.52 129.62,102.35 130.5,101.48 130.5,90.31 130.03,89.84 130.03,88.95 130.21,88.77 130.21,85.62 128.28,83.69 128.28,81.88 v2(127.95,81.56) ; 92.79,138.73 v3(92.55,138.49) ; 92.79,138.73 92.51,139.02 90.98,139.02 88.33,141.67 88.33,142.44 88.23,142.54 88.02,142.54 v2(87.83,142.35)
DMI_IT_MR_DN3: length 128
  TOP w0.102: CPU1.AC5 76.28,171.58 76.28,169.52 75.54,168.77 75.54,165.66 89.46,151.74 89.46,143.16 v2(89.16,142.86) ; v2(129.02,83.3) 129.32,83.01 129.57,83.01 129.9,82.68 129.9,82.35 130.6,81.65 130.6,81.5 U2.B30
  BOTTOM w0.102: 94.75,138.58 93.69,139.64 91.24,139.64 89.46,141.42 89.46,142.56 v2(89.16,142.86) ; 94.75,138.58 v3(94.53,138.37) ; 94.75,138.58 95.24,138.09 110.94,138.09 130.24,118.78 130.24,103.19 131.12,102.31 131.12,88.85 130.79,88.52 130.79,84.28 129.6,83.08 129.24,83.08 v2(129.02,83.3)
DMI_IT_MR_DP0: length 135.9
  TOP w0.102: CPU1.Y3 74.13,170.61 74.03,170.71 73.88,170.71 73.77,170.59 73.77,168.58 73.94,168.41 73.94,164.62 85.88,152.67 85.88,150.58 85.99,150.47 85.99,150.17 85.88,150.06 85.88,149.75 85.99,149.64 85.99,149.34 85.88,149.22 85.88,148.92 85.99,148.81 85.99,148.5 85.88,148.39 85.88,145.89 85.99,145.78 85.99,145.48 85.88,145.36 85.88,142.85 85.55,142.52 85.2,142.52 v2(84.91,142.22) ; v2(127.92,79.35) 128.22,79.65 128.22,79.91 128.44,80.13 129.83,80.13 130.27,79.69 130.59,79.69 U2.B27
  BOTTOM w0.102: v2(127.92,79.35) 128.2,79.62 128.2,80.21 128,80.42 126.51,80.42 ; v3(126.51,80.12) 126.51,80.42 ; 126.51,80.42 126.01,80.42 125.71,80.72 125.71,83.08 129.01,86.38 129.01,95.79 128.17,96.63 128.17,118.21 110.18,136.21 92.37,136.21 90.84,137.74 88.9,137.74 85.67,140.98 85.67,142.3 85.45,142.52 85.22,142.52 85.11,142.42 85.11,142.41 85.1,142.39 85.08,142.39 v2(84.91,142.22)
DMI_IT_MR_DP1: length 133
  TOP w0.102: CPU1.AA4 75.04,171.51 74.95,171.6 74.78,171.6 74.68,171.51 74.68,170.04 74.41,169.76 74.41,165.33 87.28,152.46 87.28,146.83 87.39,146.72 87.39,146.42 87.28,146.31 87.28,142.82 86.94,142.48 86.68,142.48 v2(86.38,142.18) ; v2(126.47,81.26) 126.48,81.26 127.01,80.73 127.01,80.73 127.24,80.5 127.35,80.39 129.96,80.39 130.18,80.17 130.19,80.17 U2.A28
  BOTTOM w0.102: 129.39,101.7 129,102.09 129,118.27 110.44,136.83 92.87,136.83 91.3,138.4 89.6,138.4 88.95,139.04 88.95,139.04 88.58,139.42 87.06,140.93 87.06,142.35 86.92,142.49 86.7,142.49 v2(86.38,142.18) ; 129.39,101.7 129.77,101.32 129.77,90.25 129.55,90.02 129.55,86.04 126.85,83.34 126.85,81.64 v2(126.47,81.26) ; 129.39,101.7 v3(129.15,101.46)
DMI_IT_MR_DP2: length 129.5
  TOP w0.102: U2.C29 130.83,81.08 129.01,81.08 128.71,81.38 v2(128.71,81.65) ; CPU1.AB4 75.37,170.67 75.37,169.36 74.84,168.83 74.84,165.48 88.33,151.99 88.33,144.94 ; v2(87.83,143.16) 88.13,142.86 88.23,142.86 88.33,142.96 88.33,144.94 ; 88.33,144.94 v1(87.95,144.94)
  BOTTOM w0.102: v2(87.83,143.16) 88.13,142.86 88.21,142.86 88.54,142.53 88.54,141.76 91.07,139.24 92.6,139.24 94.15,137.68 110.77,137.68 129.84,118.61 129.84,102.44 130.71,101.57 130.71,90.22 130.24,89.75 130.24,89.04 130.42,88.86 130.42,85.53 128.49,83.6 128.49,81.86 v2(128.71,81.65)
DMI_IT_MR_DP3: length 128
  TOP w0.102: 89.67,144.11 89.67,151.83 75.75,165.75 75.75,168.69 76.5,169.43 76.5,171.49 76.66,171.65 76.76,171.65 76.87,171.55 CPU1.AC4 ; 89.67,144.11 89.67,143.16 v2(89.97,142.86) ; 89.67,144.11 v1(90.06,144.11) ; U2.A30 130.25,81.69 129.69,82.26 129.69,82.59 129.48,82.79 129.28,82.79 v2(129.02,82.54)
  BOTTOM w0.102: v2(89.97,142.86) 89.67,142.56 89.67,141.51 91.33,139.86 93.78,139.86 95.33,138.3 111.03,138.3 130.46,118.87 130.46,103.28 131.34,102.4 131.34,92.52 131.45,92.41 131.45,92.1 131.34,91.99 131.34,91.69 131.45,91.57 131.45,91.27 131.34,91.16 131.34,88.76 131.01,88.43 131.01,84.19 129.69,82.87 129.36,82.87 v2(129.02,82.54)
DMI_MT_IR_DN0: length 133
  TOP w0.102: v2(134.8,80.18) 135.17,79.8 U2.L27 ; v2(90.87,146.49) 90.58,146.19 90.39,146.19 90.3,146.28 90.3,152.08 76.43,165.95 76.43,168.68 76.62,168.87 76.78,168.87 76.87,168.78 CPU1.AC1
  BOTTOM w0.102: 133.5,82.38 133.5,80.45 134.51,79.44 134.98,79.44 135.08,79.54 135.08,79.89 v2(134.8,80.18) ; 133.5,82.38 v3(133.83,82.38) ; 133.5,82.38 133.5,84.17 135.22,85.89 135.22,87.1 134.88,87.45 134.88,90.02 134.33,90.56 134.33,91.03 134.79,91.48 134.79,95.15 134.23,95.71 134.23,99.74 134.79,100.3 134.79,110.71 132.57,112.94 132.57,119.41 114.68,137.31 114.68,139.56 113.1,141.14 113.1,141.3 112.88,141.52 112.72,141.52 112.51,141.73 112.51,141.89 112.29,142.1 112.14,142.1 111.92,142.32 107.95,146.29 107.95,146.44 107.74,146.66 107.58,146.66 107.37,146.88 107.37,147.03 107.15,147.25 106.99,147.25 106.78,147.46 106.78,147.62 106.56,147.84 106.4,147.84 105.03,149.21 101.26,149.21 101.15,149.32 100.84,149.32 100.73,149.21 100.43,149.21 100.32,149.32 100.01,149.32 99.9,149.21 99.59,149.21 99.48,149.32 99.18,149.32 99.07,149.21 97.8,149.21 96.9,148.32 96.74,148.32 96.53,148.1 96.53,147.94 96.31,147.73 96.15,147.73 95.94,147.51 95.94,147.35 95.72,147.14 95.57,147.14 95.35,146.92 95.35,146.76 94.74,146.16 91.2,146.16 v2(90.87,146.49)
DMI_MT_IR_DN1: length 131
  TOP w0.102: U2.E24 132.12,78.02 v2(131.99,77.89) ; v2(92.15,142.22) 91.76,142.61 91.76,151.5 77.11,166.15 77.11,167.8 77.43,168.12 77.43,169.68 77.56,169.81 77.69,169.81 77.78,169.72 CPU1.AD2
  BOTTOM w0.102: v2(131.99,77.89) 132.31,77.56 132.31,77.45 132.03,77.16 131.48,77.16 131.26,77.38 131.26,83.7 132.05,84.49 132.05,85.43 132.43,85.81 132.43,87.01 132.83,87.41 132.83,89.71 132.64,89.9 132.64,94.19 131.96,94.88 131.96,102.67 131.08,103.54 131.08,119.13 111.29,138.92 109.63,138.92 109.52,139.04 109.22,139.04 109.11,138.92 108.8,138.92 108.69,139.04 108.38,139.04 108.27,138.92 107.97,138.92 107.86,139.04 107.55,139.04 107.44,138.92 106.88,138.92 ; 106.88,138.92 105.54,138.92 105.42,139.04 105.12,139.04 105.01,138.92 104.7,138.92 104.59,139.04 104.29,139.04 104.18,138.92 103.87,138.92 103.76,139.04 103.45,139.04 103.34,138.92 98.26,138.92 98.15,139.04 97.85,139.04 97.73,138.92 97.43,138.92 97.32,139.04 97.01,139.04 96.9,138.92 96.6,138.92 96.48,139.04 96.18,139.04 96.07,138.92 95.62,138.92 94.07,140.48 92.42,140.48 91.83,141.07 91.83,141.91 v2(92.15,142.22) ; 106.88,138.92 v3(106.88,139.23)
DMI_MT_IR_DN2: length 129.9
  TOP w0.102: v2(93.41,143.88) 93.41,143.88 93.13,143.59 92.62,143.59 92.39,143.83 92.39,145.5 ; 92.39,145.5 92.39,151.77 78.34,165.82 78.34,168.76 78.46,168.89 78.63,168.89 78.7,168.82 CPU1.AE1 ; 92.39,145.5 v1(92.75,145.5) ; U2.G27 132.88,79.2 v2(133.03,79.05)
  BOTTOM w0.102: v2(133.03,79.05) 132.74,79.34 132.74,80.32 131.84,81.23 131.84,83.49 133.84,85.5 133.84,87.15 134.04,87.35 134.04,89.66 133.13,90.58 133.13,90.78 133.26,90.91 133.26,94.45 132.58,95.13 132.58,103.19 131.77,104 131.77,119.02 131.77,119.32 107.72,143.37 107.72,144.63 105.53,146.83 105.53,146.99 105.31,147.2 105.15,147.2 103.82,148.54 99.33,148.54 94.36,143.57 93.72,143.57 93.41,143.88 v2(93.41,143.88)
DMI_MT_IR_DN3: length 128.2
  TOP w0.102: U2.L29 135.53,81.16 v2(135.53,81.32) ; v2(93.08,146.67) 93.45,147.04 93.45,151.28 78.81,165.92 78.81,168.09 79.04,168.32 79.04,169.77 CPU1.AF3
  BOTTOM w0.102: v2(93.08,146.67) 93.5,147.09 93.5,148.13 95.64,150.27 105.41,150.27 115.54,140.13 115.54,137.32 133.66,119.2 133.66,112.8 134.49,111.98 ; v2(135.53,81.32) 135.23,81.61 135.23,82.37 134.66,82.94 134.66,84.65 135.76,85.74 135.76,86.4 136.05,86.69 136.05,88.92 135.41,89.56 135.41,111.05 134.49,111.98 ; 134.49,111.98 v3(134.74,112.23)
DMI_MT_IR_DP0: length 132.9
  TOP w0.102: v2(90.87,145.67) 90.58,145.97 90.3,145.97 90.08,146.19 90.08,151.99 76.21,165.87 76.21,168.76 CPU1.AC2 ; U2.N27 135.93,79.9 v2(135.58,80.25)
  BOTTOM w0.102: v2(135.58,80.25) 135.3,79.97 135.3,79.45 135.07,79.22 134.42,79.22 133.28,80.36 133.28,84.26 135.01,85.98 135.01,87.01 134.66,87.36 134.66,89.93 134.12,90.47 134.12,91.12 134.57,91.57 134.57,95.06 134.02,95.62 134.02,99.83 134.57,100.39 134.57,110.62 132.35,112.85 132.35,119.32 114.46,137.22 114.46,139.47 110.38,143.55 ; v2(90.87,145.67) 91.14,145.94 94.83,145.94 97.89,149 104.94,149 110.38,143.55 ; v3(110.18,143.34) 110.38,143.55
DMI_MT_IR_DP1: length 131
  TOP w0.102: U2.G24 132.88,77.96 v2(132.78,77.85) ; v2(91.25,142.23) 91.55,142.52 91.55,151.41 76.89,166.06 76.89,167.89 77.21,168.21 77.21,169.77 CPU1.AD3
  BOTTOM w0.102: 131.04,78.22 131.04,77.29 131.39,76.95 132.12,76.95 132.53,77.36 132.53,77.6 v2(132.78,77.85) ; 131.04,78.22 v3(130.73,78.22) ; 131.04,78.22 131.04,83.79 131.83,84.58 131.83,85.52 132.21,85.9 132.21,87.1 132.62,87.5 132.62,89.62 132.43,89.81 132.43,94.1 131.74,94.79 131.74,102.58 130.87,103.45 130.87,119.04 111.2,138.71 95.53,138.71 93.98,140.26 92.33,140.26 91.62,140.98 91.62,141.86 v2(91.25,142.23)
DMI_MT_IR_DP2: length 129.9
  TOP w0.102: v2(93.41,143.12) 93.15,143.38 92.53,143.38 92.17,143.74 92.17,151.68 78.13,165.73 78.13,168.85 CPU1.AE2 ; v2(132.27,79.01) 132.27,79.47 U2.E26
  BOTTOM w0.102: 110.5,140.29 107.51,143.28 107.51,144.54 103.73,148.32 99.42,148.32 94.45,143.36 93.66,143.36 v2(93.41,143.12) ; 110.5,140.29 v3(110.25,140.04) ; 110.5,140.29 131.55,119.23 131.55,103.91 132.36,103.1 132.36,95.04 133.05,94.36 133.05,91 132.91,90.87 132.91,90.49 133.83,89.57 133.83,87.44 133.62,87.24 133.62,85.59 131.62,83.58 131.62,81.14 132.53,80.23 132.53,79.27 v2(132.27,79.01)
DMI_MT_IR_DP3: length 128.2
  TOP w0.102: v2(94.07,146.65) 94.07,146.65 93.67,147.05 93.67,151.37 79.02,166.01 79.02,168 79.26,168.23 79.26,169.68 79.4,169.82 79.54,169.82 79.61,169.74 CPU1.AF2 ; U2.K29 134.68,81.07 v2(134.68,81.44)
  BOTTOM w0.102: 135.2,90.82 v3(134.84,90.82) ; 135.2,90.82 135.2,110.96 133.44,112.71 133.44,119.11 115.32,137.23 115.32,140.04 113.19,142.18 112.6,142.76 112.44,142.76 112.23,142.98 112.23,143.14 112.01,143.35 111.85,143.35 111.64,143.57 111.64,143.73 108.05,147.32 107.89,147.32 107.67,147.53 107.67,147.69 107.46,147.91 107.3,147.91 107.08,148.12 107.08,148.28 106.87,148.5 106.71,148.5 106.49,148.71 106.49,148.87 105.32,150.05 103.25,150.05 103.14,149.94 102.84,149.94 102.73,150.05 99.43,150.05 99.32,149.94 99.02,149.94 98.9,150.05 98.6,150.05 98.49,149.94 98.18,149.94 98.07,150.05 97.77,150.05 97.65,149.94 97.35,149.94 97.24,150.05 95.73,150.05 93.72,148.04 93.72,147 94.07,146.65 v2(94.07,146.65) ; 135.2,90.82 135.2,89.47 135.83,88.83 135.83,86.78 135.54,86.49 135.54,85.83 134.45,84.74 134.45,82.85 135.02,82.28 135.02,81.78 v2(134.68,81.44)
DP_AUXN_C: length 4.3
  TOP w0.102: 39.04,20.92 39.04,19.33 39.24,19.13 39.67,19.13 C12175.2 ; 39.04,20.92 v1(39.39,20.92) ; 39.04,20.92 39.04,21.49 R9530.1
DP_AUXP_C: length 4.6
  TOP w0.102: 38.82,19.52 38.82,21.49 R9527.1 ; 38.82,19.52 v1(38.47,19.52) ; 38.82,19.52 38.82,19.24 39.15,18.92 39.67,18.92 C12176.2
DP_LANE0N_C: length 4.3
  TOP w0.102: 45.36,33.82 45.36,33.98 45.03,34.31 44.79,34.31 44.64,34.46 SCA1.13 ; 45.36,33.82 45.36,33.35 45.6,33.11 46.34,33.11 C12180.2 ; 45.36,33.82 v1(45.71,33.82)
DP_LANE0P_C: length 3.9
  TOP w0.102: SCA1.12 44.63,33.95 44.77,34.1 44.94,34.1 45.14,33.89 45.14,33.26 45.51,32.89 46.47,32.89 C12179.2
DP_LANE1N_C: length 3.7
  TOP w0.102: SCA1.15 44.92,35.45 45.06,35.31 45.25,35.31 45.41,35.16 ; v1(45.69,35.43) 45.41,35.16 ; 45.41,35.16 45.71,34.86 46.31,34.86 C12182.2
DP_LANE1P_C: length 3.2
  TOP w0.102: SCA1.14 44.92,34.96 45.06,35.1 45.16,35.1 45.62,34.64 46.5,34.64 C12181.2
DP_LANE2N_C: length 3.2
  TOP w0.102: SCA1.17 44.92,36.46 45.06,36.31 45.54,36.31 46,36.78 46.45,36.78 C12338.2
DP_LANE2P_C: length 3.3
  TOP w0.102: SCA1.16 44.92,35.95 45.06,36.1 45.63,36.1 46.09,36.56 46.36,36.56 C12337.2
DP_LANE3N_C: length 3.6
  TOP w0.102: C12340.2 46.45,38.56 46.02,38.56 45.5,38.04 45.5,37.87 44.94,37.31 44.77,37.31 44.63,37.45 SCA1.19
DP_LANE3P_C: length 4
  TOP w0.102: 45.48,37.55 45.03,37.1 44.83,37.1 44.68,36.95 SCA1.18 ; 45.48,37.55 45.71,37.78 45.71,37.95 46.11,38.34 46.36,38.34 C12339.2 ; 45.48,37.55 v1(45.74,37.3)
DP_RCOMP: length 6.8
  TOP w0.203: CPU1.M9 67.01,175.82 68.08,176.9
  TOP w0.508: 68.08,176.9 68.34,177.15 v2(69.28,177.15) 70.02,177.15 71.2,178.34 R71.1
  BOTTOM w0.508: v2(69.28,177.15) 69.92,176.52 v3(70.17,176.52)
DPD_AUXN: length 205.7
  TOP w0.102: v2(41.39,159.74) 41.69,160.03 45.36,160.03 48.8,163.47 48.8,170.8 55.98,177.98 59.19,177.98 59.25,178.04 59.63,178.04 60.16,178.57 CPU1.E12 ; C12175.1 41.24,19.12 42.37,19.12 42.78,18.72 42.78,18.05 R79755.2 R79172.1 42.72,16.16 42.72,15.68 v2(43.02,15.38)
  L4 w0.127: v2(41.39,159.74) 41.14,159.99 40.82,159.99 40.59,159.77 40.59,154.13 34.11,147.64 34.11,143.2 30.08,139.17 30.08,137.06 30.07,137.05 30.07,136.82 24.67,131.42 24.67,126.93 22.54,124.79 22.54,111.43 21.07,109.97 21.07,100.52 20.92,100.37 19.37,98.82 19.37,98.74 19.37,91.32 14.6,86.55 14.6,69.26 29.48,54.37 29.48,52.33 30.17,51.65 30.17,46.09 38.05,38.2 38.05,32.13 39.07,31.11 39.07,20.67 42.75,16.99 42.75,15.66 v2(43.02,15.38)
  BOTTOM w0.102: v3(43.38,14.85) v2(43.02,15.38)
DPD_AUXP: length 204.8
  TOP w0.102: v2(41.39,160.5) 41.65,160.25 45.27,160.25 48.58,163.56 48.58,170.89 55.89,178.2 59.03,178.2 59.4,178.57 CPU1.D12 ; C12176.1 41.23,18.91 42.28,18.91 42.56,18.63 42.56,18.16 R79171.2 R79756.1 42.51,16.16 42.51,15.68 v2(42.21,15.38)
  L4 w0.127: v2(41.39,160.5) 41.15,160.26 40.71,160.26 40.33,159.88 40.33,154.24 33.84,147.75 33.84,143.31 29.81,139.28 29.81,137.17 29.8,137.16 29.8,136.93 24.56,131.68 24.4,131.53 24.4,127.04 22.27,124.9 22.27,111.54 20.81,110.08 20.81,100.63 19.11,98.93 19.11,98.85 19.11,91.43 14.33,86.66 14.33,69.15 29.22,54.26 29.22,52.22 29.9,51.54 29.9,45.98 37.79,38.09 37.79,32.02 38.8,31 38.8,20.56 42.48,16.88 42.48,15.73 42.21,15.46 v2(42.21,15.38)
  BOTTOM w0.102: v2(42.21,15.38) v3(41.85,14.85)
DPD_LANE0N: length 190.9
  TOP w0.102: CPU1.D10 59.5,176.66 59.24,176.41 56.72,176.41 55.64,175.33 55.48,175.33 55.26,175.11 55.26,174.95 55.05,174.74 54.89,174.74 54.67,174.52 54.67,174.36 54.46,174.15 54.3,174.15 54.08,173.93 54.08,173.77 53.87,173.56 53.71,173.56 53.5,173.34 53.5,173.18 52.57,172.26 52.41,172.26 52.2,172.04 52.2,171.89 51.98,171.67 51.82,171.67 51.61,171.45 51.61,171.3 51.39,171.08 51.23,171.08 51.02,170.87 51.02,170.71 50.8,170.49 50.64,170.49 50.43,170.28 50.43,170.12 49.75,169.43 49.75,167.99 49.63,167.88 49.63,167.58 49.75,167.46 49.75,167.16 49.63,167.05 49.63,166.74 49.75,166.63 49.75,166.33 49.63,166.21 49.63,165.91 49.75,165.8 49.75,165.49 49.63,165.38 49.63,165.08 49.75,164.96 49.75,163.13 45.88,159.26 45.54,159.26 45.02,158.74 v2(44.9,158.74) ; C12180.1 47.97,33.18 49.59,33.18 49.85,33.44 v2(49.85,33.9)
  L4 w0.127: v2(49.85,33.9) 49.55,33.59 44.09,33.59 37.51,40.17 37.51,44.33 35.76,46.09 35.76,47 35.6,47.15 35.6,47.15 35.17,47.59 35.17,47.59 30.93,51.82 30.93,53.91 15.32,69.52 15.32,73.02 15.46,73.16 15.46,73.54 15.32,73.68 15.32,74.06 15.46,74.2 15.46,74.58 15.32,74.71 15.32,75.1 15.46,75.23 15.46,75.61 15.32,75.75 15.32,76.13 15.46,76.27 15.46,76.65 15.32,76.79 15.32,80.59 15.46,80.72 15.46,81.1 15.32,81.24 15.32,81.62 15.46,81.76 15.46,82.14 15.32,82.28 15.32,82.66 15.46,82.79 15.46,83.18 15.32,83.31 15.32,86.28 20.07,91.03 20.07,97.87 20.07,98.48 21.77,100.18 21.77,109.68 23.23,111.14 23.23,123.2 23.38,123.34 23.57,123.34 23.84,123.61 23.84,123.81 24.11,124.08 24.3,124.08 24.57,124.35 24.57,124.54 24.84,124.81 25.04,124.81 25.31,125.08 25.31,125.27 25.57,125.54 25.77,125.54 26.04,125.81 26.04,126.01 28.14,128.1 28.14,131.18 31.35,134.39 31.35,135.98 31.49,136.12 31.49,136.5 31.35,136.64 31.35,137.02 31.49,137.16 31.49,137.54 31.35,137.67 31.35,138.06 31.49,138.19 31.49,138.57 31.35,138.71 31.35,139.45 34.8,142.91 34.8,147.33 41.85,154.37 41.85,155.49 41.99,155.63 41.99,156.01 41.85,156.15 41.85,156.53 41.99,156.67 41.99,157.05 41.85,157.19 41.85,157.57 41.99,157.7 41.99,158.09 41.85,158.22 41.85,159.12 42.23,159.5 44.9,159.5 45.14,159.26 45.14,158.98 v2(44.9,158.74)
  BOTTOM w0.102: v3(44.99,158.13) v2(44.9,158.74)
DPD_LANE0P: length 191.3
  TOP w0.102: CPU1.E10 59.86,176.19 56.81,176.19 49.96,169.35 49.96,163.93 49.96,163.04 45.76,158.84 v2(45.76,158.69) ; v1(48.65,32.59) 48.65,32.96 ; 48.65,32.96 49.68,32.96 50.01,33.29 50.13,33.29 50.62,33.77 v2(50.62,33.9) ; 48.65,32.96 47.97,32.96 C12179.1
  L4 w0.127: v2(45.76,158.69) 45.71,158.69 45.41,158.99 45.41,159.37 45.01,159.76 42.12,159.76 41.59,159.23 41.59,154.48 34.54,147.44 34.54,143.02 31.08,139.56 31.08,134.5 27.87,131.29 27.87,128.21 22.97,123.31 22.97,111.25 21.51,109.79 21.51,100.29 19.8,98.59 19.8,98.56 19.8,97.76 19.8,97.76 19.8,91.15 15.06,86.4 15.06,69.41 30.66,53.8 30.66,51.71 35.06,47.32 35.06,47.32 35.34,47.04 35.34,47.04 35.49,46.89 35.49,45.98 37.24,44.22 37.24,40.06 43.82,33.48 43.98,33.32 50.04,33.32 v2(50.62,33.9)
  BOTTOM w0.102: v3(45.92,159.28) v2(45.76,158.69)
DPD_LANE1N: length 183.6
  TOP w0.102: v2(43.27,158.74) 43.18,158.74 42.83,158.38 42.83,158.28 42.96,158.15 47.31,158.15 48.02,158.86 48.05,158.89 48.55,159.39 48.55,159.54 48.76,159.76 48.92,159.76 49.14,159.98 49.14,160.13 49.35,160.35 49.51,160.35 49.73,160.56 49.73,160.72 49.94,160.94 50.1,160.94 50.31,161.15 51.03,161.87 51.03,164.93 50.92,165.04 50.92,165.35 51.03,165.46 51.03,165.76 50.92,165.88 50.92,166.18 51.03,166.29 51.03,166.6 50.92,166.71 50.92,167.01 51.03,167.13 51.03,169.1 52.34,170.41 52.34,170.57 52.56,170.78 52.71,170.78 52.93,171 52.93,171.16 53.15,171.37 53.3,171.37 53.52,171.59 53.52,171.75 53.73,171.96 53.89,171.96 55.28,173.35 55.28,173.51 55.5,173.73 55.66,173.73 55.87,173.94 55.87,174.1 56.09,174.32 56.25,174.32 56.46,174.53 56.46,174.69 56.68,174.91 56.84,174.91 57.39,175.46 58.22,175.46 CPU1.C9 ; v2(48.98,35.25) 48.68,34.96 47.97,34.96 C12182.1
  L4 w0.127: v2(48.98,35.25) 48.7,34.98 43.69,34.98 39.76,38.91 39.76,39.1 39.49,39.37 39.3,39.37 38.3,40.37 38.3,46.21 35.12,49.39 35.12,50.71 16.22,69.61 16.22,86.07 20.77,90.62 20.77,98.16 22.56,99.95 22.56,109.22 23.93,110.59 23.93,122.54 28.83,127.44 28.83,130.84 28.95,130.95 29.79,131.79 29.79,131.82 32.19,134.22 32.19,135.94 32.32,136.08 32.32,136.46 32.19,136.59 32.19,136.98 32.32,137.11 32.32,137.49 32.19,137.63 32.19,138.01 32.32,138.15 32.32,138.53 32.19,138.67 32.19,139.3 35.5,142.62 35.5,147.01 42.91,154.41 42.91,158.46 43.18,158.74 v2(43.27,158.74)
  BOTTOM w0.102: v3(43.48,159.31) v2(43.27,158.74)
DPD_LANE1P: length 183.6
  TOP w0.102: v2(48.98,34.44) 48.68,34.74 47.97,34.74 C12181.1 ; v2(42.39,158.74) 42.49,158.64 42.49,158.31 42.87,157.93 47.4,157.93 51.25,161.78 51.25,169.01 57.48,175.25 58.31,175.25 58.5,175.44 58.73,175.44 59.12,175.82 CPU1.D9
  L4 w0.127: v2(42.39,158.74) 42.64,158.49 42.64,154.52 35.24,147.12 35.24,142.73 31.92,139.41 31.92,134.33 29.68,132.08 29.52,131.93 29.52,131.9 28.68,131.06 28.57,130.95 28.57,127.55 23.67,122.65 23.67,110.7 22.29,109.33 22.29,100.06 20.5,98.27 20.5,90.73 15.96,86.18 15.96,69.5 34.85,50.6 34.85,49.28 38.03,46.1 38.03,40.26 43.58,34.71 48.7,34.71 v2(48.98,34.44)
  BOTTOM w0.102: v3(42.22,158.15) v2(42.39,158.74)
DPD_LANE2N: length 180.8
  TOP w0.102: CPU1.H10 62.66,176.25 v5(62.66,176.24) ; C12338.1 47.97,36.73 48.63,36.73 v2(48.93,37.03)
  L4 w0.127: v2(48.93,37.03) 48.66,36.76 46.66,36.76 45.58,37.84 42.73,37.84 39.06,41.51 39.06,46.27 39.06,46.28 39.06,46.5 36.61,48.94 36.01,49.54 36.01,50.81 35.82,51 18,68.82 18,85.24 23.28,90.52 23.28,90.52 23.44,90.68 23.44,104.43 24.25,105.24 24.25,109.58 24.63,109.96 24.63,122.25 29.53,127.15 29.53,130.55 29.65,130.66 33.17,134.18 33.17,139.28 36.2,142.32 36.2,146.7 43.6,154.1 43.6,156.68 43.87,156.95 44.14,156.95 v2(44.42,156.66)
  BOTTOM w0.102: 54.93,165.95 54.93,165.14 47.77,157.97 46.09,157.97 45.08,156.96 44.72,156.96 v2(44.42,156.66) ; 54.93,165.95 54.93,172.26 59.17,176.5 62.4,176.5 v5(62.66,176.24) ; 54.93,165.95 v3(55.26,165.95)
DPD_LANE2P: length 181.7
  TOP w0.102: v5(62.68,177.15) 62.27,176.74 CPU1.G10 ; C12337.1 47.97,36.52 48.63,36.52 v2(48.93,36.22)
  L4 w0.127: v2(44.42,157.47) 44.16,157.21 43.76,157.21 43.34,156.79 43.34,154.21 35.93,146.81 35.93,142.43 32.9,139.4 32.9,134.29 29.38,130.77 29.27,130.66 29.27,127.26 24.36,122.36 24.36,110.07 23.98,109.69 23.98,105.35 23.17,104.54 23.17,90.79 17.73,85.36 17.73,85.13 17.73,68.71 35.55,50.89 35.74,50.7 35.74,49.43 36.5,48.68 38.79,46.39 38.79,41.4 38.95,41.24 42.62,37.57 45.47,37.57 46.54,36.49 48.66,36.49 v2(48.93,36.22)
  BOTTOM w0.102: v2(44.42,157.47) 44.72,157.17 44.99,157.17 46,158.19 47.68,158.19 52.23,162.74 ; 52.23,162.74 54.72,165.23 54.72,172.35 59.09,176.72 62.23,176.72 62.66,177.15 v5(62.68,177.15) ; 52.23,162.74 v3(51.99,162.98)
DPD_LANE3N: length 176.1
  TOP w0.102: v2(48.98,38.81) 48.68,38.51 47.97,38.51 C12340.1 ; v5(61.76,175.34) CPU1.G9
  L4 w0.127: v2(46.42,156.66) 46.13,156.96 45.54,156.96 45.34,156.77 45.34,155.17 45.34,155.17 45.34,154.85 36.9,146.41 36.9,142.03 33.87,138.99 33.87,133.89 30.8,130.82 30.35,130.37 30.35,126.98 25.33,121.96 25.33,109.54 24.95,109.16 24.95,104.82 24.17,104.05 24.17,90.3 18.76,84.89 18.76,69.05 20.66,67.15 36.9,50.91 36.9,50.69 36.9,49.64 39.82,46.72 39.82,41.74 41.29,40.27 42.72,40.27 43.15,39.84 43.15,39.83 44.45,38.54 48.7,38.54 v2(48.98,38.81)
  BOTTOM w0.102: v3(56.48,170.14) 56.19,170.14 ; 56.19,170.14 56.19,165.49 47.63,156.93 46.69,156.93 v2(46.42,156.66) ; 56.19,170.14 56.19,171.04 56.71,171.56 57.73,171.56 58.74,172.58 60.01,172.58 61.45,174.02 61.45,175.04 v5(61.76,175.34)
DPD_LANE3P: length 176.7
  TOP w0.102: v2(48.98,38) 48.68,38.3 47.97,38.3 C12339.1 ; CPU1.F9 v5(60.88,175.38)
  L4 w0.127: v2(46.42,157.44) 46.21,157.22 45.42,157.22 45.08,156.88 45.08,154.96 36.63,146.52 36.63,142.14 33.6,139.1 33.6,134 30.69,131.09 30.08,130.48 30.08,127.09 25.06,122.07 25.06,109.65 24.68,109.27 24.68,104.94 23.91,104.16 23.91,90.41 18.5,85 18.5,68.93 36.63,50.8 36.63,49.53 36.79,49.38 39.55,46.61 39.55,41.63 41.18,40 42.61,40 42.88,39.73 42.88,39.72 44.33,38.27 48.7,38.27 v2(48.98,38)
  BOTTOM w0.102: v5(60.88,175.38) 61.24,175.02 61.24,174.11 59.92,172.79 58.65,172.79 57.64,171.78 56.62,171.78 55.97,171.13 55.97,168.34 ; 55.97,168.34 55.97,165.58 47.54,157.14 46.72,157.14 v2(46.42,157.44) ; 55.97,168.34 v3(55.67,168.34)
DPLVDS_BL_EN: length 133.7
  TOP w0.102: R79724.1 11.05,19.42 11.8,19.42 16.06,23.67 v2(17.32,23.67) ; v2(107.35,63.31) 107.78,63.74 109.29,63.74 109.38,63.83 U109.54 109.38,66.87 110.13,67.62 110.13,68.96 109.12,69.96 109.1,69.96 R280.1 ; v2(41.6,28.59) 41.6,28.45 41.51,28.37 SCA1.126 41.51,25.6 v2(42.21,24.9)
  L3 w0.127: v2(46.04,30.33) 46.04,31.5 47.54,33.01 51.15,33.01 51.79,33.64 53.16,33.64 57.7,38.19 62.44,38.19 69.41,45.16 79.15,45.16 80.21,45.16 81.58,46.53 82.72,46.53 87.53,51.34 90.99,51.34 91.6,51.95 92.15,51.95 92.18,51.98 92.57,51.98 92.59,51.95 98.1,51.95 99.86,53.72 99.86,56.29 103.83,60.26 103.83,60.88 104.91,61.96 105.32,61.96 106.68,63.31 v2(107.35,63.31)
  BOTTOM w0.102: v2(42.21,24.9) 42.03,24.9 40.75,23.62 29.15,23.62 28.66,24.11 25.25,24.11 23.34,26.02 21.33,26.02 20.82,25.51 19.16,25.51 v2(17.32,23.67) ; R9528.1 40.62,28.59 v2(41.6,28.59) 42.08,29.07 v3(43.76,29.07) 44.93,29.07 46.04,30.18 v2(46.04,30.33)
DPLVDS_HPD: length 17.7
  TOP w0.102: SCA1.110 33.51,26.23 33.67,26.07 33.67,25.45 33.35,25.13 32.25,25.13 31.74,24.62 28.01,24.62 27.86,24.78 22.78,24.78 v1(22.42,25.13) 21.43,25.13 20.26,23.96 R79763.1
DPLVDS_PANEL_VCC: length 29.9
  TOP w0.102: v2(34.74,46.09) 34.41,46.42 34.41,47.04 34.51,47.14 SCA1.55
  L4 w0.127: v2(31.18,45.96) 34.61,45.96 v2(34.74,46.09)
  BOTTOM w0.102: R9545.1 33.98,46.85 v2(34.74,46.09) ; v2(31.18,45.96) 31.18,44.69 30.79,44.3 28.5,44.3 v3(25.98,41.77) 23.06,38.85 23.06,33.39 21.69,32.02 21.69,30.82 R79734.2
DPLVDS_PWMIN: length 8.2
  BOTTOM w0.165: R79777.2 22.29,30.02 v3(22.51,30.25) 23.44,30.25 23.91,29.77 R79778.1 24.64,29.77 25.09,30.21 26.74,30.21 27.36,29.59 Q9614.1
DPLVDS_PWMOUT: length 38.8
  TOP w0.165: R79723.1 4.65,15.86 3.82,15.86 3.21,16.47 3.21,19.92 4.36,21.07 10.23,21.07 10.61,20.69 v1(12.01,20.69) 12.39,20.69 16.07,24.37 17.47,24.37 18.48,25.39 19.92,25.39 21.95,27.42 v2(23.18,27.42) ; SCA1.103 29.15,27.09 v2(27.88,25.82)
  L4 w0.165: v2(23.18,27.42) 26.28,27.42 v2(27.88,25.82)
  BOTTOM w0.165: Q9614.4 28.66,26.42 28.06,25.82 v2(27.88,25.82)
DQMA0: length 26.2
  TOP w0.127: VRAM2.E7 71.46,91.48 71.34,91.35 71.34,90.64 71.21,90.51 71.01,90.51 70.88,90.64 70.88,91.68 70.63,91.93 v5(70.21,91.93) ; v5(76.54,102.17) 76.96,102.59 GPU1.D19
  L3 w0.165: v5(76.54,102.17) 76.34,102.17 75.58,101.41 75.58,99.97 75.67,99.88 75.67,99.32 75.3,98.96 75.3,96.93 74.57,96.2 74.57,96.02 74.15,95.6 73.97,95.6 73.28,96.29 72.84,96.29 72.71,96.17 72.71,95.43 72.84,95.3 73.41,95.3 73.58,95.12 73.58,94.85 73.46,94.73 72.53,94.73 72.2,95.06 71.74,95.06 71.62,94.93 71.62,93.14 70.79,92.32 70.79,91.73 70.66,91.6 70.34,91.6 70.21,91.73 v5(70.21,91.93)
  BOTTOM w0.127: v5(70.21,91.93) 70.21,91.62 70.07,91.48 69.81,91.48 69.69,91.6 69.69,92.42 69.56,92.54 69.28,92.54 69.15,92.42 69.15,91.98 69.05,91.88 68.82,91.88 68.69,91.76 VRAM4.E7
DQMA1: length 19.1
  TOP w0.127: v5(80.67,103.04) 80.67,103.02 81.07,102.62 GPU1.D14 ; VRAM1.E7 84.56,91.48 v5(84.38,91.3)
  L3 w0.165: v5(84.38,91.3) 84.38,91.44 84.17,91.65 84.17,92.11 85.01,92.95 85.01,94.65 84.37,95.28 84.37,95.55 84.54,95.71 85.04,95.71 85.21,95.88 85.21,97.41 83.04,99.58 82.73,99.58 81.81,100.5 81.81,101.9 v5(80.67,103.04)
  BOTTOM w0.127: VRAM3.E7 84.19,91.48 84.37,91.3 v5(84.38,91.3)
DQMA2: length 23.7
  TOP w0.127: VRAM1.D3 83.07,91.93 v5(84.61,91.93) ; GPU1.C17 78.23,101.45 78.23,100.76 78.68,100.31 78.68,99.94 80.43,98.19 v5(80.43,97.04)
  L4 w0.165: v5(80.43,97.04) 80.59,96.88 80.59,95.82 80.75,95.65 82.59,95.65 82.96,95.27 82.96,93.52 83.87,92.61 83.87,89.74 84.14,89.47 84.5,89.47 84.82,89.78 84.82,91.72 v5(84.61,91.93)
  BOTTOM w0.127: VRAM3.D3 85.6,92.59 84.73,92.59 84.61,92.47 v5(84.61,91.93) ; v3(79.85,96.91) v5(80.43,97.04)
DQMA3: length 26
  TOP w0.127: VRAM2.D3 69,92.28 69.13,92.15 69.13,91.6 69.25,91.48 69.53,91.48 69.66,91.6 69.66,92.24 69.79,92.37 70.83,92.37 70.96,92.49 70.96,92.73 70.83,92.86 70.15,92.86 70.03,92.98 v5(69.55,92.98) ; v5(74.09,101.4) 74.48,101.8 GPU1.C22
  L4 w0.165: v5(69.55,92.98) 69.55,93.98 70.21,94.64 70.21,95.77 70.09,95.9 69.46,95.9 69.28,96.07 69.28,96.3 69.46,96.48 70.07,96.48 70.19,96.61 70.19,96.96 70.38,97.14 70.81,97.14 71.13,96.82 71.38,96.82 71.54,96.97 71.54,97.54 71.54,97.55 71.54,97.6 71.72,97.78 71.72,97.78 72.48,98.54 73.17,98.54 73.62,98.99 73.62,99.41 73.3,99.73 72.99,99.73 72.86,99.86 72.86,100.89 72.99,101.02 73.7,101.02 v5(74.09,101.4)
  BOTTOM w0.127: VRAM4.D3 71.89,91.95 71.76,91.82 71.57,91.82 71.44,91.7 71.44,90.99 71.31,90.87 70.94,90.87 70.81,90.99 70.81,92.77 70.71,92.86 70.15,92.86 70.03,92.98 v5(69.55,92.98)
DQMA4: length 26
  TOP w0.127: VRAM5.E7 61.64,103.17 61.8,103.32 61.8,103.5 61.58,103.72 61.4,103.72 v5(61.08,103.39) ; GPU1.P24 72.79,110.92 v5(73.2,110.52)
  L3 w0.102: 70.25,110.45 70.25,110.55 70.62,110.92 72.54,110.92 73.04,111.42 74.18,111.42 74.31,111.28 74.31,111.09 74.18,110.95 73.63,110.95 v5(73.2,110.52)
  L3 w0.165: v5(61.08,103.39) 61.84,104.15 61.84,105.04 62.48,105.68 62.48,106.84 62.81,107.17 63.21,107.17 63.56,107.52 63.56,108.17 63.65,108.25 63.65,108.83 64.18,109.36 66.56,109.36 66.79,109.12 67.07,109.12 67.27,109.33 68.05,109.33 68.2,109.18 69.62,109.18 70.25,109.81 70.25,110.45
  BOTTOM w0.127: VRAM7.E7 61.64,104.89 61.08,104.33 v5(61.08,103.39)
DQMA5: length 23.6
  TOP w0.127: v5(72.37,114.64) 72.77,115.04 GPU1.W24 ; VRAM6.E7 61.64,116.28 61.64,117.81 v5(61.62,117.83)
  L3 w0.165: v5(72.37,114.64) 72.63,114.64 72.65,114.66 73.19,114.66 73.32,114.79 73.32,115.07 73.19,115.2 72.02,115.2 71.72,114.9 71.29,114.9 71.06,115.12 71.06,115.83 70.09,116.8 70.09,118.87 69.58,119.38 68.46,119.38 68.06,118.98 67.03,118.98 66.62,119.38 66.32,119.38 66.07,119.13 66.07,118.14 65.65,117.73 65.65,117.48 65.49,117.31 65.16,117.31 64.99,117.48 64.99,117.73 64.83,117.89 64.53,117.89 64.4,117.77 64.4,117.33 64.28,117.2 62.27,117.2 61.64,117.83 v5(61.62,117.83)
  BOTTOM w0.127: v5(61.62,117.83) 61.64,117.85 VRAM8.E7
DQMA6: length 17.6
  TOP w0.127: v5(67.76,117.46) 67.86,117.36 69.89,117.36 70.13,117.12 71.58,117.12 GPU1.AA25 ; v5(62.34,118.43) 61.79,118.43 61.66,118.55 61.66,118.91 61.79,119.04 62.27,119.04 62.44,119.2 VRAM6.D3
  L4 w0.165: v5(62.34,118.43) 62.12,118.21 62.12,117.44 62.36,117.2 64.25,117.2 65.35,118.3 67.4,118.3 67.76,117.94 v5(67.76,117.46)
  BOTTOM w0.127: VRAM8.D3 62.24,116.48 62.24,118.32 v5(62.34,118.43) ; v3(68.29,117.72) v5(67.76,117.46)
DQMA7: length 20.3
  TOP w0.127: v5(62.88,104.3) 62.44,104.74 VRAM5.D3 ; v5(67.33,111.42) 67.47,111.55 67.47,112.62 v1(67.62,112.78) 67.95,112.78 68.98,113.8 71.58,113.8 GPU1.U25
  L4 w0.165: v5(62.88,104.3) 63.05,104.48 63.27,104.48 63.27,104.48 64.69,104.48 64.69,104.48 65.06,104.48 66.53,105.95 66.53,107.77 67.13,108.37 67.13,110.28 67.46,110.61 67.46,111.29 v5(67.33,111.42)
  BOTTOM w0.127: VRAM7.D3 62.36,102.33 62.36,103.78 v5(62.88,104.3)
DRAM_RST: length 129.9
  TOP w0.102: v5(51.83,105.6) 51.95,105.6 52,105.65 52.24,105.65 VRAM5.T2 ; VRAM1.T2 81.92,82.68 81.92,82.54 v5(82.44,82.02) 82.44,81.6 82.11,81.26 80.98,81.26 80.85,81.39 80.85,81.77 80.75,81.88 80.54,81.88 80.44,81.77 80.44,81.39 80.32,81.26 80.11,81.26 80.01,81.36 80.01,81.76 79.89,81.88 79.72,81.88 79.6,81.76 79.6,81.36 79.5,81.26 79.3,81.26 79.2,81.36 79.2,81.73 79.08,81.85 78.91,81.85 78.79,81.73 78.79,81.55 78.78,81.55 78.66,81.42 78.33,81.42 77.96,81.79 v5(77.42,81.79) ; v5(70.89,83.33) 70.88,83.33 70.75,83.46 70.38,83.46 69.74,82.82 69.03,82.82 68.77,83.07 68.28,83.07 VRAM2.T2 ; v5(60.05,91.32) 60.2,91.48 60.27,91.48 60.34,91.54 R599.1 ; VRAM6.T2 52.84,120.28 52,119.44 52,118.41 53.03,117.38 54.18,117.38 v5(54.26,117.31)
  TOP w0.127: GPU1.M27 69.76,108.66 68.56,108.66 66.1,106.2 66.1,100.79 64.44,99.12 63.41,99.12 59.15,94.86 v1(59.15,94.42) 58.87,94.14 58.87,93.31 59.43,92.75 59.43,91.94 v5(60.05,91.32)
  L3 w0.102: 70.83,82.67 70.83,83.27 v5(70.89,83.33)
  L3 w0.127: v5(51.83,105.6) 51.83,106.04 52.16,106.37 52.16,106.99 51.69,107.46 51.69,109.29 52.49,110.09 v5(52.49,111.82) 52.49,113.05 52.01,113.52 52.01,115.15 52.67,115.81 52.67,116.45 53.54,117.31 v5(54.26,117.31) ; 70.83,82.67 72.23,81.27 73.63,81.27 74.01,81.65 75.47,81.65 75.91,82.09 76.79,82.09 76.81,82.06 76.9,82.06 77.18,81.79 v5(77.42,81.79)
  L4 w0.127: v5(52.49,111.82) 52.49,110.03 52.3,109.84 52.3,109.32 52.2,109.21 52.2,107.36 52.49,107.07 52.49,105.6 52.85,105.24 52.85,104.51 52.73,104.39 52.73,102.82 52.75,102.81 52.75,101.51 54.07,100.19 54.07,99.58 58.55,95.1 58.55,93.72 59.38,92.9 59.38,91.99 v5(60.05,91.32) 60.05,91.08 60.26,90.87 60.26,90.43 61.42,89.27 61.67,89.27 61.67,89.27 62.73,89.27 63.74,88.26 63.8,88.26 64.06,88 64.06,87.98 65.87,86.17 66.42,86.17 67.87,84.72 67.87,84.52 67.89,84.51 67.89,84.07 67.9,84.06 67.9,83.7 68.38,83.22 68.55,83.22 70.16,81.61 73.36,81.61 73.86,82.1 74.82,82.1 75.66,82.94 76.27,82.94 v5(77.42,81.79)
  BOTTOM w0.102: v5(82.44,82.02) 82.91,82.02 83.13,82.23 84.9,82.23 85.28,81.86 85.9,81.86 VRAM3.T2 ; VRAM8.T2 52.64,115.68 52.64,116.02 52.51,116.14 52.51,116.42 53.25,117.16 53.76,117.16 53.86,117.26 54.21,117.26 v5(54.26,117.31) ; VRAM4.T2 72.36,82.35 71.55,82.35 70.88,83.02 70.88,83.32 v5(70.89,83.33) ; v5(51.83,105.6) 51.8,105.56 51.8,104.51 52.38,103.92 52.38,103.4 51.91,102.92 51.91,102.2 52.66,101.45 VRAM7.T2
DRVON: length 155
  TOP w0.254: v2(61.05,263.08) 61.11,263.13 PR102.2 ; v2(7.18,211.44) 7.18,210.49 PR87.2 ; PR109.2 88.4,259.07 88.4,260.27 87.57,261.1 v2(87.57,262.24) ; v2(7.03,193.48) 7,193.46 7,192.49 v1(6.95,192.44) 6.95,192.37 6.93,192.34 PR81.2 ; PR93.2 13.09,239.8 v2(13.15,239.86)
  L3 w0.254: v2(7.03,193.48) 7.27,193.72 7.27,211.35 v2(7.18,211.44) 6.09,212.53 6.09,234.86 11.09,239.86 v2(13.15,239.86) 27.4,239.86 28.49,238.77 35.17,238.77 36.26,239.86 40.24,239.86 40.84,240.46 40.84,240.89 v2(41.1,241.16) 42.54,241.16 48.58,247.2 48.58,250.76 53.36,255.54 57.08,255.54 61.05,259.51 v2(61.05,263.08) 61.11,263.13 61.11,263.17 61.98,264.04 85.77,264.04 v2(87.57,262.24)
  BOTTOM w0.203: v2(41.1,241.16) 41.1,241.29 41.31,241.49 PU4401.35
EAPD_DEPOP: length 59.3
  TOP w0.203: v2(182.57,38.47) 184.17,36.87 R393.1 ; v2(176.27,50.79) 176.32,50.79 177.11,51.57 v1(177.11,51.8) 176.09,52.82 176.09,54.47 176.7,55.08 U9.14
  L3 w0.203: v2(176.27,50.79) 175.15,49.67 171.77,49.67 170,47.89 170,43.52 167.71,41.24 167.71,39.1 v2(165.93,37.32)
  L4 w0.203: v2(165.93,37.32) 164.41,35.8 164.41,33.26 165.53,32.14 178.28,32.14 178.89,31.53 181.49,31.53 183.81,33.85 183.81,37.22 v2(182.57,38.47)
EAPD_DEPOP_1: length 3.1
  TOP w0.102: R394.1 184.18,35.88 R393.2 184.14,35.89 R391.1 182.23,35.89 v1(182.16,35.83)
EAPD_DEPOP_2: length 3.2
  TOP w0.254: R394.2 185.22,37.06 v2(184.73,37.56) 184.35,37.94 Q13.5
  BOTTOM w0.254: v2(184.73,37.56) 184.73,37.07 v3(185.11,36.69)
EAPD_DEPOP_2_D: length 2.5
  TOP w0.102: R79871.2 v1(183.56,29.96) 182.73,29.96 Q9620.6
EC_HDMI_PD_N: length 67
  TOP w0.102: v2(109.58,50.56) 109.16,50.56 108.58,49.97 U109.105
  L4 w0.127: v2(109.58,50.56) 109.62,50.52 109.62,50.37 111.46,48.53 112.56,48.53 112.64,48.45 113.31,47.78 122.51,47.78 124.01,46.28 127.94,46.28 129.65,47.98 133.03,47.98 v2(133.67,48.63)
  BOTTOM w0.102: Q1249.G 167.39,53.9 167.01,54.28 R2091.2 163.86,54.28 163.67,54.09 159.96,54.09 159.48,54.57 156.94,54.57 153.56,51.19 151.74,51.19 151.08,50.53 150.17,50.53 148.93,49.29 v3(143.78,49.29) 134.33,49.29 v2(133.67,48.63)
EC_LAN_DISABLE_N: length 108.8
  TOP w0.102: R79925.1 105.61,68.08 107.64,66.05 v2(107.89,66.05) 107.89,65.59 107.78,65.47 U109.58 ; R1194.1 60.71,12.55 61.33,11.92 v2(61.41,11.92)
  L3 w0.127: v2(53.52,42.94) 54.43,43.84 54.43,44.07 57.42,47.06 63.03,47.06 64.17,45.92 79.47,45.92 79.89,45.92 81.26,47.29 82.4,47.29 87.21,52.11 90.67,52.11 91.29,52.73 91.85,52.73 91.86,52.74 92.88,52.74 92.9,52.73 97.75,52.73 99.1,54.08 99.1,56.61 103.07,60.58 103.07,61.62 107.5,66.05 v2(107.89,66.05)
  BOTTOM w0.102: v2(61.41,11.92) 61.41,11.93 61.41,12.95 59.48,14.87 59.48,16.38 60.14,17.04 60.14,18.27 v3(59.89,18.53) 59.38,19.04 59,19.04 58.51,19.52 58.51,20.92 57.8,21.63 57.8,21.71 56.74,22.77 56.39,22.77 55.63,23.54 55.63,25.71 55.52,25.82 55.52,26.55 54.65,27.41 54.65,28.74 53.87,29.52 53.87,31.71 54.86,32.7 54.86,40.01 53.52,41.35 v2(53.52,42.94)
EC_PECI: length 143.7
  TOP w0.102: R79739.2 111.41,73.91 v2(112.16,74.66) ; R37.1 56.97,144.39 54.37,141.79 v1(54.37,137.83) 55.16,137.05 v2(55.16,136.99)
  L3 w0.127: v2(55.16,136.99) 56.18,136.99 56.3,137.11 62.93,137.11 63.93,138.11 81.09,138.11 81.35,137.84 109.99,137.84 124.31,123.52 v2(124.31,116.34)
  L4 w0.127: v2(124.31,116.34) 124.74,115.91 124.74,102.24 124.53,102.02 124.53,95.41 124.64,95.3 124.64,88.97 122.36,86.69 119.09,86.69 116.26,83.86 116.26,82.29 112.85,78.88 112.85,75.35 v2(112.16,74.66)
EDID_RDY: length 131.9
  TOP w0.102: v2(41.78,44.85) 41.78,46.98 41.51,47.24 SCA1.41 ; R79839.2 136.34,93.51 136.91,92.94 v2(136.91,92.62) 136.75,92.45 v1(136.75,91.65) 136.75,91.35 137.71,90.38 137.71,89.01 137.51,88.81 137.51,88.52 137.74,88.29 U2.T44
  L3 w0.127: v2(136.91,92.62) 136.91,90.98 135.83,89.9 135.83,89.06 133.8,87.03 133.8,85.62 132.76,84.58 132.27,84.58 132.04,84.35 129.41,84.35 127.92,82.85 126.24,82.85 124.89,81.5 121.68,81.5 117.18,77 116.09,77 109.27,70.18 108.65,70.18 106.19,67.72 106.19,66.33 103.73,63.87 102.93,63.87 100.15,61.09 100.15,59.1 98.08,57.03 98.08,54.5 97.38,53.8 90.86,53.8 90.19,53.12 87,53.12 87,53.12 86.79,53.12 81.98,48.31 80.84,48.31 79.47,46.94 64.64,46.94 63.5,48.08 56.96,48.08 55.39,46.5 50.56,46.5 49.64,45.58 44.54,45.58 43.87,44.91 41.89,44.91 41.83,44.85 v2(41.78,44.85)
EDP_4_HPD: length 205
  TOP w0.102: R522.1 19.31,24.88 v2(19.5,24.88) ; v2(155.33,66.72) 155.26,66.79 154.87,66.79 153.74,67.91 153.74,67.95 153.66,68.03 153.66,68.18 152.54,69.31 152.39,69.31 152.01,69.68 151.71,69.68 151.49,69.9 U2.BD7
  L3 w0.127: v2(100.96,70.49) 100.1,69.63 95.57,69.63 95.29,69.36 95.29,65.19 95.53,64.95 95.53,63.01 92.11,59.58 92.11,58.47 90.11,56.48 88.62,56.48 87.78,55.64 85.75,55.64 80.93,50.82 79.8,50.82 78.98,50.01 68.29,50.01 67.52,50.79 51.14,50.79 50.42,51.51 42.37,51.51 40.82,49.96 40.82,48.78 38.04,45.99 38.04,33.59 35.34,30.89 35.21,30.89 34.18,29.86 34.18,21.4 33.72,20.94 v2(33.72,20.92)
  BOTTOM w0.102: v2(100.96,70.49) 101.79,70.49 102.94,71.64 104.68,71.64 106.06,70.27 114.91,70.27 118,67.17 121.42,67.17 121.42,67.17 121.71,67.17 124.25,64.63 124.42,64.63 126.99,62.06 134.55,62.06 135.06,62.57 135.54,62.57 138.24,62.57 138.47,62.8 144.58,62.8 146.98,65.2 146.98,67.39 147.39,67.8 147.39,69.58 147.64,69.84 147.64,70.98 148.24,71.57 148.75,71.57 149.34,72.17 149.34,72.42 149.6,72.68 150.01,72.68 150.28,72.4 151.05,72.4 151.3,72.15 151.3,72.07 151.83,71.54 153.69,71.54 154.93,70.29 156.56,70.29 v3(157.37,69.48) 157.37,69.19 155.88,67.7 155.88,67.63 155.65,67.39 155.65,66.97 155.39,66.72 v2(155.33,66.72) ; v2(19.5,24.88) 20.06,24.32 21.46,24.32 23.61,22.16 32.48,22.16 v2(33.72,20.92)
