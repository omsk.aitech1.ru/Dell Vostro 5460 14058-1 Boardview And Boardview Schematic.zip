# Allegro board 14058-1.0623WZS1658.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIRST1#: length 13.6
  TOP w0.102: v2(114.72,57.09) 115.39,57.75 115.39,59.85 117.52,61.99 118.19,61.99 118.61,62.41 U109.30
  BOTTOM w0.102: R79977.1 113.38,53.67 113.38,54.62 v3(113.4,54.65) 113.4,54.89 RN2.5 114.36,56.7 114.41,56.75 114.41,56.77 v2(114.72,57.09) 114.75,57.09 115.01,56.83 RN2.6
PCIRST3#: length 16
  TOP w0.102: U109.81 104.59,56.81 104.88,56.52 106.64,56.52 v2(108.23,54.93)
  BOTTOM w0.102: 115.51,56.37 116.01,56.37 116.16,56.22 RN2.8 ; 115.51,56.37 115.51,56.95 114.91,57.54 114.39,57.54 112.4,55.55 R79976.1 v3(109.48,55.55) 108.84,55.55 v2(108.23,54.93) ; 115.51,56.37 RN2.7
PD_N: length 11
  TOP w0.102: v2(165.93,45.45) 165.38,46 164.03,46 163.91,45.88 U118.36
  BOTTOM w0.102: Q1249.D 168.09,50.21 v3(168.09,49.62) 167.99,49.62 166.57,48.2 166.57,46.09 v2(165.93,45.45)
PECI_SIO: length 10.4
  TOP w0.102: v1(110,73.32) 110.29,73.02 R79739.1 111.35,71.77 C12126.1 111.75,71.31 111.75,70.96 111.75,70.96 111.75,69.16 111.75,69.15 111.75,66.71 110.58,65.53 U109.51
PEG_C_RXN0: length 13.3
  TOP w0.102: GPU1.AB9 85.56,117.94 85.56,117.94 v5(85.6,117.99)
  BOTTOM w0.102: 86.34,123.84 86.34,121.79 84.93,120.38 84.93,118.47 85.2,118.2 85.39,118.2 v5(85.6,117.99) ; 86.34,123.84 86.34,124.48 87.83,125.97 87.83,128.41 C12265.2 ; 86.34,123.84 v3(86.02,123.84)
PEG_C_RXN1: length 11.5
  TOP w0.102: GPU1.AC10 84.4,118.41 v5(83.97,117.98)
  BOTTOM w0.102: C12267.2 86.1,127.21 86.1,125.9 85.04,124.84 ; 85.04,124.84 84.51,124.3 84.51,118.52 v5(83.97,117.98) ; 85.04,124.84 v3(84.83,125.06)
PEG_C_RXN2: length 13.8
  TOP w0.102: v5(84,118.85) 83.88,118.85 83.56,118.53 GPU1.AC11
  BOTTOM w0.102: v5(84,118.85) 83.76,119.09 83.76,127.09 83.4,127.45 83.4,129.78 ; 83.4,129.78 83.4,130.9 C12269.2 ; 83.4,129.78 v3(83.71,129.78)
PEG_C_RXN3: length 12.7
  TOP w0.102: v5(82.31,117.99) 82.34,117.99 82.72,117.62 GPU1.AB12
  BOTTOM w0.102: v3(81.6,127.57) 81.91,127.57 ; 81.91,127.57 81.91,128.74 C12271.2 ; 81.91,127.57 81.91,127.14 81.8,127.03 81.8,126.73 81.91,126.61 81.91,126.31 81.8,126.2 81.8,125.89 81.91,125.78 81.91,125.48 81.8,125.36 81.8,125.06 81.91,124.95 81.91,122.16 82.48,121.59 82.48,118.16 v5(82.31,117.99)
PEG_C_RXN4: length 14.5
  TOP w0.102: v5(81.48,118.83) 81.89,118.42 GPU1.AC13
  BOTTOM w0.102: 81.12,123.4 v3(80.82,123.4) ; 81.12,123.4 81.12,121.71 82.06,120.77 82.06,118.74 81.89,118.58 81.73,118.58 v5(81.48,118.83) ; 81.12,123.4 81.12,124.38 81.01,124.5 81.01,124.8 81.12,124.91 81.12,125.22 81.01,125.33 81.01,125.63 81.12,125.75 81.12,126.05 81.01,126.16 81.01,126.47 81.12,126.58 81.12,126.88 80.01,128 80.01,130.01 C12273.2
PEG_C_RXN5: length 10.7
  TOP w0.102: GPU1.AC14 81.05,118.42 v5(80.64,118.83)
  BOTTOM w0.102: v3(79.04,125.11) 79.27,125.33 ; 79.27,125.33 80.03,124.57 80.03,120.03 80.16,119.89 80.23,119.82 80.23,119.47 80.64,119.06 v5(80.64,118.83) ; 79.27,125.33 78.48,126.12 78.48,127.21 C12275.2
PEG_C_RXN6: length 14.7
  TOP w0.102: v5(79.83,117.99) GPU1.AB15
  BOTTOM w0.102: 76.96,128.74 76.96,129.98 C12277.2 ; 76.96,128.74 v3(76.65,128.74) ; 76.96,128.74 76.96,126.16 79.34,123.78 79.34,120.02 79.2,119.88 79.2,119.36 79.44,119.12 79.44,118.66 79.62,118.49 79.62,118.31 79.72,118.2 79.72,118.1 v5(79.83,117.99)
PEG_C_RXN7: length 12.8
  TOP w0.102: v5(79.03,118.85) 79.09,118.8 79.09,118.77 GPU1.AC16
  BOTTOM w0.102: v3(75.99,127.01) 75.76,126.78 ; 75.76,126.78 74.99,127.55 74.99,127.75 C12279.2 ; 75.76,126.78 78.94,123.61 78.94,119.39 78.53,118.99 78.53,118.85 78.74,118.65 78.88,118.65 79.03,118.8 v5(79.03,118.85)
PEG_C_RXP0: length 13.4
  TOP w0.102: GPU1.AC9 85.2,118.68 85.34,118.82 v5(85.63,118.82)
  BOTTOM w0.102: 88.04,127.34 88.04,125.88 86.56,124.39 86.56,121.7 85.14,120.29 85.14,118.56 85.29,118.42 85.48,118.42 85.63,118.56 v5(85.63,118.82) ; 88.04,127.34 v3(88.36,127.34) ; 88.04,127.34 88.04,128.3 C12264.2
PEG_C_RXP1: length 11.5
  TOP w0.102: GPU1.AB10 84.4,117.6 v5(84.8,117.99)
  BOTTOM w0.102: 86.32,126.35 86.32,127.21 C12266.2 ; 86.32,126.35 86.32,125.81 84.72,124.21 84.72,123.91 84.84,123.8 84.84,123.49 84.72,123.38 84.72,123.08 84.84,122.96 84.84,122.66 84.72,122.55 84.72,118.06 v5(84.8,117.99) ; 86.32,126.35 v3(86.66,126.35)
PEG_C_RXP2: length 13.7
  TOP w0.102: GPU1.AD11 83.54,119.22 v5(83.15,118.83)
  BOTTOM w0.102: v3(83.23,123.53) 83.55,123.53 ; 83.55,123.53 83.55,127 83.18,127.36 83.18,130.9 C12268.2 ; 83.55,123.53 83.55,119.23 v5(83.15,118.83)
PEG_C_RXP3: length 12.6
  TOP w0.102: GPU1.AC12 82.72,118.35 83.08,117.99 v5(83.16,117.99)
  BOTTOM w0.102: v5(83.16,117.99) 83.16,118.04 82.7,118.5 82.7,121.68 82.13,122.25 82.13,125.74 ; C12270.2 82.13,128.74 82.13,125.74 ; v3(82.44,125.74) 82.13,125.74
PEG_C_RXP4: length 14.7
  TOP w0.102: GPU1.AB13 81.86,117.58 v5(81.45,117.99)
  BOTTOM w0.102: 80.22,128.89 v3(80.54,128.89) ; 80.22,128.89 80.22,130.01 C12272.2 ; 80.22,128.89 80.22,128.09 81.34,126.97 81.34,121.8 82.28,120.86 82.28,118.65 81.98,118.36 81.82,118.36 v5(81.45,117.99)
PEG_C_RXP5: length 9.8
  TOP w0.102: v5(80.66,119.62) 81.06,119.22 GPU1.AD14
  BOTTOM w0.102: 80.24,121.55 80.24,120.12 80.45,119.91 80.66,119.7 v5(80.66,119.62) ; 80.24,121.55 v3(80.59,121.55) ; 80.24,121.55 80.24,124.66 78.7,126.21 78.7,127.21 C12274.2
PEG_C_RXP6: length 13.8
  TOP w0.102: v5(79.85,118.83) 80.24,118.44 GPU1.AC15
  BOTTOM w0.102: v5(79.85,118.83) 79.68,119.01 79.68,119.11 79.66,119.12 79.66,119.21 79.41,119.45 79.41,119.79 79.56,119.93 79.56,123.87 77.17,126.25 77.17,126.61 ; C12276.2 77.17,129.98 77.17,126.61 ; 77.17,126.61 v3(77.51,126.61)
PEG_C_RXP7: length 13.2
  TOP w0.102: GPU1.AB16 79.02,118 v5(79.02,118.07)
  BOTTOM w0.102: 76.66,125.58 74.77,127.46 74.77,127.75 C12278.2 ; 76.66,125.58 v3(76.45,125.36) ; 76.66,125.58 78.72,123.52 78.72,119.48 78.32,119.07 78.32,118.76 78.44,118.64 v5(79.02,118.07)
PEG_C_TXN0: length 45.1
  TOP w0.102: C11908.1 85.34,132.95 85.34,135.9 ; CPU1.T3 69.88,169.75 69.88,167.42 70.71,166.6 70.71,150.66 74.79,146.57 75.34,146.02 75.78,146.02 85.34,136.46 85.34,135.9 ; 85.34,135.9 v1(84.96,135.9)
PEG_C_TXN1: length 45.2
  TOP w0.102: CPU1.R1 69.41,168.37 69.41,167.78 69.42,167.77 69.42,164.79 69.91,164.31 69.91,150.02 74.62,145.31 75.32,145.31 82.66,137.97 84.3,136.33 84.3,133.87 ; v1(84.65,133.87) 84.3,133.87 ; 84.3,133.87 84.3,130.79 C11907.1
PEG_C_TXN2: length 45.1
  TOP w0.102: 82.8,133.64 82.8,135.72 68.69,149.83 68.69,154.24 68.58,154.35 68.58,154.66 68.69,154.77 68.69,155.07 68.58,155.18 68.58,155.49 68.69,155.6 68.69,155.91 68.58,156.02 68.58,156.32 68.69,156.43 68.69,161.76 68.58,161.87 68.58,162.18 68.69,162.29 68.69,162.59 68.58,162.71 68.58,163.01 68.69,163.12 68.69,163.43 68.58,163.54 68.58,163.84 68.69,163.95 68.69,164.26 68.08,164.87 68.08,169.78 CPU1.P3 ; 82.8,133.64 v1(82.44,133.64) ; 82.8,133.64 82.8,132.95 C11905.1
PEG_C_TXN3: length 45.5
  TOP w0.102: 79.01,138.14 67.34,149.81 67.34,169.04 CPU1.N2 ; 79.01,138.14 81.51,135.63 81.51,130.78 C11904.1 ; 79.01,138.14 v1(78.76,137.88)
PEG_C_TXN4: length 44.3
  TOP w0.102: C11902.1 80.24,132.94 80.24,134.87 78.92,136.19 ; v1(78.66,135.93) 78.92,136.19 ; 78.92,136.19 66.25,148.87 66.25,169.78 CPU1.M3
PEG_C_TXN5: length 45.2
  TOP w0.102: 75.27,138.1 65.46,147.91 65.46,168.99 CPU1.L2 ; 75.27,138.1 78.86,134.51 78.86,130.79 C11900.1 ; 75.27,138.1 v1(75.02,137.86)
PEG_C_TXN6: length 44
  TOP w0.102: CPU1.K3 64.96,170.34 64.42,169.8 64.42,168.18 64.18,167.94 64.18,164.9 64.48,164.6 64.48,147.08 77.29,134.28 77.29,133.79 ; v1(76.93,133.79) 77.29,133.79 ; 77.29,133.79 77.29,132.91 C11895.1
PEG_C_TXN7: length 44.8
  TOP w0.102: CPU1.J2 63.62,168.98 63.62,145.53 75.88,133.26 75.88,131.69 ; 75.88,131.69 75.88,130.87 C11898.1 ; 75.88,131.69 v1(75.51,131.69)
PEG_C_TXP0: length 45
  TOP w0.102: 84.42,137.68 75.86,146.24 75.43,146.24 70.92,150.75 70.92,156.97 71.03,157.08 71.03,157.38 70.92,157.5 70.92,157.8 71.03,157.91 71.03,158.22 70.92,158.33 70.92,166.69 70.1,167.51 70.1,169.66 70.18,169.75 70.33,169.75 70.47,169.61 CPU1.T2 ; 84.42,137.68 v1(84.68,137.93) ; 84.42,137.68 85.55,136.55 85.55,132.97 85.65,132.86 85.66,132.86 85.67,132.85 85.67,132.84 C12145.1
PEG_C_TXP1: length 46.3
  TOP w0.102: 82.5,137.82 75.23,145.09 74.53,145.09 69.69,149.93 69.69,164.22 69.21,164.71 69.21,167.68 69.2,167.69 69.2,167.73 69.08,167.84 69.08,168.87 69.55,169.34 CPU1.R2 ; 82.5,137.82 84.08,136.24 84.08,130.81 C12144.1 ; 82.5,137.82 v1(82.24,137.55)
PEG_C_TXP2: length 44.3
  TOP w0.102: C12143.1 83.13,132.84 83.13,132.85 83.12,132.86 83.11,132.86 83.01,132.97 83.01,135.81 80.36,138.47 ; CPU1.P2 68.64,169.69 68.54,169.79 68.4,169.79 68.29,169.69 68.29,164.96 68.9,164.35 68.9,149.92 80.36,138.47 ; 80.36,138.47 v1(80.6,138.71)
PEG_C_TXP3: length 45.3
  TOP w0.102: v1(82.09,135.6) 81.73,135.6 ; 81.73,135.6 81.73,130.81 C12142.1 ; 81.73,135.6 81.73,135.72 69.94,147.52 69.94,147.68 69.72,147.89 69.56,147.89 69.35,148.11 69.35,148.27 69.13,148.48 68.97,148.48 68.76,148.7 68.76,148.85 68.54,149.07 68.38,149.07 67.56,149.9 67.56,155.5 67.67,155.61 67.67,155.92 67.56,156.03 67.56,156.34 67.67,156.45 67.67,156.75 67.56,156.86 67.56,157.17 67.67,157.28 67.67,157.59 67.56,157.7 67.56,162.78 67.67,162.89 67.67,163.19 67.56,163.31 67.56,163.61 67.67,163.72 67.67,164.03 67.56,164.14 67.56,164.44 67.67,164.55 67.67,164.86 67.56,164.97 67.56,168.34 CPU1.N1
PEG_C_TXP4: length 45
  TOP w0.102: 76.52,138.9 v1(76.78,139.15) ; 76.52,138.9 80.46,134.96 80.46,132.97 C12141.1 ; 76.52,138.9 70.17,145.25 70.17,145.41 69.95,145.63 69.79,145.63 66.46,148.96 66.46,150.62 66.58,150.73 66.58,151.03 66.46,151.15 66.46,151.45 66.58,151.56 66.58,151.87 66.46,151.98 66.46,152.28 66.58,152.39 66.58,152.7 66.46,152.81 66.46,157.89 66.58,158 66.58,158.31 66.46,158.42 66.46,158.72 66.58,158.84 66.58,159.14 66.46,159.25 66.46,159.56 66.58,159.67 66.58,159.97 66.46,160.09 66.46,165.17 66.58,165.28 66.58,165.58 66.46,165.69 66.46,166 66.58,166.11 66.58,166.42 66.46,166.53 66.46,166.83 66.58,166.94 66.58,167.25 66.46,167.36 66.46,169.69 66.6,169.82 66.71,169.82 66.81,169.72 CPU1.M2
PEG_C_TXP5: length 44.4
  TOP w0.102: 79.08,133.72 79.08,134.6 65.68,148 65.68,155.77 65.79,155.89 65.79,156.19 65.68,156.3 65.68,156.86 65.79,156.97 65.79,157.28 65.68,157.39 65.68,168.29 CPU1.L1 ; 79.08,133.72 79.08,130.8 C12140.1 ; 79.08,133.72 v1(79.44,133.72)
PEG_C_TXP6: length 43.9
  TOP w0.102: 76.4,135.47 77.5,134.37 77.5,133.02 C12139.1 ; 76.4,135.47 v1(76.68,135.75) ; 76.4,135.47 64.7,147.17 64.7,164.69 64.4,164.99 64.4,167.85 64.64,168.09 64.64,169.71 64.74,169.81 64.88,169.81 64.98,169.71 CPU1.K2
PEG_C_TXP7: length 45.6
  TOP w0.102: 72.67,136.78 70.75,138.71 70.75,138.86 70.53,139.08 70.37,139.08 70.16,139.29 70.16,139.45 69.94,139.67 69.78,139.67 69.57,139.88 69.57,140.04 69.35,140.26 69.2,140.26 66.24,143.21 66.24,143.37 66.03,143.58 65.87,143.58 65.65,143.8 65.65,143.96 65.44,144.17 65.28,144.17 65.06,144.39 65.06,144.55 64.85,144.76 64.69,144.76 64.48,144.98 64.48,145.14 64.26,145.35 64.1,145.35 63.84,145.62 63.84,148.04 63.95,148.15 63.95,148.46 63.84,148.57 63.84,148.87 63.95,148.99 63.95,149.29 63.84,149.4 63.84,149.71 63.95,149.82 63.95,150.12 63.84,150.24 63.84,155.32 63.95,155.43 63.95,155.73 63.84,155.84 63.84,156.15 63.95,156.26 63.95,156.56 63.84,156.68 63.84,156.98 63.95,157.09 63.95,157.4 63.84,157.51 63.84,161.78 63.95,161.89 63.95,162.19 63.84,162.3 63.84,162.61 63.95,162.72 63.95,163.03 63.84,163.14 63.84,163.44 63.95,163.55 63.95,163.86 63.84,163.97 63.84,164.28 63.95,164.39 63.95,164.69 63.84,164.8 63.84,168.28 CPU1.J1 ; 72.67,136.78 73.12,136.34 73.27,136.34 73.49,136.12 73.49,135.96 73.7,135.75 73.86,135.75 74.08,135.53 74.08,135.37 74.29,135.16 74.45,135.16 74.67,134.94 74.67,134.79 76.1,133.35 76.1,130.74 C12138.1 ; 72.67,136.78 v1(72.94,137.04)
PEG_COMP: length 10
  TOP w0.203: CPU1.L7 66.36,174.46 66.36,175.97 66.7,176.31 66.99,176.31 67.35,176.67
  TOP w0.305: R63.2 70.68,179.22 70.68,178.68 70.05,178.04 v2(68.9,178.04) 68.27,178.04 67.35,177.12 67.35,176.67
  BOTTOM w0.305: v3(69.79,178.04) v2(68.9,178.04)
PEG_RXN0: length 51
  TOP w0.102: CPU1.U4 71.66,171.53 71.66,171.58 v5(71.78,171.7)
  BOTTOM w0.102: 79.68,155.89 79.68,141.73 87.86,133.55 87.86,129.9 C12265.1 ; 79.68,155.89 79.68,156.42 79.24,156.85 78.59,157.5 78.44,157.5 78.22,157.71 78.22,157.87 76.88,159.21 76.72,159.21 76.51,159.43 76.51,159.59 76.29,159.8 76.13,159.8 75.92,160.02 75.92,160.17 75.7,160.39 75.54,160.39 75.33,160.61 75.33,160.76 73.45,162.64 73.45,170.83 72.23,172.05 72.13,172.05 v5(71.78,171.7) ; 79.68,155.89 v3(79.34,155.89)
PEG_RXN1: length 53
  TOP w0.102: v5(70.08,172.62) 70.47,172.24 CPU1.T5
  BOTTOM w0.102: 71.38,165.72 71.38,170.79 71.33,170.84 71.33,170.96 70.71,171.59 70.71,172.78 70.52,172.96 70.42,172.96 v5(70.08,172.62) ; 71.38,165.72 71.38,162.65 72.46,161.56 73.05,160.98 73.05,160.82 73.27,160.6 73.43,160.6 73.64,160.39 73.64,160.23 73.86,160.01 74.02,160.01 74.23,159.8 74.23,159.64 74.45,159.42 74.6,159.42 75.62,158.4 75.62,158.24 75.84,158.03 76,158.03 78.97,155.05 78.97,141.45 86.09,134.34 86.09,128.76 C12267.1 ; 71.38,165.72 v3(71.09,165.72)
PEG_RXN2: length 47
  TOP w0.102: v5(70.05,170.83) 69.62,171.25 CPU1.R4
  BOTTOM w0.102: C12269.1 83.4,132.46 83.4,136.18 70.34,149.24 70.34,156.31 70.45,156.42 70.45,156.73 70.34,156.84 70.34,158.21 70.45,158.32 70.45,158.62 70.34,158.73 70.34,159.04 70.45,159.15 70.45,159.46 70.34,159.57 70.34,159.87 70.45,159.98 70.45,160.29 70.34,160.4 70.34,163.41 ; v5(70.05,170.83) 69.71,171.16 69.61,171.16 69.42,170.98 69.42,170.48 70.34,169.57 70.34,163.41 ; 70.34,163.41 v3(70.66,163.41)
PEG_RXN3: length 50.8
  TOP w0.102: CPU1.P5 68.63,172.17 v5(68.19,172.6)
  BOTTOM w0.102: 69.36,161.66 69.36,162.52 69.25,162.64 69.25,162.94 69.36,163.05 69.36,163.36 69.25,163.47 69.25,163.77 69.36,163.89 69.36,164.19 69.25,164.3 69.25,164.61 69.36,164.72 69.36,168.39 68.47,169.27 68.47,170.51 68.6,170.63 68.6,171.54 68.92,171.86 68.92,172.7 68.68,172.94 68.57,172.95 v5(68.19,172.6) ; 69.36,161.66 v3(69.06,161.66) ; 69.36,161.66 69.36,148.45 81.89,135.91 81.89,130.28 C12271.1
PEG_RXN4: length 47.8
  TOP w0.102: v5(67.29,171.62) 67.29,171.62 67.67,171.25 67.72,171.25 CPU1.N4
  BOTTOM w0.102: v3(79.67,132.5) 79.99,132.5 ; 79.99,132.5 79.99,131.55 C12273.1 ; 79.99,132.5 79.99,133.92 79.88,134.03 79.88,134.34 79.99,134.45 79.99,134.76 79.88,134.87 79.88,135.17 79.99,135.28 79.99,135.59 79.88,135.7 79.88,136 79.99,136.12 79.99,136.42 78.29,138.12 78.13,138.12 77.91,138.34 77.91,138.5 77.7,138.71 77.54,138.71 77.32,138.93 77.32,139.09 77.11,139.3 76.95,139.3 76.73,139.52 76.73,139.68 75.04,141.37 74.88,141.37 74.66,141.59 74.66,141.75 74.45,141.96 74.29,141.96 74.08,142.18 74.08,142.34 73.86,142.55 73.7,142.55 73.49,142.77 73.49,142.93 69.89,146.52 69.74,146.52 69.52,146.73 69.52,146.89 69.31,147.11 69.15,147.11 68.93,147.32 68.93,147.48 68.72,147.7 68.56,147.7 68.34,147.91 68.34,148.07 68.01,148.4 68.01,168.95 67.68,169.28 67.68,171.23 v5(67.29,171.62)
PEG_RXN5: length 50.5
  TOP w0.102: v5(66.36,172.71) 66.52,172.71 66.81,172.41 CPU1.M5
  BOTTOM w0.102: 78.47,135.34 78.47,128.76 C12275.1 ; 78.47,135.34 78.47,136.14 67.34,147.27 67.34,168.25 66.65,168.94 66.65,172.42 v5(66.36,172.71) ; 78.47,135.34 v3(78.15,135.34)
PEG_RXN6: length 47.2
  TOP w0.102: CPU1.L4 65.9,171.32 65.52,171.7 v5(65.5,171.7)
  BOTTOM w0.102: 66.08,162.22 66.08,171.95 65.97,172.07 65.87,172.07 v5(65.5,171.7) ; 66.08,162.22 66.08,147.28 77.07,136.29 77.07,131.65 C12277.1 ; 66.08,162.22 v3(65.78,162.22)
PEG_RXN7: length 49.7
  TOP w0.102: v5(64.61,171.69) 64.61,171.84 64.94,172.17 CPU1.K5
  BOTTOM w0.102: v5(64.61,171.69) 64.37,171.45 64.37,169.45 64.37,167.11 64.48,167 64.48,166.69 64.37,166.58 64.37,166.28 64.48,166.17 64.48,165.86 64.37,165.75 64.37,165.44 64.48,165.33 64.48,165.03 64.37,164.92 64.37,159.84 64.48,159.72 64.48,159.42 64.37,159.31 64.37,159 64.48,158.89 64.48,158.59 64.37,158.47 64.37,158.17 64.48,158.06 64.48,157.75 64.37,157.64 64.37,150.43 ; C12279.1 74.99,129.31 74.99,133.06 75.1,133.17 75.1,133.47 74.99,133.58 74.99,133.89 75.1,134 75.1,134.31 74.99,134.42 74.99,134.72 75.1,134.83 75.1,135.14 74.99,135.25 74.99,135.55 71.36,139.19 71.36,139.34 71.14,139.56 70.98,139.56 70.77,139.78 70.77,139.93 70.55,140.15 70.4,140.15 70.18,140.37 70.18,140.52 69.96,140.74 69.81,140.74 66.21,144.33 66.21,144.49 66,144.7 65.84,144.7 65.62,144.92 65.62,145.08 65.41,145.29 65.25,145.29 65.04,145.51 65.04,145.67 64.82,145.88 64.66,145.88 64.37,146.18 64.37,147.05 64.37,150.43 ; v3(64.69,150.43) 64.37,150.43
PEG_RXP0: length 51
  TOP w0.102: CPU1.U5 71.72,172.51 71.72,172.56 v5(71.78,172.62)
  BOTTOM w0.102: v3(74.72,162.17) 74.48,161.92 ; 74.48,161.92 73.66,162.73 73.66,170.92 72.32,172.27 72.13,172.27 v5(71.78,172.62) ; 74.48,161.92 79.89,156.5 79.89,141.82 88.08,133.64 88.08,129.93 C12264.1
PEG_RXP1: length 53
  TOP w0.102: v5(70.06,173.52) 70.47,173.11 CPU1.T6
  BOTTOM w0.102: v3(71.9,168.85) 71.6,168.85 ; 71.6,168.85 71.6,170.88 71.55,170.93 71.55,171.05 70.92,171.68 70.92,172.87 70.61,173.18 70.42,173.18 70.08,173.52 v5(70.06,173.52) ; 71.6,168.85 71.6,162.74 77.64,156.69 79.19,155.14 79.19,141.54 86.3,134.43 86.3,128.79 C12266.1
PEG_RXP2: length 47
  TOP w0.102: CPU1.R5 69.62,172.17 v5(70.07,171.72)
  BOTTOM w0.102: v5(70.07,171.72) 70.05,171.72 69.71,171.38 69.52,171.38 69.21,171.07 69.21,170.39 70.12,169.48 70.12,149.15 83.18,136.09 83.18,135.39 ; C12268.1 83.18,132.46 83.18,135.39 ; 83.18,135.39 v3(82.85,135.39)
PEG_RXP3: length 50.9
  TOP w0.102: CPU1.P6 68.64,173.15 v5(68.24,173.54)
  BOTTOM w0.102: C12270.1 82.11,130.31 82.11,133.44 ; v3(82.42,133.44) 82.11,133.44 ; 82.11,133.44 82.11,136 69.58,148.54 69.58,168.48 68.69,169.36 68.69,170.42 68.81,170.54 68.81,171.45 69.13,171.77 69.13,172.79 68.77,173.15 68.6,173.16 68.59,173.16 v5(68.24,173.54)
PEG_RXP4: length 47.7
  TOP w0.102: CPU1.N5 67.71,172.17 67.35,172.53 67.35,172.55 v5(67.33,172.58)
  BOTTOM w0.102: 68.23,158.58 68.23,169.04 67.9,169.37 67.9,172.01 v5(67.33,172.58) ; 68.23,158.58 68.23,148.49 80.21,136.51 80.21,131.58 C12272.1 ; 68.23,158.58 v3(68.55,158.58)
PEG_RXP5: length 51.4
  TOP w0.102: v5(66.36,173.6) 66.81,173.15 CPU1.M6
  BOTTOM w0.102: C12274.1 78.68,128.79 78.68,136.23 75.71,139.2 ; v3(75.94,139.43) 75.71,139.2 ; 75.71,139.2 67.56,147.36 67.56,168.34 66.86,169.03 66.86,173.1 v5(66.36,173.6)
PEG_RXP6: length 48.1
  TOP w0.102: v5(65.47,172.65) 65.49,172.63 65.52,172.63 65.9,172.26 CPU1.L5
  BOTTOM w0.102: v5(65.47,172.65) 65.5,172.65 65.87,172.28 66.06,172.28 66.3,172.04 66.3,167.45 66.41,167.34 66.41,167.03 66.3,166.92 66.3,166.62 66.41,166.5 66.41,166.2 66.3,166.09 66.3,165.78 66.41,165.67 66.41,165.37 66.3,165.25 66.3,160.17 66.41,160.06 66.41,159.76 66.3,159.65 66.3,159.34 66.41,159.23 66.41,158.92 66.3,158.81 66.3,158.51 66.41,158.4 66.41,158.09 66.3,157.98 66.3,148.73 ; C12276.1 77.29,131.43 77.29,136.38 66.3,147.37 66.3,148.73 ; 66.3,148.73 v3(66.64,148.73)
PEG_RXP7: length 49.3
  TOP w0.102: v5(64.56,172.6) 64.56,172.68 64.98,173.1 CPU1.K6
  BOTTOM w0.102: 64.15,147.05 64.15,146.09 74.77,135.47 74.77,129.31 C12278.1 ; 64.15,147.05 64.15,172.2 v5(64.56,172.6) ; 64.15,147.05 v3(63.85,147.05)
PEG_TXN0: length 11.5
  TOP w0.102: 86.15,130.31 85.36,131.1 85.36,131.37 C11908.2 ; 86.15,130.31 87.17,129.29 87.17,121.91 GPU1.AG7 ; 86.15,130.31 v1(85.9,130.06)
PEG_TXN1: length 11.7
  TOP w0.102: C11907.2 84.28,129.23 84.28,128.62 85.72,127.19 ; 85.72,127.19 v1(85.98,127.44) ; 85.72,127.19 86.54,126.37 86.54,122.06 86.54,121.76 86.54,121.76 86.54,121.48 86.74,121.28 87.02,121.28 87.32,120.98 87.32,120.46 GPU1.AE7
PEG_TXN2: length 12.8
  TOP w0.102: 85.31,125.1 85.31,122.94 85.22,122.84 85.22,122.13 85.54,121.81 85.54,121.16 GPU1.AF9 ; 85.31,125.1 v1(84.96,125.1) ; 85.31,125.1 85.31,125.54 82.87,127.98 82.87,131.32 C11905.2
PEG_TXN3: length 9.8
  TOP w0.102: 81.53,128.21 81.53,127.41 84.59,124.35 84.59,121.81 GPU1.AG10 ; 81.53,128.21 v1(81.15,128.21) ; 81.53,128.21 81.53,129.23 C11904.2
PEG_TXN4: length 13.9
  TOP w0.102: C11902.2 80.22,131.43 80.22,127 80.41,126.81 ; GPU1.AE10 84.02,120.4 84.02,121.21 83.64,121.59 83.64,123.59 80.41,126.81 ; v1(80.16,126.55) 80.41,126.81
PEG_TXN5: length 11.3
  TOP w0.102: 81.75,124.12 82.91,122.96 82.91,121.91 83.06,121.76 83.06,121.48 82.91,121.33 82.91,121.01 GPU1.AF12 ; 81.75,124.12 80.31,125.56 79.98,125.56 78.86,126.68 78.86,129.23 C11900.2 ; 81.75,124.12 v1(81.5,123.86)
PEG_TXN6: length 12.8
  TOP w0.102: C11895.2 77.34,131.4 77.34,127.44 ; 77.34,127.44 77.34,126.91 82.21,122.03 82.21,121.91 GPU1.AG13 ; 77.34,127.44 v1(76.98,127.44)
PEG_TXN7: length 12.6
  TOP w0.102: 75.82,128.28 75.82,129.24 C11898.2 ; 75.82,128.28 v1(75.43,128.28) ; 75.82,128.28 75.82,126.68 81.51,120.98 81.51,120.43 GPU1.AE13
PEG_TXP0: length 11.5
  TOP w0.102: C12145.2 85.58,131.42 85.58,131.19 87.39,129.38 87.39,128.66 ; 87.39,128.66 87.39,121.91 GPU1.AG6 ; 87.39,128.66 v1(87.78,128.66)
PEG_TXP1: length 10.4
  TOP w0.102: 84.07,128.54 84.07,129.23 C12144.2 ; 84.07,128.54 v1(83.71,128.54) ; 84.07,128.54 86.32,126.28 86.32,122.06 86.32,121.85 86.32,121.39 86.65,121.06 86.69,121.06 86.88,120.87 GPU1.AF7
PEG_TXP2: length 13.6
  TOP w0.102: v1(84.55,127.12) 84.29,126.87 ; 84.29,126.87 85.53,125.63 85.53,122.85 85.44,122.75 85.44,122.22 85.76,121.9 85.76,121.07 85.61,120.92 85.61,120.43 GPU1.AE9 ; 84.29,126.87 83.09,128.07 83.09,131.47 C12143.2
PEG_TXP3: length 9.9
  TOP w0.102: 82.62,126.63 81.74,127.5 81.74,129.23 C12142.2 ; 82.62,126.63 v1(82.88,126.89) ; 82.62,126.63 84.8,124.44 84.8,122.02 GPU1.AG9
PEG_TXP4: length 13.1
  TOP w0.102: 83.47,124.05 83.85,123.68 83.85,121.68 84.4,121.13 GPU1.AF10 ; 83.47,124.05 v1(83.74,124.32) ; 83.47,124.05 80.43,127.09 80.43,131.35 C12141.2
PEG_TXP5: length 12.2
  TOP w0.102: 79.08,128.18 v1(79.44,128.18) ; 79.08,128.18 79.08,129.23 C12140.2 ; 79.08,128.18 79.08,126.77 80.07,125.78 80.4,125.78 83.13,123.05 83.13,122 83.28,121.85 83.28,121.39 83.13,121.24 83.13,120.43 GPU1.AE12
PEG_TXP6: length 12.8
  TOP w0.102: 79.83,124.73 82.43,122.12 82.43,121.91 GPU1.AG12 ; 79.83,124.73 v1(80.08,124.98) ; 79.83,124.73 77.56,126.99 77.56,131.4 C12139.2
PEG_TXP7: length 11.7
  TOP w0.102: 77.92,124.88 76.03,126.77 76.03,129.24 C12138.2 ; 77.92,124.88 81.73,121.07 81.73,121.01 GPU1.AF13 ; 77.92,124.88 v1(78.17,125.13)
PEX_CLKREQ: length 2.6
  TOP w0.102: v5(87.27,118.81) 87.34,118.73 87.43,118.73 87.74,118.42 GPU1.AC6
  BOTTOM w0.102: v5(87.27,118.81) 87.27,119 87.74,119.47 v3(87.74,119.47) 88.04,119.77 R591.2
PEX_PLLVDD_GPU: length 1.2
  TOP w0.356: GPU1.AA14 81.06,116.78 v5(80.66,117.18) 80.26,116.78 GPU1.AA15
  vias: v3(79.42,117.28)
PEX_RST_GPU: length 25.2
  TOP w0.102: v5(93.67,116.83) 93.54,116.83 92.42,117.94 87.47,117.94 86.99,118.42 GPU1.AC7 ; R1212.1 100.4,116.32 100.5,116.5 100.57,116.5 101.03,116.95 R605.1 101.67,117.52 101.67,121.27 100.53,122.41 99.57,122.41 99.12,122.87 v2(99,122.87)
  BOTTOM w0.102: v5(93.67,116.83) 94.3,117.46 94.33,117.46 v3(95.7,118.83) 99,122.13 v2(99,122.87)
PEX_TERMP: length 4.5
  TOP w0.127: GPU1.AF25 71.98,121.08 72.42,121.53 72.42,121.77 72.61,121.95 v1(72.61,123.94) 72.65,123.98 R79978.1
PEX_TSTCLK_OUT: length 4.8
  TOP w0.127: GPU1.AF22 74.87,121.21 74.87,122.51 75.68,123.33 v1(75.68,123.94) 75.68,124.97 R193.2
PEX_TSTCLK_OUT#: length 5.5
  TOP w0.127: R193.1 74.68,124.31 74.34,123.96 v1(74.34,123.94) 74.31,123.94 74.12,123.75 74.12,120.38 GPU1.AE22
PLTRST*_SIO: length 8.1
  TOP w0.102: v2(111.63,63.36) 112.09,63.82 112.35,63.82 112.57,64.04 U109.46
  BOTTOM w0.102: v2(111.63,63.36) 111.83,63.56 111.83,63.93 C180.1 111.16,64.5 110.6,63.94 110.37,63.94 v3(109.92,63.49) 109.92,63.48 109.92,62.85 110.69,62.09 R256.2 R251.1
PLTRST_CPU_N: length 255.7
  TOP w0.102: v2(40.2,118.22) 40.12,118.3 40.12,123.43 39.11,124.45 v1(38.3,124.45) 37.56,124.45 36.01,122.9 33.89,122.9 R1771.1 ; v2(126.59,64.12) 126.59,63.47 128.05,62.01 129.65,62.01 132.06,59.6 138.3,59.6 139.29,60.59 139.29,62.23 140.57,63.51 142.68,63.51 144.15,64.98 144.15,67.18 144.38,67.41 U2.AK2 ; v2(59.63,166.91) 58.11,168.44 58.11,172.09 58.11,172.2 58.16,172.24 58.16,172.27 58.55,172.66 59.59,172.66 59.89,172.95 59.89,173.47 CPU1.E7
  L4 w0.127: v2(71.86,68.72) 71.86,69.39 70.65,70.6 65.09,70.6 57.5,78.19 54.94,78.19 51.07,82.06 51.07,83.16 48.87,85.37 37.78,85.37 36.52,85.37 30.94,90.95 30.94,102.46 31.48,102.99 31.48,107.41 31.76,107.68 31.76,110.04 31.88,110.17 31.88,112.15 31.93,112.2 31.93,113.49 35.68,117.23 37.29,117.23 38.34,118.27 39.41,118.27 39.45,118.32 40.1,118.32 v2(40.2,118.22) 40.2,118.32 41.37,119.49 41.37,122.38 42.7,123.71 42.7,126.42 44.1,127.82 46.37,127.82 52.75,134.21 54.37,134.21 58.65,138.49 58.65,145.34 59.63,146.32 v2(59.63,166.91)
  BOTTOM w0.102: v2(126.59,64.12) 125.01,65.7 124.7,65.7 122.13,68.26 118.51,68.26 117.52,69.25 117.52,71.39 114.96,73.95 114.96,74.17 114.66,74.46 114.45,74.46 112.29,76.62 109.6,76.62 108.91,75.93 108.62,75.93 94.3,75.93 91.53,73.16 77.46,73.16 77.16,72.86 76.32,72.86 75.97,72.5 75.83,72.5 72.76,69.44 72.57,69.44 v2(71.86,68.72)
PLTRST_CR: length 157.9
  L3 w0.127: v2(185.62,123.81) 185.62,122.82 186.34,122.1 186.34,118.57 186.09,118.31 186.09,91.39 184.72,90.03 181.97,90.03 180.96,89.01 178.32,89.01 178,88.69 178,85.16 175.71,82.87 175.71,81.94 173.28,79.51 173.28,78.79 173.28,77.73 172.59,77.04 172.59,76.39 167.89,71.69 166.24,71.69 165.42,70.88 165.42,60.79 166.44,59.78 v2(166.44,59.32)
  L4 w0.127: v2(185.62,123.81) 185.62,127.24 188.33,129.96 v2(188.33,132.17)
  BOTTOM w0.102: v2(188.33,132.17) 188.33,132.24 187.04,133.54 187.04,135.98 v3(186.63,136.38) 186.63,137.02 187.23,137.62 187.23,138.37 187.88,139.03 188.06,139.03 188.91,139.87 U14.1 ; v2(166.44,59.32) 166.44,59.27 164.66,57.49 163.43,57.49 162.88,56.94 162.68,56.73 153.74,56.73 153.13,56.12 150.96,56.12 150.13,55.29 150.13,54.31 148.44,52.61 147.99,52.61 147.98,52.61 127.25,52.61 126.18,51.55 122.5,51.55 120.22,53.83 117.07,53.83 115.57,52.34 114.18,52.34 113.89,52.63 113.89,53.91 114.36,54.38 RN2.4
PLTRST_LAN_N: length 75.4
  TOP w0.102: v2(62.38,31.86) 62.26,31.75 U9623.19
  L3 w0.127: v2(117.11,55.71) 111.63,55.71 109.29,53.37 109.29,52.67 109.71,52.25 109.71,51.56 108.4,50.25 108.4,50.01 106.49,48.1 106.25,48.1 103.76,45.6 103.63,45.6 90.36,45.6 88.63,43.87 88.63,41.27 86.49,39.14 86.49,36.81 85.3,35.62 79.28,35.62 77.34,33.68 66.97,33.68 65.28,31.99 62.5,31.99 v2(62.38,31.86)
  BOTTOM w0.102: v2(117.11,55.71) 117.01,55.61 117.01,54.78 116.03,53.8 v3(115.77,53.8) 115.51,54.06 RN2.2
PLTRST_N: length 129.9
  L4 w0.127: v2(109.8,61.71) 110.9,60.6 110.9,59.79 111.4,59.29 111.79,59.29 117.88,53.2 121.74,53.2 122.98,51.96 145.63,51.96 147.68,49.91 149.53,49.91 150.12,50.49 150.5,50.49 150.84,50.16 153.16,50.16 157.27,54.27 168.44,54.27 169.62,55.46 v2(169.63,55.46)
  BOTTOM w0.102: R256.1 110.37,61.14 v2(109.8,61.71) ; v2(169.63,55.46) 170.25,56.07 170.25,56.93 170.96,57.64 170.96,59.93 172.12,61.08 172.12,67.65 173.5,69.04 v3(173.5,71.28) 173.5,74.99 174.8,76.29 174.8,78.05 171.27,81.58 171.27,90.93 170.08,92.11 167.99,92.11 167.56,91.68 164.39,91.68 163.77,91.07 163.77,89.27 163.82,89.22 163.82,88.52 161.98,86.68 160.93,86.68 159.79,85.53 157.05,85.53 R1982.2
PLTRST_N_1A: length 46
  TOP w0.102: v2(98.62,110.35) 98.62,110.49 98.33,110.78 98.33,112.85 98.67,113.19 98.67,114.4 C12384.2 99.51,115.24 99.51,115.34 99.81,115.64 99.81,116.43 100.21,116.83 R605.2 100.21,117.65 100.02,117.84 v1(100.02,117.97) ; v2(106.5,92.95) 106.5,92.02 Q9630.G
  L3 w0.127: v2(106.5,92.95) 106.11,92.57 105.61,92.57 102.3,89.27 101.64,89.27 99.36,86.98 v2(97.99,86.98)
  L4 w0.127: v2(97.99,86.98) 97.69,87.27 97.69,87.3 97.32,87.67 97.32,91.73 96.93,92.12 96.93,103.93 97.31,104.31 97.31,104.7 96.53,105.48 96.53,108.26 v2(98.62,110.35)
PLTRST_N_C: length 3.5
  BOTTOM w0.102: Q6704.C 108.91,83.36 108.91,81.14 v3(108.78,81.01) 107.83,81.01 R79980.2
PLTRST_N_CPU: length 6.7
  TOP w0.102: U2.BB27 150.46,80 v2(150.29,80.17)
  BOTTOM w0.102: R1982.1 153.42,82.79 153.42,82.45 152.82,81.85 v3(152.59,81.85) 152.59,81.85 152.39,81.65 151.13,81.65 151.02,81.76 150.66,81.76 150.36,81.46 150.36,81.16 150.29,81.09 v2(150.29,80.17)
PLTRST_SL_N: length 115.1
  TOP w0.102: v2(99.81,109.79) 100.23,110.21 R80059.1 100.1,110.69 99.43,110.69 99.04,111.08 99.04,112.42 99.26,112.64 U9621.2
  L4 w0.127: v2(99.81,109.79) 97.3,107.27 97.3,105.8 98.07,105.02 98.07,100.1 100.87,97.31 100.87,93.91 100.18,93.23 100.18,88.21 100.23,88.16 100.23,86.47 97.54,83.77 97.54,82.88 94.56,79.9 94.56,77.33 94.17,76.94 94.17,69.03 94.45,68.76 94.84,68.76 95.29,69.21 95.29,69.36 95.57,69.63 99.08,69.63 100.23,68.48 106.52,68.48 110.19,64.81 110.19,62.96 110.55,62.6 110.58,62.6 115.58,57.61 115.58,56.59 117.32,54.85 v2(117.57,54.85) 124.31,54.85 125.35,53.81 126.58,53.81 127.67,52.72 137.62,52.72 139.41,54.51 139.41,56.02 LPC1.3
  BOTTOM w0.102: v2(117.57,54.85) 117.57,54.84 115.43,52.69 114.55,52.69 v3(114.39,52.84) 114.24,53 114.24,53.68 115.01,54.45 RN2.3
PM_PWRBTN_N: length 72.4
  TOP w0.102: v2(133.17,50.21) 133.79,50.84 148.12,50.84 150.12,52.84 150.5,52.84 150.82,52.52 150.82,51.89 150.98,51.73 152.43,51.73 152.6,51.89 152.6,53.07 153.65,54.13 156.19,54.13 157.23,55.17 C151.1 157.42,56.06 R142.2 ; R333.1 99.7,61.33 100.91,61.33 v2(101.16,61.07)
  L4 w0.127: v2(101.16,61.07) 101.16,60.83 102.57,59.42 103.09,59.42 105.88,56.63 109.18,56.63 113.04,52.77 113.04,51.38 114.33,50.09 118.11,50.09 118.78,50.76 118.82,50.8 129.56,50.8 130.15,50.21 v2(133.17,50.21)
  BOTTOM w0.102: v2(101.16,61.07) 100.84,60.76 R334.2 ; v3(132.35,50.2) 133.15,50.2 v2(133.17,50.21)
PM_SLP_S3#_R: length 10.4
  TOP w0.102: SCA1.34 44.9,44.96 45.64,45.69 45.64,46.86 46.59,47.82 47.2,47.82 47.44,48.06 47.44,48.35 47.76,48.67 48.56,48.67 48.76,48.47 49.47,48.47 50.19,49.2 R79789.2 51.5,49.2 v1(51.5,49.2)
PME_N: length 15.1
  TOP w0.102: R79796.2 R96.2 163.91,77.53 161.45,77.53 160.68,76.77 160.61,76.77 v1(160.51,76.67) 160.31,76.67 159.45,75.81 158.83,75.81 158.43,75.4 156.09,75.4 155.89,75.6 155.06,75.6 154.99,75.68 154.25,75.68 153.62,75.05 151.54,75.05 U2.BD17
PORTC_SPK_L: length 30
  TOP w0.203: U9.43 178.3,62.89 v2(178.21,62.99) ; v2(178.48,43.8) 177.99,43.31 177.99,43.09 v1(177.97,43.07) 177.97,41.66 C12332.1
  L3 w0.203: v2(178.48,43.8) 179.01,43.8 179.52,44.31 180.68,44.31 184.9,48.53 184.9,52.38 182.08,55.21 181.4,55.89 181.4,61.45 180.38,62.47 178.73,62.47 178.21,62.99 v2(178.21,62.99)
PORTC_SPK_L_1: length 2.2
  TOP w0.203: R384.1 176.6,42.66 v1(176.73,42.53) 177.09,42.16 C12332.2
PORTC_SPK_R: length 34.9
  TOP w0.203: v2(177.36,63.36) 177.36,63.12 177.83,62.64 177.9,62.57 U9.44 ; v2(179.49,43.12) 179.82,42.79 C12331.1
  L3 w0.203: v2(179.49,43.12) 179.56,43.05 180.25,43.05 185.49,48.29 185.49,52.63 182.33,55.79 181.98,56.13 181.98,61.78 181.35,62.42 181.35,64.15 180.33,65.16 178.1,65.16 177.36,64.43 v2(177.36,63.36)
  BOTTOM w0.203: v2(179.49,43.12) 179.9,42.71 v3(180.21,42.71)
PORTC_SPK_R_1: length 2.7
  TOP w0.203: R383.1 181.74,43.29 C12331.2 181.23,42.54 v1(180.43,41.74)
PRE: length 7.7
  TOP w0.102: U118.16 157.83,45.48 157.68,45.33 157.17,45.33 156.58,45.91 155.25,45.91 R2090.1 154.26,46.6 153.41,47.45 v1(153.24,47.45) 153.11,47.33 152.95,47.33 152.22,46.6 R2088.2
PRIM_XDP_JTAG_TCK_R: length 4.5
  TOP w0.102: v2(44.89,122.29) v1(44.02,122.29) R1764.2
  BOTTOM w0.102: v2(44.89,122.29) 44.6,122.29 44.31,122.01 XDPC1.55
PROG: length 3.2
  TOP w0.508: v2(43.49,249.33) 43.79,249.03 v1(44.44,249.03) 44.58,249.17 PR4458.1
  BOTTOM w0.203: PU4401.10 43.31,249.14 v2(43.49,249.33)
PSID_D: length 5.9
  BOTTOM w0.102: R501.1 52.65,24.75 52.9,25.01 54.17,25.01 54.43,25.26 L21.2 54.43,26.02 v3(54.04,26.4) 53.66,26.78 53.66,27.35 Q24.D
PSID_D_1: length 8.4
  TOP w0.102: Q26.B 50.81,28.53 50.06,27.78 50.06,26.71 50.03,26.68 50.03,26.14 v2(49.66,25.77)
  BOTTOM w0.102: v2(49.66,25.77) 49.66,25.64 50.03,25.27 50.03,25.08 50.49,24.63 R503.1 50.49,23.74 50.74,23.48 v3(50.87,23.48) 51.57,24.18 R501.2
PSID_G: length 9
  TOP w0.102: Q26.C 52.71,29.24 52.77,29.3 v2(52.77,30.23)
  BOTTOM w0.102: v3(49.4,26.99) 49.73,27.32 Q24.G ; v2(52.77,30.23) 52.77,29.57 50.81,27.61 Q24.G ; Q24.G 51.57,26.56 R499.2
PW_CLEAR: length 51.3
  TOP w0.102: v2(137.56,86.07) 137.7,85.92 U2.U39 ; v2(133.42,121.35) 132.96,121.35 132.78,121.53 R151.1 133.99,122.1 134.21,121.88 136.71,121.88 136.81,121.78 140.54,121.78 140.55,121.77 141.29,121.77 141.3,121.78 143.59,121.78 PSWD1.2
  BOTTOM w0.102: v2(137.56,86.07) 137.47,86.07 136.25,87.29 136.25,89.01 135.82,89.44 135.82,114.2 v3(135.09,114.93) 134.07,115.95 134.07,119.76 133.42,120.41 v2(133.42,121.35)
PWM1: length 86.7
  TOP w0.305: PU4.2 9.17,189.59 8.43,190.33 8.43,191.32 v1(8.35,191.4) 8.43,191.48 8.43,192.92 v2(8.32,193.03)
  L3 w0.305: v2(41.47,240.26) 40.49,239.28 36.54,239.28 35.45,238.19 27.63,238.19 26.85,238.96 11.02,238.96 6.67,234.62 6.67,213.22 7.97,211.92 7.97,193.66 8.32,193.31 v2(8.32,193.03)
  BOTTOM w0.203: PU4401.34 41.71,240.97 41.47,240.74 v2(41.47,240.26)
PWM1A: length 41
  TOP w0.254: PU19.2 67.5,263.03 v2(67.13,263.41) ; v2(43.63,240.65) 43.68,240.7 v1(43.68,241.62)
  L3 w0.254: v2(67.13,263.41) 66.34,262.62 64.88,262.62 57.29,255.03 53.57,255.03 49.09,250.55 49.09,244.47 45.27,240.65 v2(43.63,240.65)
  BOTTOM w0.203: v2(43.63,240.65) 43.31,240.98 PU4401.30
PWM2: length 68.5
  TOP w0.305: v2(8.58,211.49) 8.35,211.26 v1(8.35,210.3) 8.35,208.88 8.84,208.39 PU9.2
  L3 w0.305: v2(8.58,211.49) 8.58,212.18 7.28,213.47 7.28,234.37 11.27,238.35 26.6,238.35 27.37,237.58 35.73,237.58 36.82,238.67 41.32,238.67 v2(42.28,239.64)
  BOTTOM w0.203: v2(42.28,239.64) 41.98,239.94 41.98,240.78 42.11,240.91 PU4401.33
PWM2A: length 69.8
  TOP w0.254: PU24.2 92.66,258.89 91.94,258.18 90.01,258.18 88.91,259.28 88.91,260.48 88.21,261.18 v2(88.21,261.48) ; v1(44.14,239.08) v2(43.45,239.76)
  L3 w0.254: v2(43.45,239.76) 45.1,239.76 49.85,244.51 49.85,250.59 53.22,253.96 56.94,253.96 65.09,262.11 69.06,262.11 69.67,262.72 85.82,262.72 87.06,261.48 v2(88.21,261.48)
  BOTTOM w0.203: PU4401.31 42.91,240.87 43.12,240.65 43.12,240.09 v2(43.45,239.76)
PWM3: length 36.8
  TOP w0.305: PU14.2 13.65,236.85 v2(14.04,237.24) 14.04,237.98 v1(14.42,238.37)
  L3 w0.305: v2(14.04,237.24) 14.55,237.74 26.34,237.74 27.12,236.97 36.39,236.97 37.15,236.21 38.04,236.21 38.8,236.97 40.58,236.97 42.89,239.28 42.89,239.38 42.89,240.14 v2(42.51,240.52)
  BOTTOM w0.203: PU4401.32 v2(42.51,240.52)
PWM_SW_EN: length 27.9
  TOP w0.102: SCA1.54 35.01,47 v2(34.87,46.85)
  L3 w0.127: v2(32.71,30.62) 32.73,30.62 33.61,31.49 33.61,40.48 34.49,41.36 34.49,43.29 35.22,44.02 35.22,46.3 34.87,46.65 v2(34.87,46.85)
  BOTTOM w0.102: Q9614.5 Q9614.2 28.01,29.58 v3(28.61,30.18) 29.2,30.77 32.53,30.77 32.68,30.62 v2(32.71,30.62) ; v2(34.87,46.85) 35.12,47.1 R79205.1
PWR_1D0V: length 9.5
  TOP w0.254: PG17.2 155.12,98.69
  TOP w0.635: 166.78,99.02 PT30.1 ; PT30.1 167.84,100.08 ; PT30.1 168.89,99.02 ; PT30.1 167.84,97.97 ; 158.13,103.41 PT29.1 ; PT29.1 157.07,104.47 ; PT29.1 159.18,104.47 ; PT29.1 158.13,105.52
  vias: v1(164.79,90.03)
PWR_1D0V_BOOT: length 6.4
  BOTTOM w0.305: 156.18,122.67 PU44.10
  BOTTOM w0.508: 156.18,122.67 156.18,122.01 157.19,120.99 157.3,120.99 v3(157.4,120.89) 158.44,120.89 158.82,121.27 PR209.1
PWR_1D0V_BOOT_R: length 2.8
  BOTTOM w0.508: PC103.2 PR209.2 160.34,121.78 v3(160.09,121.53)
PWR_1D0V_CS: length 3.4
  BOTTOM w0.254: PU44.2 152.35,123.95 151.81,123.4 v3(151.43,123.4) 150.95,122.92 PR208.1
PWR_1D0V_EN: length 5.8
  TOP w0.254: v2(151.99,124.37) 151.63,124.37 v1(151.15,123.89) 150.93,124.12 PC105.1 PR4475.2 R1947.2
  BOTTOM w0.254: PU44.3 152.05,124.45 151.99,124.38 v2(151.99,124.37)
PWR_1D0V_FB: length 6.6
  TOP w0.254: v2(151.96,125.24) 151.93,125.21 PC108.2 PR212.2
  BOTTOM w0.254: PR214.1 151.12,124.94 v3(151.12,125.21) 151.16,125.24 v2(151.96,125.24) 152.26,124.95 PU44.4
PWR_1D0V_FB_R: length 34.6
  TOP w0.254: v2(148.17,125.96) 148.43,126.22 PR212.1 PC108.1 ; v2(153.87,99.6) 153.45,99.19 PG17.1
  L4 w0.254: v2(148.17,125.96) 148.82,125.31 148.82,121.43 147.02,119.63 147.02,107.26 153.87,100.41 v2(153.87,99.6)
  BOTTOM w0.254: v3(149.25,126.01) 149.19,125.96 v2(148.17,125.96)
PWR_1D0V_LGATE: length 22
  TOP w0.762: PU45.4 v4(168.85,123.94)
  L4 w1.016: v4(157.42,126.22) 165.55,126.22 167.84,123.94 v4(168.85,123.94) v4(172.66,123.94)
  BOTTOM w0.305: v4(157.42,126.22) 157.42,126.27 156.66,127.04 v3(156.48,127.04) 156.18,126.73 PU44.6
  BOTTOM w0.762: PU46.4 v4(172.66,123.94)
PWR_1D0V_PG: length 3.7
  BOTTOM w0.254: PU44.1 153.08,123.28 151.71,121.91 v3(151.45,121.91) PR207.2
PWR_1D0V_PHASE: length 17.1
  L4 w1.016: v4(167.71,115.43) 167.71,116.24 159.5,124.45 v4(157.55,124.45)
  BOTTOM w0.305: v4(157.55,124.45) PU44.8
  BOTTOM w0.635: v4(157.55,124.45) 158.59,124.45 PC103.1
  vias: v3(162.65,115.48) v3(168.5,112) v3(172.71,111.59) v4(165.17,114.67) v4(165.17,113.52) v4(165.17,112.25) v4(170.63,115.3) v4(170.63,114.03) v4(170.63,112.76)
PWR_1D0V_RF: length 6.3
  BOTTOM w0.254: PR210.1 150.12,126.41 150.92,127.21 152.75,127.21 v3(152.85,127.11) 153.08,126.88 PU44.5
PWR_1D0V_SNB: length 2.7
  BOTTOM w0.508: PC106.2 v3(166.44,119.47) PR211.1
PWR_1D0V_UGATE: length 15.8
  TOP w0.254: v1(156.76,122.8) v4(157.7,122.8)
  TOP w0.762: PU43.4 v4(166.06,115.56)
  L4 w1.016: v4(166.06,115.56) 158.82,122.8 v4(157.7,122.8)
  BOTTOM w0.305: v4(157.7,122.8) 157.7,123.02 156.78,123.95 PU44.9
PWR_1D35V: length 106.8
  TOP w0.635: 125.76,220.46 126.82,220.46 ; 126.82,220.46 126.82,221.51 ; 126.82,220.46 127.87,220.46 ; 126.82,220.46 126.82,219.4 ; 126.82,211.53 126.82,212.58 ; 126.82,212.58 125.76,212.58 ; 126.82,212.58 127.87,212.58 ; 126.82,212.58 126.82,213.64
  L4 w0.381: v4(131.01,218.3) 131.39,218.68 131.39,221.47 133.23,223.32 141.55,223.32 141.59,223.27 169.21,223.27 175.2,217.28 v2(175.2,211.52)
  BOTTOM w0.635: 126.82,220.46 127.87,220.46 ; 126.82,220.46 126.82,221.51 ; 126.82,220.46 126.82,219.4 ; 126.82,220.46 125.76,220.46 ; v2(175.2,211.52) 175.33,211.39 175.33,210.17 174.62,209.46 PR191.1 ; 126.82,212.58 126.82,213.64 ; 126.82,212.58 127.87,212.58 ; 126.82,212.58 126.82,211.53 ; 126.82,212.58 125.76,212.58
  BOTTOM w1.27: PR188.1 PR189.1 165.85,225.16 151.2,225.16 137.86,222.49
  vias: v1(135.65,223.99) v3(122.22,216.75) v3(135.37,223.84) v3(136.21,208.06) v4(128.34,218.3) v4(128.34,217.28) v4(128.34,215.38) v4(128.34,214.36) v4(129.74,218.3) v4(129.74,217.28) v4(129.74,215.38) v4(129.74,214.36) v4(131.01,217.28) v4(131.01,215.38) v4(131.01,214.36) v4(133.17,213.35) v4(133.29,219.32) v4(134.56,213.35) v4(134.69,219.32) v4(135.83,213.35) v4(135.96,219.32)
PWR_1D35V_VGA: length 12.9
  TOP w0.508: PR8620.1 PC8614.1 37.53,102.48 37.41,102.35 v4(37.28,102.35)
  L3 w1.27: v4(37.28,102.35) 37.28,101.08 36.39,100.19 36.39,98.46 40.58,94.27 v4(40.58,93.59)
  vias: v1(43.5,90.79) v1(44.77,86.35)
PWR_3D3V: length 45.1
  TOP w0.254: 59.86,80.61 PG14.2
  L4 w0.508: v2(26.91,79.11) 26.91,79.34 26.89,79.35 26.89,82.31 30.8,86.22 34.86,86.22 36.28,84.8 38.02,84.8 47.34,84.8 47.95,84.19 49.24,84.19 50.49,82.94 50.49,81.65 54.52,77.62 56.42,77.62 v2(58.49,75.55)
  BOTTOM w0.508: PR162.1 24.87,80.5 v3(25.98,80.5) 26.91,79.57 v2(26.91,79.11)
PWR_3D3V_BOOT2: length 3.9
  BOTTOM w0.203: PU35.7 28.88,77.73 28.09,78.52
  BOTTOM w0.508: PR153.2 28.09,80.45 v3(28.09,79.49) 28.09,78.52
PWR_3D3V_BOOT2_R: length 2.9
  BOTTOM w0.508: 29.15,83.17 29.53,82.79 PC74.1 ; 29.15,83.17 28.36,83.17 PR153.1 ; 29.15,83.17 v3(29.16,83.17)
PWR_3D3V_ENTRIP2: length 4.7
  BOTTOM w0.203: 26.91,76.29 27.12,76.08 PU35.4
  BOTTOM w0.254: PR169.1 25.63,76.49 PC85.1 25.93,76.74 25.93,76.83 v3(26.36,77.25) 26.56,77.25 26.91,76.9 26.91,76.29
PWR_3D3V_FB: length 44.2
  TOP w0.254: PG14.1 59.86,83.17 58.8,84.24 50.49,84.24 50.06,83.81 v2(46.81,83.81) ; PC79.2 PR158.1 24.64,78.66 24.02,79.28 v2(23.82,79.28)
  L3 w0.254: v2(46.81,83.81) 44.65,83.81 43.76,84.7 29.19,84.7 23.95,79.45 23.95,79.41 v2(23.82,79.28)
  BOTTOM w0.254: v3(45.89,83.81) v2(46.81,83.81)
PWR_3D3V_FB2: length 4.8
  TOP w0.254: PR158.2 PC79.1 25.6,77.39 PR161.1 26.89,77.11 v2(27.5,77.11) 28.45,77.11 v1(28.47,77.13)
  BOTTOM w0.203: v2(27.5,77.11) 27.73,76.89 PU35.5
PWR_3D3V_HG2R:
  vias: v3(42.69,83.27) v4(41.78,83.3)
PWR_3D3V_LDO3: length 5.3
  BOTTOM w0.203: 31.44,74.54 31.1,74.88 PU35.15
  BOTTOM w0.254: 31.44,74.54 PC77.2 32.07,72.63 v3(32.07,72.1) 32.3,71.87 32.91,71.87 PG16.1
PWR_3D3V_LGATE2: length 8.6
  TOP w0.508: v1(31.16,77.66) 31.13,77.66 v2(30.68,77.2)
  L4 w1.016: v4(37.33,75.53) 34.38,75.53 32.71,77.2 v2(30.68,77.2)
  BOTTOM w0.203: PU35.10 30.65,77.23 v2(30.68,77.2)
PWR_3D3V_PHASE2: length 20.5
  L4 w1.016: v4(30.35,78.38) 30.47,78.5 30.47,79.87 32.12,81.52 41.67,81.52 v4(41.93,81.77)
  BOTTOM w0.203: v4(30.35,78.38) 29.68,77.71 PU35.9
  BOTTOM w0.508: PC74.2 29.53,79.54 30.35,78.73 v4(30.35,78.38)
  BOTTOM w1.016: PR157.1 v3(41.93,80.78) v4(41.93,81.77)
PWR_3D3V_SNB: length 3.8
  BOTTOM w0.508: PR157.2 40,78.09 39.49,77.58 v3(38.8,77.58) 38.55,77.84 PC82.1
PWR_3D3V_UGATE2: length 14.4
  L4 w1.016: v4(35.58,83.17) 31.44,83.17 28.82,80.55 v4(28.82,78.7)
  BOTTOM w0.203: PU35.8 29.28,77.96 28.9,78.35 28.9,78.36 28.82,78.44 v4(28.82,78.7)
  BOTTOM w1.016: PR155.2 v3(37,83.17) v4(35.58,83.17)
PWR_5V: length 1
  TOP w0.254: PG15.1 73.6,61.07 73.48,60.95
  vias: v2(71.19,55.23) v2(72.33,55.23) v3(58.36,72.81) v4(57.22,69.46) v4(57.22,67.68) v4(57.47,70.98) v4(58.74,65.77) v4(59,70.98) v4(60.27,65.77) v4(60.52,70.98) v4(61.79,65.77) v4(67.38,66.15) v4(67.38,64.76) v4(67.38,63.49)
PWR_5V3V_EMN: length 6.3
  BOTTOM w0.203: 31.98,75.68 PU35.13
  BOTTOM w0.254: 31.98,75.68 32.39,75.68 PR163.2 33.18,75.96 33.19,75.96 33.42,76.19 v3(35.2,76.19) 35.87,75.51 PR166.1
PWR_5V3V_ENLDO: length 3
  BOTTOM w0.203: PU35.12 31.53,76.08 31.79,76.34
  BOTTOM w0.508: 31.79,76.34 31.93,76.48 PR152.2 32.57,76.48 33.06,76.97 v3(33.5,76.97)
PWR_5V3V_LDO5: length 5
  TOP w0.254: v2(31.82,75.17) 31.82,75.68 32.12,75.98 v1(32.45,75.98) 32.91,75.98 33.34,75.55 PC73.1
  BOTTOM w0.203: PU35.14 31.71,75.28 v2(31.82,75.17)
  BOTTOM w0.254: v2(31.82,75.17) 32.58,74.41 PG13.1
PWR_5V3V_PGOOD: length 4.7
  BOTTOM w0.203: 26.89,77.94 27.21,77.62 27.87,77.62 28.26,77.23 PU35.6
  BOTTOM w0.254: PR162.2 24.93,79.4 v3(25.56,78.77) 26.39,77.94 26.89,77.94
PWR_5V3V_TON: length 3.5
  BOTTOM w0.203: 27.12,75.68 PU35.3
  BOTTOM w0.254: 27.12,75.68 25.93,75.68 v3(25.75,75.5) 25.75,75.45 24.82,74.52 PR165.1
PWR_5V_BOOT1: length 4.8
  BOTTOM w0.203: 28.26,73.01 28.88,73.63 PU35.19
  BOTTOM w0.508: 28.26,73.01 27.88,72.63 27.88,71.6 v3(27.7,71.41) 27.45,71.17 PR154.1
PWR_5V_BOOT1_R: length 4.1
  BOTTOM w0.508: PC75.2 30.93,68.67 30.55,68.29 v3(30.24,68.29) 29.99,68.29 29.38,68.9 PR154.2
PWR_5V_BYP1: length 70.7
  TOP w0.254: PG15.2 75.23,61.25 v2(75.23,63.84) ; v2(27.32,73.09) 27.63,73.39 PC81.1 27.12,74.15 26.23,73.27 v1(25.98,73.27) 25.09,73.27 24.67,73.68 PR159.2 PC83.1 24.45,75.3 23.82,74.66 v2(23.82,74.41)
  L3 w0.254: v2(75.23,63.84) 73.78,62.39 63.77,62.39 63.14,61.76 34.94,61.76 24.71,72 24.71,73.52 v2(23.82,74.41)
  BOTTOM w0.203: PU35.20 27.98,74.13
  BOTTOM w0.254: 27.98,74.13 27.32,73.47 v2(27.32,73.09)
PWR_5V_ENTRIP1: length 6.1
  BOTTOM w0.203: 27.1,75.28 PU35.2
  BOTTOM w0.254: 27.1,75.28 26.99,75.17 26.36,75.17 25.61,74.42 PC84.1 26.23,73.34 26.54,73.04 v3(26.54,72.62) 26.24,72.33 PR168.1
PWR_5V_FB1: length 6.4
  TOP w0.254: PR159.1 PC83.2 PR164.1 26.49,76.31 26.99,75.81 v1(26.99,75.42) 26.99,74.92 v2(26.61,74.54)
  BOTTOM w0.203: PU35.1 27.37,74.88 27.03,74.54 v2(26.61,74.54)
PWR_5V_LGATE1: length 14.9
  L4 w1.016: v4(30.68,74.03) 32.15,74.03 33.68,72.5 38.68,72.5 40.84,70.34 v4(40.84,68.69)
  BOTTOM w0.203: PU35.16 30.58,74.13 v4(30.68,74.03)
  BOTTOM w0.254: v3(39.95,68.69) v4(40.84,68.69)
PWR_5V_PHASE1: length 24.8
  L4 w1.016: v4(30.93,72.38) 37.15,66.15 v4(47.95,66.15)
  BOTTOM w0.203: 30.32,72.99 29.68,73.63 PU35.17
  BOTTOM w0.508: v4(30.93,72.38) 30.32,72.99
  BOTTOM w1.016: v4(48.33,71.23) 47.95,70.86 47.95,70.79 v3(47.64,70.48) 47.12,69.96 PR160.1
PWR_5V_SNB: length 4.3
  BOTTOM w0.508: PC80.1 41.98,70.98 v3(42.36,71.36) 43.5,71.36 44.06,70.8 PR160.2
PWR_5V_UGATE1: length 25
  L4 w1.016: v4(47.82,64.5) 36.47,64.5 29.25,71.72 v4(29.25,71.74)
  BOTTOM w0.203: PU35.18 v3(29.28,72.63)
  BOTTOM w1.016: v4(47.82,64.5) 47.82,64.25 47.11,63.54 PR156.1
PWR_5V_UGATE1_G: length 2.5
  BOTTOM w1.016: PR156.2 v3(46.42,66.92) v4(46.42,67.93)
PWR_12V: length 31
  L3 w0.254: v2(7.94,137.27) 7.69,137.53 6.55,137.53 3.12,134.1 3.12,115.18 3.88,114.41 v2(6.65,114.41)
  BOTTOM w0.508: v2(6.65,114.41) PR5306.1 PC5310.1
  vias: v3(7.64,131.86) v3(7.82,135.75)
PWR_12V_BOOT: length 5.2
  BOTTOM w0.508: PU5301.1 13.79,112.89 14.29,112.38 v3(15.06,112.38) 15.44,112.38 15.94,112.89 PR5308.2
PWR_12V_BOOT_R: length 3.8
  BOTTOM w0.508: PC5307.1 16.95,117.46 17.24,117.17 v3(17.24,117.1) 17.24,116.9 16.22,115.89 PR5308.1
PWR_12V_DCBATOUT: length 19.9
  BOTTOM w1.27: v4(7.31,110.35) 5.91,110.35 3.24,113.02 3.24,118.48 v3(4.87,120.11) 5.78,121.02 9.27,121.02 9.34,121.09 11.32,121.09 11.37,121.14
PWR_12V_EN: length 25.1
  BOTTOM w0.102: 9.98,119.51 9.73,119.75 PR5303.1 PC5311.1 PR5305.1 7.63,118.1 7.27,118.1 5.83,116.66 5.83,113.38 5.83,113.09 6.77,112.15 10.46,112.15 v3(11.88,110.73) 12.96,109.65 PR5518.2 PQ5301.D
PWR_12V_EN_G: length 10.5
  BOTTOM w0.102: PR5302.2 16.9,110.48 PC5303.1 v3(19.12,109.59) 19.44,109.27 PQ5301.G 19.44,107.87 18.31,106.74 17.01,106.74 15.63,108.12 15.63,108.13 PQ5302.D
PWR_12V_FB: length 6.1
  BOTTOM w0.254: 9.98,114.4 9.98,115.43 8.96,116.45 v3(8.39,116.45) PC5310.2 PR5306.2 PR5309.1
PWR_12V_SNB: length 4.4
  BOTTOM w0.508: v3(18.48,132.45) PC5309.1 18.48,130.29 17.42,129.22 PR5307.2
PWR_12V_SW:
  vias: v3(16.58,121.02)
PWR_81203_ALERT: length 4.7
  BOTTOM w0.102: PR4467.2 39.95,251.42 40.91,250.46 v3(40.91,249.8) PU4401.4
PWR_81203_COMP: length 7.2
  BOTTOM w0.203: PU4401.48 38.13,246.28 37.85,246.56
  BOTTOM w0.254: PC4404.1 33.98,247.7 33.98,247.52 34.39,247.11 35.16,247.11 PC4405.1 v3(36.52,247.45) 36.96,247.45 37.85,246.56
PWR_81203_COMP1: length 2.1
  BOTTOM w0.254: PR4451.1 33.34,250.37 PC4403.1 v3(31.31,250.37)
PWR_81203_COMP2: length 2.6
  BOTTOM w0.254: v3(30,248.99) 30.52,248.46 PR4452.1 32.33,248.46 PC4404.2
PWR_81203_COMPA: length 11.6
  BOTTOM w0.203: 48.58,245.86 48.19,246.25 47.69,246.25 47.29,246.65 46.37,246.65 46,246.28 PU4401.18
  BOTTOM w0.254: 48.58,245.86 49.47,245.86 49.6,245.73 52.37,245.73 53.09,246.45 PC4411.1 53.56,246.75 53.62,246.81 PC4410.1 54.2,246.79 v3(54.2,245.53)
PWR_81203_COMPA1: length 2
  BOTTOM w0.254: PR4457.1 50.93,249.48 v3(51.05,249.36) 51.12,249.29 PC4409.2
PWR_81203_COMPA2: length 2.5
  BOTTOM w0.254: PR4454.1 53.16,247.7 PC4410.2 55.1,247.7 v3(55.44,248.04)
PWR_81203_CSCOMP: length 121.7
  TOP w0.254: PR4439.1 30.11,248.08 v2(29.82,247.79) ; PR4466.1 32.2,188.14 32.2,187.62 v2(32.44,187.37)
  L3 w0.254: v2(29.82,247.79) 29.79,247.76 29.3,247.76 22.44,240.91 10.7,240.91 5.07,235.28 5.07,190.36 12.31,183.12 20.12,183.12 21.41,184.42 30.35,184.42 32.25,186.31 32.25,187.18 v2(32.44,187.37)
  BOTTOM w0.203: 36.01,246.43 37.15,246.43 37.71,245.88 PU4401.47
  BOTTOM w0.254: 36.01,246.43 PR4438.2 34.11,246.43 33.28,247.26 PC4424.1 32.39,247.26 PC4425.1 31.25,246.81 v3(30.68,247.38) 30.27,247.79 v2(29.82,247.79)
PWR_81203_CSCOMP1: length 109.8
  TOP w0.254: PR4439.2 32.2,246.05 PR4440.1 31.34,245.99 30.81,246.51 v1(30.81,246.52) 30.81,246.52 30.8,246.52 30.27,246.52 v2(29.91,246.87) ; PR4466.2 31.69,188.14 31.69,187.51 v2(31.55,187.37)
  L3 w0.254: v2(29.91,246.87) 29.3,246.87 22.83,240.4 10.91,240.4 5.58,235.07 5.58,190.57 12.52,183.63 19.91,183.63 21.2,184.92 30.14,184.92 31.74,186.52 31.74,187.18 v2(31.55,187.37)
PWR_81203_CSCOMPA: length 33.8
  TOP w0.254: v2(53.28,245.35) 53.6,245.67 PR4426.1 54.49,245.48 56.61,245.48 v1(60.7,241.39) 60.93,241.16 75.19,241.16 PR4465.1
  BOTTOM w0.203: PU4401.19 46.07,245.88 46.49,246.3 47.17,246.3 48.12,245.35 49.09,245.35 49.41,245.03 PR4424.2
  BOTTOM w0.254: PR4424.2 50.04,244.72 PC4419.1 PC4418.1 51.44,245.03 51.5,245.1 53.03,245.1 v2(53.28,245.35)
PWR_81203_CSCOMPA1: length 25.6
  TOP w0.254: PR4425.1 53.98,244.46 PR4426.2 54.49,244.97 56.2,244.97 v1(57.54,243.63) 60.52,240.65 75.57,240.65 PR4465.2
PWR_81203_CSN3: length 7.9
  TOP w0.254: PR4468.1 33.09,242.49 PR4444.1 34.85,242.49 v2(35.08,242.26)
  BOTTOM w0.203: PU4401.42 38.63,243.88 37.79,243.04
  BOTTOM w0.254: 37.79,243.04 37.24,242.49 PC4420.2 35.57,242.49 35.33,242.26 v2(35.08,242.26) 34.96,242.26 34.38,242.84 v3(34.37,242.84)
PWR_81203_CSP1: length 6.5
  TOP w0.254: v2(37.66,237.86) 37.41,237.6 PR4443.2
  BOTTOM w0.203: 37.6,240.33 v3(38.33,241.06) 39.71,242.44 PU4401.39
  BOTTOM w0.254: 37.6,240.33 PC4427.1 PR4446.2 37.6,238.05 37.66,237.98 v2(37.66,237.86)
PWR_81203_CSP1A: length 7.3
  BOTTOM w0.203: PU4401.25 45.33,243.48 46.74,242.07 46.74,241.82 46.75,241.81 46.75,241.46
  BOTTOM w0.254: 46.75,241.46 v3(46.93,241.29) 48.14,240.08 PC4422.1 PR4430.2 49.28,240.08 49.73,240.52 PR4429.2
PWR_81203_CSP2: length 7.1
  TOP w0.254: PR4445.2 PR4442.2 35.18,241.35 v2(35.25,241.41)
  BOTTOM w0.203: 37.85,242.47 38.86,243.48 PU4401.41
  BOTTOM w0.254: 37.85,242.47 37.55,242.16 37.55,242.11 v3(37.2,241.77) 36.91,241.48 PC4426.1 35.31,241.48 v2(35.25,241.41)
PWR_81203_CSP2A: length 7
  BOTTOM w0.203: PC4421.1 47.67,242.11 46.68,243.11 46.68,243.6 v3(46.36,243.92) 46,244.28 PU4401.23
  BOTTOM w0.254: PC4421.1 PR4428.2 49.47,242.11 PR4427.2
PWR_81203_CSP3: length 8.1
  TOP w0.254: v2(35.36,243.08) 35.05,243.38 PR4444.2 33.34,243.38 PR4441.2 PR4477.2
  BOTTOM w0.203: 37.53,243.83 37.66,243.95 v3(37.81,243.95) 38.14,244.28 PU4401.43
  BOTTOM w0.254: v2(35.36,243.08) 36.01,243.08 36.26,243.33 PC4420.1 37.09,243.38 37.53,243.83
PWR_81203_CSREF: length 21
  TOP w0.254: PR4433.2 38.55,242.81 v2(37.03,244.33) ; v2(30.17,240.4) 29.79,240.4 29.15,241.03 PR4431.2 29.41,241.35 PR4432.2
  BOTTOM w0.203: PU4401.44 37.37,244.68 v2(37.03,244.33)
  BOTTOM w0.254: v2(37.03,244.33) PC4423.1 36.2,244.27 35.63,243.7 34.4,243.7 31.39,240.68 v3(31.39,240.4) v2(30.17,240.4)
PWR_81203_CSREFA: length 17.9
  TOP w0.254: v2(47.06,244.33) 49.73,241.67 v2(52.14,241.67)
  BOTTOM w0.203: PU4401.22 46.72,244.68 v2(47.06,244.33)
  BOTTOM w0.254: PC4417.1 49.03,243.07 48.3,243.8 47.59,243.8 v2(47.06,244.33) ; PR4421.2 v2(52.14,241.67) 53.46,240.35 v3(53.46,240.07) 53.46,239.76 52.42,238.72 50.77,238.72 50.42,239.06 PR4422.2
