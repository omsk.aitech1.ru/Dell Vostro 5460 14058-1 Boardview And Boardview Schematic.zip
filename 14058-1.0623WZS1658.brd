# Allegro board 14058-1.0623WZS1658.brd (continued)
## Nets (continued)
GND: BT1.2 C1.2 C2.2 C4.2 C5.2 C6.2 C7.2 C8.2 C9.2 C10.2 C11.2 C12.2 C13.2 C14.2 C15.2 C16.2 C17.2 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.2 C42.2 C43.2 C44.2 C45.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.2 C76.2 C77.2 C78.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.2 C85.2 C86.2 C87.2 C88.2 C89.2 C90.2 C91.2 C92.2 C93.2 C94.2 C95.2 C96.2 C97.2 C98.2 C99.2 C100.2 C101.2 C102.2 C103.2 C104.2 C105.2 C106.2 C107.2 C108.2 C109.2 C110.2 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C118.2 C119.2 C120.2 C121.2 C122.2 C123.2 C124.2 C125.2 C126.2 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C133.2 C134.2 C136.2 C138.2 C139.2 C140.1 C141.1 C142.1 C143.2 C144.1 C145.2 C146.2 C147.2 C148.2 C149.2 C151.2 C152.2 C153.2 C156.2 C157.2 C158.2 C159.2 C160.2 C163.2 C169.2 C171.2 C172.2 C173.2 C180.2 C182.2 C185.2 C186.1 C187.2 C189.2 C190.2 C191.2 C193.2 C194.2 C195.2 C197.2 C199.2 C201.2 C202.2 C204.2 C216.2 C217.2 C219.2 C220.2 C221.2 C222.2 C223.2 C224.2 C227.2 C228.2 C231.1 C232.2 C233.2 C245.2 C247.2 C248.2 C251.2 C252.2 C253.2 C254.2 C255.2 C256.2 C257.2 C258.2 C259.2 C260.2 C261.2 C262.2 C269.2 C270.1 C278.2 C279.2 C281.2 C282.2 C283.2 C284.2 C286.2 C287.2 C288.2 C289.2 C290.2 C291.2 C292.2 C294.2 C295.2 C296.2 C297.2 C298.2 C299.2 C311.2 C312.1 C314.2 C329.1 C330.2 C331.2 C332.2 C333.2 C334.2 C338.2 C339.2 C340.2 C341.2 C342.2 C343.2 C344.2 C345.2 C351.2 C352.2 C353.1 C355.2 C356.2 C357.2 C362.2 C363.2 C364.2 C365.2 C366.2 C367.2 C368.2 C369.2 C370.2 C371.2 C372.2 C374.2 C375.2 C376.2 C377.2 C378.2 C379.2 C380.2 C381.2 C382.2 C383.2 C384.2 C412.2 C413.2 C414.1 C415.2 C417.2 C418.2 C419.2 C420.2 C421.2 C426.2 C427.2 C428.2 C429.2 C430.2 C433.1 C434.2 C435.2 C436.2 C437.1 C438.1 C440.2 C441.2 C442.2 C443.1 C444.2 C445.2 C446.1 C447.2 C448.2 C449.2 C452.2 C453.1 C454.1 C455.2 C456.2 C458.1 C459.2 C460.2 C461.1 C463.2 C464.1 C465.2 C466.1 C467.2 C468.1 C469.2 C471.2 C472.1 C473.1 C476.1 C477.2 C479.1 C481.1 C482.1 C484.2 C486.2 C487.1 C488.1 C489.2 C490.2 C491.2 C492.1 C502.2 C503.2 C504.2 C505.2 C506.2 C511.2 C512.2 C513.2 C514.2 C515.2 C516.2 C517.2 C518.2 C519.2 C520.2 C522.2 C523.2 C524.2 C526.1 C528.2 C837.2 C1935.2 C3366.2 C3367.2 C3453.2 C3454.2 C6702.2 C6704.2 C6705.2 C6706.1 C6707.1 C6708.2 C6709.1 C6710.2 C6711.2 C6712.2 C6713.2 C6714.2 C6723.2 C6724.2 C6725.2 C7503.2 C7504.2 C7505.2 C7506.2 C7507.2 C7508.2 C7511.2 C7512.2 C7516.2 C7521.2 C7522.2 C9504.2 C9516.2 C9518.2 C9520.2 C9522.2 C11833.2 C11834.2 C11835.2 C11836.2 C11837.2 C11838.2 C11839.2 C11888.2 C11892.2 C12052.2 C12055.2 C12056.2 C12057.2 C12059.2 C12060.2 C12061.2 C12098.2 C12100.2 C12101.2 C12103.2 C12107.2 C12108.2 C12113.2 C12114.2 C12120.2 C12121.2 C12122.2 C12123.2 C12125.2 C12126.2 C12128.2 C12131.2 C12148.2 C12149.2 C12150.2 C12151.2 C12152.2 C12154.2 C12155.1 C12156.1 C12157.2 C12158.1 C12159.1 C12160.1 C12161.1 C12162.1 C12163.2 C12164.2 C12165.2 C12166.1 C12167.2 C12168.2 C12169.2 C12170.2 C12171.2 C12172.2 C12174.2 C12183.1 C12184.1 C12185.2 C12186.2 C12187.2 C12188.2 C12189.2 C12190.2 C12191.2 C12194.2 C12195.2 C12196.2 C12197.2 C12199.2 C12200.2 C12201.2 C12202.2 C12203.2 C12204.2 C12205.2 C12206.2 C12207.2 C12216.2 C12217.2 C12218.2 C12219.2 C12220.2 C12221.2 C12222.2 C12223.2 C12224.2 C12225.2 C12226.2 C12229.2 C12230.2 C12238.2 C12239.2 C12240.2 C12241.2 C12242.2 C12243.2 C12244.2 C12245.2 C12246.2 C12314.2 C12324.2 C12326.2 C12327.2 C12328.2 C12329.2 C12330.2 C12333.2 C12334.2 C12336.2 C12341.2 C12376.2 C12377.1 C12378.2 C12379.2 C12380.2 C12381.2 C12382.2 C12383.2 C12384.1 C12385.2 C12386.2 C12387.2 C12388.2 C12389.2 C12390.2 C12391.2 C12392.2 C12393.2 C12394.2 C12395.2 C12397.2 C12400.2 C12401.2 C12403.2 C12405.2 C12406.2 C12407.2 C12408.2 C12409.2 C12413.2 C12414.2 C12415.2 C12416.2 C12417.2 C12418.2 C12419.2 C12422.2 C12423.2 C12424.2 C12425.2 C12426.2 C12427.2 C12429.2 C12431.2 C12433.2 C12434.2 C12435.2 C12436.2 C12437.2 C12438.2 C12439.2 C12440.2 C12441.2 C12443.2 C12444.2 C12445.2 CN3.4 CN3.5 CN3.6 CONVT1.10A CONVT1.10B CONVT1.11 CONVT1.12 CPU1.A4 CPU1.A7 CPU1.A11 CPU1.A13 CPU1.A15 CPU1.A17 CPU1.A24 CPU1.AA3 CPU1.AA8 CPU1.AA33 CPU1.AB5 CPU1.AB39 CPU1.AC3 CPU1.AC6 CPU1.AC33 CPU1.AC34 CPU1.AC35 CPU1.AD1 CPU1.AD4 CPU1.AD6 CPU1.AD7 CPU1.AD8 CPU1.AD33 CPU1.AD36 CPU1.AD37 CPU1.AD38 CPU1.AD39 CPU1.AD40 CPU1.AE3 CPU1.AE5 CPU1.AE8 CPU1.AE33 CPU1.AE36 CPU1.AF1 CPU1.AF5 CPU1.AF8 CPU1.AF33 CPU1.AF36 CPU1.AF37 CPU1.AF40 CPU1.AG1 CPU1.AG2 CPU1.AG3 CPU1.AG4 CPU1.AG5 CPU1.AG8 CPU1.AG33 CPU1.AG36 CPU1.AH5 CPU1.AH8 CPU1.AH33 CPU1.AH36 CPU1.AH37 CPU1.AH38 CPU1.AH39 CPU1.AH40 CPU1.AJ1 CPU1.AJ4 CPU1.AJ5 CPU1.AJ8 CPU1.AJ31 CPU1.AJ32 CPU1.AJ33 CPU1.AJ34 CPU1.AJ35 CPU1.AJ36 CPU1.AK5 CPU1.AK6 CPU1.AK7 CPU1.AK8 CPU1.AK9 CPU1.AK10 CPU1.AK12 CPU1.AK13 CPU1.AK15 CPU1.AK16 CPU1.AK17 CPU1.AK18 CPU1.AK19 CPU1.AK20 CPU1.AK23 CPU1.AK25 CPU1.AK26 CPU1.AK28 CPU1.AK29 CPU1.AK30 CPU1.AK36 CPU1.AK37 CPU1.AK40 CPU1.AL1 CPU1.AL2 CPU1.AL3 CPU1.AL4 CPU1.AL5 CPU1.AL11 CPU1.AL14 CPU1.AL21 CPU1.AL24 CPU1.AL27 CPU1.AL30 CPU1.AL36 CPU1.AM5 CPU1.AM11 CPU1.AM14 CPU1.AM17 CPU1.AM19 CPU1.AM24 CPU1.AM27 CPU1.AM30 CPU1.AM31 CPU1.AM32 CPU1.AM33 CPU1.AM34 CPU1.AM35 CPU1.AM36 CPU1.AM37 CPU1.AM38 CPU1.AM39 CPU1.AM40 CPU1.AN1 CPU1.AN4 CPU1.AN5 CPU1.AN6 CPU1.AN7 CPU1.AN8 CPU1.AN9 CPU1.AN10 CPU1.AN11 CPU1.AN14 CPU1.AN16 CPU1.AN19 CPU1.AN22 CPU1.AN23 CPU1.AN24 CPU1.AN27 CPU1.AN30 CPU1.AN36 CPU1.AP5 CPU1.AP11 CPU1.AP14 CPU1.AP24 CPU1.AP27 CPU1.AP30 CPU1.AP36 CPU1.AP37 CPU1.AP40 CPU1.AR1 CPU1.AR2 CPU1.AR3 CPU1.AR4 CPU1.AR5 CPU1.AR11 CPU1.AR14 CPU1.AR16 CPU1.AR17 CPU1.AR18 CPU1.AR19 CPU1.AR20 CPU1.AR21 CPU1.AR22 CPU1.AR23 CPU1.AR24 CPU1.AR27 CPU1.AR30 CPU1.AR31 CPU1.AR32 CPU1.AR33 CPU1.AR34 CPU1.AR35 CPU1.AR36 CPU1.AT5 CPU1.AT6 CPU1.AT7 CPU1.AT8 CPU1.AT9 CPU1.AT10 CPU1.AT11 CPU1.AT12 CPU1.AT13 CPU1.AT14 CPU1.AT15 CPU1.AT17 CPU1.AT24 CPU1.AT25 CPU1.AT26 CPU1.AT27 CPU1.AT28 CPU1.AT29 CPU1.AT30 CPU1.AT31 CPU1.AT32 CPU1.AT34 CPU1.AT36 CPU1.AT37 CPU1.AT38 CPU1.AT39 CPU1.AT40 CPU1.AU1 CPU1.AU4 CPU1.AU5 CPU1.AU7 CPU1.AU25 CPU1.AU30 CPU1.AU34 CPU1.AV2 CPU1.AV5 CPU1.AV9 CPU1.AV26 CPU1.AV28 CPU1.AV30 CPU1.AV34 CPU1.AV38 CPU1.AW3 CPU1.AW5 CPU1.AW9 CPU1.AW30 CPU1.AW32 CPU1.AW34 CPU1.AW36 CPU1.AY3 CPU1.AY5 CPU1.AY7 CPU1.AY9 CPU1.AY27 CPU1.AY30 CPU1.B6 CPU1.B24 CPU1.B26 CPU1.B28 CPU1.B30 CPU1.B38 CPU1.C2 CPU1.C5 CPU1.C8 CPU1.C10 CPU1.C12 CPU1.C14 CPU1.C16 CPU1.C18 CPU1.C20 CPU1.C22 CPU1.C24 CPU1.C31 CPU1.C33 CPU1.C35 CPU1.C37 CPU1.D4 CPU1.D7 CPU1.D24 CPU1.D26 CPU1.D28 CPU1.D30 CPU1.D37 CPU1.D39 CPU1.D40 CPU1.E3 CPU1.E6 CPU1.E9 CPU1.E11 CPU1.E13 CPU1.E15 CPU1.E17 CPU1.E19 CPU1.E21 CPU1.E23 CPU1.E31 CPU1.E33 CPU1.E35 CPU1.E37 CPU1.F1 CPU1.F4 CPU1.F7 CPU1.F10 CPU1.F22 CPU1.F26 CPU1.F28 CPU1.F30 CPU1.F40 CPU1.G3 CPU1.G6 CPU1.G8 CPU1.G11 CPU1.G13 CPU1.G15 CPU1.G17 CPU1.G19 CPU1.G22 CPU1.G31 CPU1.G33 CPU1.H1 CPU1.H4 CPU1.H7 CPU1.H8 CPU1.H9 CPU1.H21 CPU1.H24 CPU1.H26 CPU1.H28 CPU1.H30 CPU1.H35 CPU1.H37 CPU1.H39 CPU1.J3 CPU1.J6 CPU1.J10 CPU1.J12 CPU1.J16 CPU1.J18 CPU1.J20 CPU1.J32 CPU1.J34 CPU1.K1 CPU1.K4 CPU1.K7 CPU1.K14 CPU1.K15 CPU1.K17 CPU1.K19 CPU1.K22 CPU1.K24 CPU1.K26 CPU1.K28 CPU1.K30 CPU1.K33 CPU1.K35 CPU1.K37 CPU1.K39 CPU1.L3 CPU1.L6 CPU1.L9 CPU1.L11 CPU1.L13 CPU1.L32 CPU1.M1 CPU1.M4 CPU1.M7 CPU1.M10 CPU1.M12 CPU1.M15 CPU1.M17 CPU1.M19 CPU1.M21 CPU1.M23 CPU1.M25 CPU1.M27 CPU1.M29 CPU1.M35 CPU1.M37 CPU1.M39 CPU1.N3 CPU1.N6 CPU1.N8 CPU1.N33 CPU1.P1 CPU1.P4 CPU1.P35 CPU1.P37 CPU1.P39 CPU1.R3 CPU1.R6 CPU1.R8 CPU1.R33 CPU1.T1 CPU1.T4 CPU1.T35 CPU1.T37 CPU1.T39 CPU1.U3 CPU1.U6 CPU1.U33 CPU1.V1 CPU1.V8 CPU1.V35 CPU1.V37 CPU1.V39 CPU1.W3 CPU1.W6 CPU1.W33 CPU1.Y5 CPU1.Y35 CPU1.Y37 D5.A D9.2 D10.2 D11.2 D12.A D13.1 D5202.1 D5203.3 D5203.8 D5204.3 D5204.8 D5210.1 D5211.1 D5212.1 D5213.1 D5214.1 DB1.2 DB2.2 DCIN1.2 DCIN1.4 DCIN1.5 DCIN1.6 DCIN1.7 DIMM1.2 DIMM1.3 DIMM1.8 DIMM1.9 DIMM1.11 DIMM1.13 DIMM1.14 DIMM1.19 DIMM1.20 DIMM1.25 DIMM1.26 DIMM1.28 DIMM1.31 DIMM1.32 DIMM1.37 DIMM1.38 DIMM1.43 DIMM1.44 DIMM1.46 DIMM1.48 DIMM1.49 DIMM1.54 DIMM1.55 DIMM1.60 DIMM1.61 DIMM1.63 DIMM1.65 DIMM1.66 DIMM1.71 DIMM1.72 DIMM1.127 DIMM1.128 DIMM1.133 DIMM1.134 DIMM1.136 DIMM1.138 DIMM1.139 DIMM1.144 DIMM1.145 DIMM1.150 DIMM1.151 DIMM1.153 DIMM1.155 DIMM1.156 DIMM1.161 DIMM1.162 DIMM1.167 DIMM1.168 DIMM1.170 DIMM1.172 DIMM1.173 DIMM1.178 DIMM1.179 DIMM1.184 DIMM1.185 DIMM1.187 DIMM1.189 DIMM1.190 DIMM1.195 DIMM1.196 DIMM1.205 DIMM1.206 DIMM2.2 DIMM2.3 DIMM2.8 DIMM2.9 DIMM2.11 DIMM2.13 DIMM2.14 DIMM2.19 DIMM2.20 DIMM2.25 DIMM2.26 DIMM2.28 DIMM2.31 DIMM2.32 DIMM2.37 DIMM2.38 DIMM2.43 DIMM2.44 DIMM2.46 DIMM2.48 DIMM2.49 DIMM2.54 DIMM2.55 DIMM2.60 DIMM2.61 DIMM2.63 DIMM2.65 DIMM2.66 DIMM2.71 DIMM2.72 DIMM2.127 DIMM2.128 DIMM2.133 DIMM2.134 DIMM2.136 DIMM2.138 DIMM2.139 DIMM2.144 DIMM2.145 DIMM2.150 DIMM2.151 DIMM2.153 DIMM2.155 DIMM2.156 DIMM2.161 DIMM2.162 DIMM2.167 DIMM2.168 DIMM2.170 DIMM2.172 DIMM2.173 DIMM2.178 DIMM2.179 DIMM2.184 DIMM2.185 DIMM2.187 DIMM2.189 DIMM2.190 DIMM2.195 DIMM2.196 DIMM2.205 DIMM2.206 FANC3.1 GPU1.A2 GPU1.A26 GPU1.AA7 GPU1.AB7 GPU1.AB11 GPU1.AB14 GPU1.AB17 GPU1.AB20 GPU1.AB24 GPU1.AC2 GPU1.AC5 GPU1.AC8 GPU1.AC22 GPU1.AC26 GPU1.AD12 GPU1.AD13 GPU1.AD15 GPU1.AD16 GPU1.AD18 GPU1.AD19 GPU1.AD21 GPU1.AD22 GPU1.AE11 GPU1.AE14 GPU1.AE17 GPU1.AE20 GPU1.AF1 GPU1.AF5 GPU1.AF8 GPU1.AF11 GPU1.AF14 GPU1.AF17 GPU1.AF20 GPU1.AF23 GPU1.AG2 GPU1.AG26 GPU1.B1 GPU1.B5 GPU1.B8 GPU1.B11 GPU1.B14 GPU1.B17 GPU1.B20 GPU1.B23 GPU1.B27 GPU1.E2 GPU1.E5 GPU1.E8 GPU1.E11 GPU1.E14 GPU1.E17 GPU1.E20 GPU1.E22 GPU1.E25 GPU1.H2 GPU1.H5 GPU1.H23 GPU1.H25 GPU1.K11 GPU1.K13 GPU1.K15 GPU1.K17 GPU1.L2 GPU1.L5 GPU1.L10 GPU1.L12 GPU1.L14 GPU1.L16 GPU1.L18 GPU1.L23 GPU1.L25 GPU1.M11 GPU1.M13 GPU1.M15 GPU1.M17 GPU1.N10 GPU1.N12 GPU1.N14 GPU1.N16 GPU1.N18 GPU1.P2 GPU1.P5 GPU1.P11 GPU1.P13 GPU1.P15 GPU1.P17 GPU1.P23 GPU1.P26 GPU1.R10 GPU1.R12 GPU1.R14 GPU1.R16 GPU1.R18 GPU1.T11 GPU1.T13 GPU1.T15 GPU1.T17 GPU1.U2 GPU1.U5 GPU1.U10 GPU1.U12 GPU1.U14 GPU1.U16 GPU1.U18 GPU1.U23 GPU1.U26 GPU1.V11 GPU1.V13 GPU1.V15 GPU1.V17 GPU1.Y2 GPU1.Y5 GPU1.Y23 GPU1.Y26 H13.1 H13.2 H13.3 H13.4 H13.5 H13.6 H13.7 H13.8 H14.1 H14.2 H14.3 H14.4 H14.5 H14.6 H14.7 H14.8 H15.1 H16.1 H17.1 H18.1 H19.1 H20.1 H22.1 H22.2 H22.3 H22.4 H22.5 H22.6 H22.7 H22.8 H23.1 H23.2 H23.3 H23.4 H23.5 H23.6 H23.7 H23.8 H24.1 H24.2 H24.3 H24.4 H24.5 H24.6 H24.7 H24.8 H25.1 H25.2 H25.3 H25.4 H25.5 H25.6 H25.7 H25.8 HDD1.1 HDD1.4 HDD1.7 HDD1.8 HDD1.9 HDMI1.2 HDMI1.5 HDMI1.8 HDMI1.11 HDMI1.17 HDMI1.20 HDMI1.21 HDMI1.22 HDMI2.2 HDMI2.5 HDMI2.8 HDMI2.17 HDMI2.20 HDMI2.21 HDMI2.22 HS6.1 LED2.K LPC1.12 LPC1.14 LVDS1.7 LVDS1.14 LVDS1.31 LVDS1.32 MEMCD1.3 MEMCD1.6 MEMCD1.10 MEMCD1.13 MEMCD1.17 MEMCD1.GND1 MEMCD1.GND2 MEMCD1.GND3 MEMCD1.GND4 NGFF1.7 NGFF1.18 NGFF1.23 NGFF1.24 NGFF1.29 NGFF1.30 NGFF1.33 NGFF1.36 NGFF1.39 NGFF1.45 NGFF1.57 NGFF1.63 NGFF1.69 NGFF1.75 NGFF1.76 NGFF1.77 ODD2.1 ODD2.4 ODD2.7 ODD2.8 ODD2.9 PC1.2 PC2.2 PC3.2 PC4.2 PC6.1 PC11.2 PC12.2 PC24.2 PC34.2 PC35.2 PC36.2 PC38.2 PC39.2 PC40.2 PC42.2 PC43.2 PC44.2 PC46.2 PC47.2 PC48.2 PC50.2 PC51.2 PC52.2 PC56.2 PC61.2 PC63.2 PC64.2 PC65.2 PC66.2 PC68.2 PC69.2 PC70.1 PC71.2 PC72.2 PC73.2 PC77.1 PC78.2 PC80.2 PC81.2 PC82.2 PC84.2 PC85.2 PC86.2 PC88.2 PC89.2 PC90.2 PC91.2 PC92.2 PC94.2 PC95.2 PC97.2 PC98.2 PC99.2 PC100.2 PC101.2 PC102.2 PC104.2 PC105.2 PC107.2 PC117.2 PC152.2 PC154.2 PC155.2 PC156.2 PC158.2 PC159.2 PC163.2 PC4401.2 PC4402.2 PC4407.2 PC4408.2 PC4413.2 PC4414.2 PC4415.2 PC4416.2 PC4417.2 PC4423.2 PC4428.2 PC4429.2 PC4430.2 PC4431.2 PC4701.1 PC5237.1 PC5246.2 PC5253.2 PC5254.2 PC5301.2 PC5302.2 PC5303.2 PC5304.2 PC5305.2 PC5306.2 PC5308.2 PC5309.2 PC5311.2 PC5312.2 PC8301.2 PC8302.2 PC8306.2 PC8307.2 PC8308.2 PC8311.2 PC8314.2 PC8315.2 PC8317.2 PC8501.2 PC8607.2 PC8609.2 PC8610.2 PC8611.2 PC8612.2 PC8613.2 PC8615.2 PC8616.2 PC8617.2 PC8618.2 PC12172.2 PC12173.2 PC12174.2 PC12175.2 PC12176.2 PC12177.2 PC12178.2 PC12179.2 PC12180.2 PC12181.2 PC12182.2 PC12183.2 PC12184.2 PC12185.2 PC12186.2 PC12187.2 PD5301.A PQ4408.S PQ5007.1 PQ5007.4 PQ5301.S PQ5302.S PR9.2 PR14.2 PR18.2 PR60.2 PR136.1 PR143.2 PR161.2 PR164.2 PR165.2 PR166.2 PR168.2 PR169.2 PR193.2 PR208.2 PR210.2 PR211.2 PR214.2 PR229.2 PR232.2 PR235.2 PR246.2 PR4409.1 PR4414.1 PR4417.2 PR4418.2 PR4420.2 PR4453.1 PR4456.2 PR4458.2 PR4461.2 PR4462.2 PR4464.1 PR4473.2 PR4474.2 PR5274.1 PR5303.2 PR5309.2 PR5522.2 PR5523.2 PR8312.2 PR8320.2 PR8333.2 PR8334.2 PR8335.2 PR8338.2 PR8621.2 PR8624.1 PSWD1.1 PT1.2 PT2.2 PT3.2 PT4.2 PT5.2 PT6.2 PT7.2 PT8.2 PT9.2 PT11.2 PT12.2 PT13.2 PT14.2 PT15.2 PT16.2 PT17.2 PT18.2 PT20.2 PT22.2 PT23.2 PT24.2 PT25.2 PT26.2 PT27.2 PT28.2 PT29.2 PT30.2 PT32.2 PT34.2 PT35.2 PU4.6 PU4.9 PU5.1 PU5.2 PU5.3 PU6.1 PU6.2 PU6.3 PU9.6 PU9.9 PU10.1 PU10.2 PU10.3 PU11.1 PU11.2 PU11.3 PU14.6 PU14.9 PU15.1 PU15.2 PU15.3 PU16.1 PU16.2 PU16.3 PU19.6 PU19.9 PU20.1 PU20.2 PU20.3 PU21.1 PU21.2 PU21.3 PU24.6 PU24.9 PU25.1 PU25.2 PU25.3 PU26.1 PU26.2 PU26.3 PU28.7 PU28.16 PU28.17 PU29.1 PU29.2 PU29.3 PU30.1 PU30.2 PU30.3 PU32.11 PU33.1 PU33.2 PU33.3 PU35.21 PU37.1 PU37.2 PU37.3 PU38.1 PU38.2 PU38.3 PU40.1 PU40.3 PU40.14 PU40.21 PU41.1 PU41.2 PU41.3 PU42.1 PU42.2 PU42.3 PU44.11 PU45.1 PU45.2 PU45.3 PU46.1 PU46.2 PU46.3 PU4401.53 PU5202.1 PU5202.2 PU5202.3 PU5204.1 PU5204.2 PU5204.3 PU5301.6 PU5301.9 PU5302.1 PU8602.4 PU8602.12 PU8602.13 PU8602.14 PU8602.15 PU8602.19 PWRCN1.4 PWRCN1.11 PWRCN1.12 Q2.E Q3.S Q6.1 Q6.4 Q8.S Q10.1 Q10.4 Q12.S Q13.4 Q15.3 Q16.3 Q17.3 Q18.E Q23.1 Q23.4 Q26.E Q30.S Q31.S Q53.S Q58.S Q60.E Q61.E Q62.E Q63.E Q64.S Q65.S Q76.E Q103.S Q1227.S Q1228.1 Q1228.4 Q1233.1 Q1233.4 Q1249.S Q1260.E Q1261.S Q1262.S Q1263.E Q1265.E Q1266.E Q1267.E Q6701.1 Q6701.4 Q6704.E Q9503.1 Q9503.4 Q9619.S Q9620.1 Q9626.S Q9628.1 Q9628.4 Q9629.1 Q9629.4 Q9630.S Q9632.1 Q9632.4 Q9633.1 Q9633.4 Q9634.E Q9635.E Q9650.S R1.2 R2.2 R5.2 R19.2 R32.2 R35.1 R45.2 R46.2 R47.2 R48.2 R49.2 R50.2 R51.2 R52.2 R53.2 R54.2 R56.2 R57.2 R58.2 R59.2 R60.2 R61.2 R62.2 R74.2 R75.2 R78.2 R80.2 R84.2 R86.2 R89.2 R91.2 R95.2 R99.2 R100.2 R127.2 R137.2 R141.2 R147.2 R152.2 R188.2 R189.2 R190.2 R192.2 R219.2 R223.2 R224.2 R227.2 R228.2 R229.2 R231.2 R235.2 R238.2 R239.1 R243.2 R246.2 R247.2 R258.2 R293.2 R303.2 R321.2 R327.2 R339.2 R362.1 R372.2 R379.1 R388.2 R417.1 R418.1 R419.1 R420.1 R423.1 R424.1 R439.2 R440.2 R457.2 R462.2 R464.2 R466.2 R469.2 R471.2 R472.2 R485.2 R486.2 R503.2 R510.2 R511.2 R512.2 R523.2 R533.2 R587.2 R598.2 R599.2 R610.1 R613.2 R615.2 R616.2 R619.2 R620.2 R621.2 R622.2 R629.2 R715.2 R722.2 R725.2 R728.2 R764.1 R894.2 R1592.2 R1660.2 R1663.2 R1685.2 R1688.2 R1780.2 R1782.1 R1789.2 R1798.1 R1799.2 R1829.1 R1830.2 R1833.2 R1840.2 R1923.1 R1952.2 R1990.2 R1991.2 R1994.2 R1996.2 R2082.2 R2085.2 R2086.2 R2089.2 R2090.2 R5201.1 R5202.1 R5203.1 R5204.1 R5205.1 R5206.1 R5207.1 R5208.1 R7514.2 R7541.2 R7917.2 R9505.2 R9508.2 R9519.1 R9554.2 R9563.2 R9604.2 R9609.2 R79172.2 R79237.1 R79376.1 R79668.2 R79697.1 R79698.2 R79703.2 R79717.2 R79719.2 R79728.2 R79742.1 R79748.2 R79753.2 R79756.2 R79760.2 R79762.2 R79764.2 R79768.2 R79770.1 R79772.2 R79773.2 R79776.2 R79782.2 R79797.2 R79801.2 R79802.2 R79811.2 R79821.1 R79822.1 R79823.1 R79824.1 R79825.1 R79840.2 R79861.2 R79875.2 R79914.2 R79916.2 R79931.2 R79933.2 R79944.2 R79945.1 R79948.2 R79949.1 R79950.1 R79978.2 R79979.2 R79981.2 R79982.2 R79985.1 R79986.2 R79988.1 R79989.2 R79993.2 R79994.2 R79998.2 R80000.2 R80020.2 R80028.2 R80034.2 R80040.2 R80049.2 R80060.1 R80215.2 R80218.2 R80225.2 RJ1.13 RN7501.6(B) RN7501.7(B) RN7502.4(B) RN7503.3(B) RN7504.3(B) RN7505.6(B) RN7505.7(B) RN7506.6(B) RN7506.7(B) RN7507.4(B) RN7508.4(B) RN7509.3(B) RN7510.4(B) RN7511.4(B) RN7512.3(B) RN7513.3(B) RN7514.4(B) RN7515.3(B) RN7516.4(B) RN7517.3(B) RV5.1 SATAP1.2 SATAP1.4 SCA1.11 SCA1.38 SCA1.61 SCA1.85 SCA1.107 SPK1.5 SPK1.7 SPK1.8 SPR1.1 SPR2.1 SRCON1.4 SSUSB1.4 SSUSB1.7 SSUSB1.10 SSUSB1.11 SSUSB2.4 SSUSB2.7 SSUSB2.10 SSUSB2.11 TC2.2 TC3.2 TC4.2 TC5.2 TC6.2 TOUCH2.2 U2.A2 U2.A3 U2.A4 U2.A18 U2.A25 U2.A32 U2.A37 U2.A42 U2.A44 U2.AA4 U2.AA17 U2.AA18 U2.AA20 U2.AA21 U2.AA25 U2.AA29 U2.AA42 U2.AB4 U2.AB5 U2.AB7 U2.AB8 U2.AB14 U2.AB15 U2.AB31 U2.AB32 U2.AB38 U2.AC1 U2.AC18 U2.AC20 U2.AC21 U2.AC25 U2.AC29 U2.AC45 U2.AD4 U2.AD8 U2.AD11 U2.AD14 U2.AD32 U2.AD33 U2.AD36 U2.AE4 U2.AE18 U2.AE20 U2.AE21 U2.AE25 U2.AE28 U2.AE29 U2.AE42 U2.AF18 U2.AF20 U2.AF21 U2.AF23 U2.AF25 U2.AF26 U2.AF28 U2.AF29 U2.AG4 U2.AG11 U2.AG13 U2.AG31 U2.AG32 U2.AG33 U2.AG38 U2.AH1 U2.AH17 U2.AH18 U2.AH20 U2.AH21 U2.AH23 U2.AH25 U2.AH26 U2.AH28 U2.AH29 U2.AH45 U2.AJ10 U2.AJ14 U2.AJ15 U2.AJ17 U2.AJ18 U2.AJ26 U2.AJ28 U2.AJ29 U2.AJ31 U2.AJ32 U2.AJ36 U2.AK4 U2.AK42 U2.AL4 U2.AL10 U2.AL11 U2.AL13 U2.AL17 U2.AL19 U2.AL24 U2.AL29 U2.AL32 U2.AL33 U2.AL38 U2.AM15 U2.AM17 U2.AM19 U2.AM22 U2.AM24 U2.AM27 U2.AM29 U2.AM45 U2.AN4 U2.AN7 U2.AN8 U2.AN10 U2.AN11 U2.AN22 U2.AN27 U2.AN31 U2.AN39 U2.AP4 U2.AP11 U2.AR5 U2.AR7 U2.AR9 U2.AR33 U2.AR34 U2.AR42 U2.AT9 U2.AT10 U2.AT15 U2.AT36 U2.AU1 U2.AU7 U2.AU35 U2.AU36 U2.AU39 U2.AU45 U2.AV6 U2.AV17 U2.AV24 U2.AV27 U2.AV31 U2.AV33 U2.AW9 U2.AW13 U2.AW19 U2.AW29 U2.AW37 U2.AY38 U2.AY45 U2.B1 U2.B2 U2.B3 U2.B6 U2.B25 U2.B37 U2.B40 U2.B44 U2.B45 U2.BA1 U2.BB1 U2.BB11 U2.BB16 U2.BB21 U2.BB25 U2.BB30 U2.BB34 U2.BC1 U2.BC2 U2.BD2 U2.BD43 U2.BD44 U2.BD45 U2.BE9 U2.BE14 U2.BE18 U2.BE23 U2.BE28 U2.BE32 U2.BE37 U2.BE40 U2.BE44 U2.C2 U2.C4 U2.C10 U2.C28 U2.C37 U2.C42 U2.D10 U2.D12 U2.D15 U2.D16 U2.D17 U2.D19 U2.D21 U2.D24 U2.D25 U2.D27 U2.D29 U2.D30 U2.D31 U2.D33 U2.D35 U2.D36 U2.D45 U2.E13 U2.E15 U2.E31 U2.E33 U2.F8 U2.F44 U2.G9 U2.G42 U2.H3 U2.H17 U2.H19 U2.H22 U2.H24 U2.H27 U2.H29 U2.H35 U2.J3 U2.J5 U2.J7 U2.J10 U2.J11 U2.J39 U2.K4 U2.K10 U2.K27 U2.K33 U2.K36 U2.K42 U2.K43 U2.L4 U2.L8 U2.L12 U2.L13 U2.L15 U2.L41 U2.M35 U2.M42 U2.N4 U2.N5 U2.N10 U2.N15 U2.N19 U2.N22 U2.N24 U2.N35 U2.N36 U2.N41 U2.P17 U2.P19 U2.P22 U2.P45 U2.R5 U2.R10 U2.R14 U2.R22 U2.R29 U2.R33 U2.R38 U2.T1 U2.T2 U2.T4 U2.T42 U2.U4 U2.U8 U2.U10 U2.U11 U2.U14 U2.U15 U2.U17 U2.U18 U2.U28 U2.U29 U2.U31 U2.U32 U2.U33 U2.U38 U2.V3 U2.V18 U2.V20 U2.V21 U2.V23 U2.V25 U2.V29 U2.V45 U2.W4 U2.W8 U2.W14 U2.W31 U2.W32 U2.W33 U2.W38 U2.Y17 U2.Y18 U2.Y20 U2.Y21 U2.Y26 U2.Y28 U2.Y29 U3.3 U6.4 U9.49 U10.8 U10.9 U10.10 U10.17 U10.20 U10.21 U10.24 U10.33 U11.2 U14.33 U15.3 U15.8 U16.3 U16.8 U21.11 U21.15 U22.11 U22.15 U26.3 U26.8 U28.3 U28.8 U29.3 U29.8 U33.4 U55.14 U55.21 U109.4 U109.35 U109.71 U118.8 U118.15 U118.35 U118.41 U120.20 U171.1 U171.4 U173.1 U173.4 U175.1 U175.4 U176.1 U176.4 U5201.1 U5201.2 U5201.3 U5201.4 U5202.3 U5203.3 U6701.5 U6701.10 U6701.12 U6701.13 U6701.15 U6701.16 U9501.4 U9502.1 U9502.2 U9502.3 U9502.4 U9601.1 U9614.2 U9616.S U9617.S U9619.22 U9619.25 U9621.3 U9622.4 U9623.33 U9624.2 U9625.14 U9625.17 UHS1.MS1 UHS1.MS2 USB1.4 USB1.5 USB1.6 USB2.4 USB2.5 USB2.6 USB3.4 USB3.5 USB3.6 USB4.4 USB4.5 USB4.6 VRAM1.A9 VRAM1.B1 VRAM1.B3 VRAM1.B9 VRAM1.D1 VRAM1.D8 VRAM1.E1 VRAM1.E2 VRAM1.E8 VRAM1.F9 VRAM1.G1 VRAM1.G8 VRAM1.G9 VRAM1.J2 VRAM1.J8 VRAM1.M1 VRAM1.M9 VRAM1.P1 VRAM1.P9 VRAM1.T1 VRAM1.T9 VRAM2.A9 VRAM2.B1 VRAM2.B3 VRAM2.B9 VRAM2.D1 VRAM2.D8 VRAM2.E1 VRAM2.E2 VRAM2.E8 VRAM2.F9 VRAM2.G1 VRAM2.G8 VRAM2.G9 VRAM2.J2 VRAM2.J8 VRAM2.M1 VRAM2.M9 VRAM2.P1 VRAM2.P9 VRAM2.T1 VRAM2.T9 VRAM3.A9 VRAM3.B1 VRAM3.B3 VRAM3.B9 VRAM3.D1 VRAM3.D8 VRAM3.E1 VRAM3.E2 VRAM3.E8 VRAM3.F9 VRAM3.G1 VRAM3.G8 VRAM3.G9 VRAM3.J2 VRAM3.J8 VRAM3.M1 VRAM3.M9 VRAM3.P1 VRAM3.P9 VRAM3.T1 VRAM3.T9 VRAM4.A9 VRAM4.B1 VRAM4.B3 VRAM4.B9 VRAM4.D1 VRAM4.D8 VRAM4.E1 VRAM4.E2 VRAM4.E8 VRAM4.F9 VRAM4.G1 VRAM4.G8 VRAM4.G9 VRAM4.J2 VRAM4.J8 VRAM4.M1 VRAM4.M9 VRAM4.P1 VRAM4.P9 VRAM4.T1 VRAM4.T9 VRAM5.A9 VRAM5.B1 VRAM5.B3 VRAM5.B9 VRAM5.D1 VRAM5.D8 VRAM5.E1 VRAM5.E2 VRAM5.E8 VRAM5.F9 VRAM5.G1 VRAM5.G8 VRAM5.G9 VRAM5.J2 VRAM5.J8 VRAM5.M1 VRAM5.M9 VRAM5.P1 VRAM5.P9 VRAM5.T1 VRAM5.T9 VRAM6.A9 VRAM6.B1 VRAM6.B3 VRAM6.B9 VRAM6.D1 VRAM6.D8 VRAM6.E1 VRAM6.E2 VRAM6.E8 VRAM6.F9 VRAM6.G1 VRAM6.G8 VRAM6.G9 VRAM6.J2 VRAM6.J8 VRAM6.M1 VRAM6.M9 VRAM6.P1 VRAM6.P9 VRAM6.T1 VRAM6.T9 VRAM7.A9 VRAM7.B1 VRAM7.B3 VRAM7.B9 VRAM7.D1 VRAM7.D8 VRAM7.E1 VRAM7.E2 VRAM7.E8 VRAM7.F9 VRAM7.G1 VRAM7.G8 VRAM7.G9 VRAM7.J2 VRAM7.J8 VRAM7.M1 VRAM7.M9 VRAM7.P1 VRAM7.P9 VRAM7.T1 VRAM7.T9 VRAM8.A9 VRAM8.B1 VRAM8.B3 VRAM8.B9 VRAM8.D1 VRAM8.D8 VRAM8.E1 VRAM8.E2 VRAM8.E8 VRAM8.F9 VRAM8.G1 VRAM8.G8 VRAM8.G9 VRAM8.J2 VRAM8.J8 VRAM8.M1 VRAM8.M9 VRAM8.P1 VRAM8.P9 VRAM8.T1 VRAM8.T9 WEBCM1.6 WEBCM1.8 WEBCM1.9 WEBCM1.10 X1.2 X1.4 X2.2 X2.3 X3.2 X3.4 X5.2 X5.4 X9502.2 X9502.4 XDPC1.2 XDPC1.7 XDPC1.8 XDPC1.13 XDPC1.14 XDPC1.19 XDPC1.20 XDPC1.25 XDPC1.26 XDPC1.31 XDPC1.32 XDPC1.37 XDPC1.38 XDPC1.49 XDPC1.50 XDPC1.59
GND_AUD: C213.1 C214.1 U9.40
P1V0_PCH_VCCDSW: C11833.1 U2.BA29
PVCC_3V3: C9504.1 C9516.1 C12170.1 C12191.1 C12197.1 L9502.1 L9505.2 R9503.2 R9507.1 R9521.2 R9525.2 R9528.2 R9544.1 R9545.2 R9548.2 R79205.2 R79236.2 R79798.1 R79799.1 R79800.1 R79868.1 RN9503.6(B) RN9503.7(B) RN9503.8(B) SCA1.49 SCA1.84 U9501.7 U9501.8 U9502.8
PVCC_3V3_SDRAM: C9518.1 C12184.2 C12194.1 C12244.1 L9503.2 SCA1.62 SCA1.106
V1P0_CPU_XDP_S5: R1748.1 R1749.1 XDPC1.43 XDPC1.44
V1P0_PCH_S5: C11834.1 C11888.1 PR213.1 PR215.1 PR216.1 PR217.1 PR218.1 PR219.1 PR220.1 Q1234.D R68.1 R132.2 R889.1 R890.1 R891.1 R892.2 R1748.2 R1749.2 R1776.1 R1841.2 R1842.2 R79779.2 U2.AA23 U2.AA26 U2.AA28 U2.AC17 U2.AC23 U2.AC26 U2.AC28 U2.AD15 U2.AE23 U2.AE26 U2.AJ20 U2.AJ21 U2.AJ23 U2.AJ25 U2.N17 U2.R17 U2.R19 U2.U20 U2.U21 U2.U23 U2.U25 U2.U26 U2.V17 U2.V26 U2.V28 U2.Y23 U2.Y25
VBAT1: BT1.1 R357.1
VBAT1_R: D2.2 D3.A R357.2 TP108.1
VBAT2: D3.K R302.2
VBAT_SIO: C190.1 R302.1 U109.66
VCC: C363.1 C364.1 C12113.1 C12199.1 D23.A F7.1 LPC1.8 PC152.1 PR74.1 PR83.1 PR89.1 PR98.1 PR106.1 PR4404.1 PR8313.1 PR8330.1 PR8339.2 PR8616.2 PU5302.6 R118.1 R266.2 R378.1 R499.1 R692.1 R693.1 R741.1 R763.1 R5217.1 R6705.1 R9540.1 R9541.1 R79858.1 R80234.1 R80239.2 U1.1 U1.2 U1.5 U1.6 U21.13 U21.14
VCC3: C104.1 C105.1 C128.1 C129.1 C219.1 C220.1 C227.1 C228.1 C365.1 C366.1 C836.2 C3367.1 C11838.1 C12131.1 C12160.2 C12200.1 C12201.1 D4.K D13.2 DIMM1.199 DIMM2.199 F20.1 L5.1 LPC1.4 PR4.1 PR135.1 PR4401.1 PR4402.1 PR5518.1 Q54.S Q9620.5 R73.2 R85.1 R124.1 R128.2 R133.1 R134.1 R143.1 R154.2 R156.2 R157.2 R158.2 R160.2 R161.2 R162.2 R165.2 R168.2 R169.2 R170.2 R172.2 R173.2 R174.2 R175.2 R176.2 R177.2 R196.1 R197.1 R199.1 R217.1 R218.1 R226.1 R249.2 R251.2 R255.2 R257.1 R262.2 R263.2 R264.2 R265.2 R267.2 R268.2 R269.2 R270.2 R286.2 R290.2 R296.2 R323.2 R324.1 R335.1 R342.1 R359.1 R373.1 R374.1 R391.2 R426.2 R436.1 R473.1 R475.1 R492.1 R517.1 R524.1 R530.2 R584.1 R586.2 R734.2 R738.1 R740.1 R747.1 R748.2 R753.2 R1129.2 R1593.1 R1594.1 R1596.1 R1598.1 R1659.1 R1661.1 R1662.1 R1684.1 R1687.1 R1762.1 R1955.1 R1961.1 R1964.1 R2087.1 R2088.1 R6701.1 R6702.1 R6703.1 R6704.1 R9532.1 R9533.1 R9543.1 R9557.1 R79171.1 R79174.2 R79720.1 R79737.1 R79755.1 R79766.2 R79767.2 R79771.1 R79810.1 R79831.2 R79838.1 R79842.1 R79867.1 R79922.2 R79932.1 R79938.2 R79939.2 R79940.2 R79941.2 R79942.2 R79946.1 R79951.1 R80018.2 R80054.1 RN1.5(B) RN1.6(B) RN1.7(B) RN1.8(B) U2.AD13 U9.11 U14.11 U21.8 U21.9 U118.11 U118.37 U119.3
VCC3_CAM: C351.1 C352.1 C353.2 F6.2 F20.2 R473.2 R474.2 WEBCM1.3
VCC3_CT2: C369.1 U21.10
VCC3_EN: C367.1 R506.2 U21.5
VCC5_DDC_HDMI: C12443.1 D23.K R2083.1 R2084.1
VCC5_PANEL: C12220.1 C12221.1 C12222.1 F17.2 LVDS1.2 LVDS1.3 Q9648.S R1163.1 R79729.1 R80230.1
VCC5_USB: C314.1 C373.2 C374.1 C375.1 F12.1 F14.1 F18.1 F19.1 Q29.1 Q29.2 Q29.3 R462.1 R466.1 R471.1 R511.1 U9625.1
VCC_CT1: C370.1 U21.12
VCC_EN: C368.1 R505.2 U21.3
VCC_RTCEXT_CAP: C1935.1 U2.BA26
VCCEOPIO_SENSE: CPU1.AJ24 TP249.1
VCCGT_VCC_SEN: CPU1.F39 PR4412.2 R79761.2
VCCGT_VSS_SEN: CPU1.F38 PC4412.2 PR4413.1 R79762.1
VCCGTX_SENSE: CPU1.F37 TP228.1
VCCIO_SENSE: CPU1.AF4 PR4802.1
VCCK_1V2: C12169.1 C12183.2 C12195.1 C12196.1 L9504.2 L9523.1 SCA1.60 SCA1.73 SCA1.120
VCCOPC_SENSE: CPU1.AK21 TP250.1
VCCSA_SENSE: CPU1.AD5 PR15.2 PR16.2 PR17.2
VCCST_PWRGD: R33.1 R1777.1 R1971.1 R1972.2
VCCST_PWRGD_CPU: CPU1.U2 R33.2 R35.2
VCCST_PWRGD_L: R1971.2 U176.3
VSS_OPC_EOPIO_SENSE: CPU1.AK22 TP248.1
VSS_SA_IO_SENSE: CPU1.AE4 PR18.1 PR4803.1 PU28.11
VSSGTX_SENSE: CPU1.F36 TP229.1
3D3V_RUN_FFS: C6702.1 C12239.1 C12240.1 R6701.2 U6701.1 U6701.7 U6701.8 U6701.14
3P3V_LAN: C281.1 C294.1 C295.1 C296.1 C297.1 C298.1 C299.1 C3453.1 C3454.1 C12121.1 C12128.1 Q1264.D R438.1 R79618.1 R79748.1 U11.5 U9614.5 U9623.11 U9623.23 U9623.32 U9624.5
3P3V_SPI: C202.1 R236.2 R341.2 R342.2 R343.1 R345.1 R1797.2 R1800.2 R1828.2 R79874.1 SRCON1.8 U2.BE41 U2.BE42 U2.BE43 U9622.8
14MHZ_IN_SCALAR: C9520.1 R9547.2 SCA1.128 X9502.3
14MHZ_OUT_SCALAR: C9522.1 R9547.1 SCA1.127 X9502.1
1117 ADJ: R1592.1 R2081.2 U119.1
2136_HPD_C: R522.2 R530.1 R79763.2 R79764.1
+OPC_FUSEPRG: CPU1.AB38 TP252.1
+V_1P05_VGA: C412.1 C413.1 C417.1 C420.1 C421.1 C426.1 C428.1 C429.1 C433.2 C434.1 C437.2 C441.1 C442.1 C445.1 C12376.1 GPU1.AA10 GPU1.AA12 GPU1.AA13 GPU1.AA16 GPU1.AA18 GPU1.AA19 GPU1.AA20 GPU1.AA21 GPU1.AA22 GPU1.AB22 GPU1.AB23 GPU1.AC23 GPU1.AC24 GPU1.AD24 GPU1.AD25 GPU1.AE25 GPU1.AE26 GPU1.AE27 GPU1.AF26 GPU1.AF27 L27.2 L28.1 L29.1 L9524.2 PR228.1 PR230.1 R80056.2
+V_1P05_VGA_DISCHIG: Q9632.6 R80056.1
+V_1P35_VGA: C148.1 C152.1 C153.1 C169.1 C171.1 C172.1 C173.1 C415.1 C418.1 C452.1 C455.1 C476.2 C477.1 C504.1 C505.1 C6707.2 C6711.1 C6712.1 C6713.1 C6714.1 C6723.1 C6725.1 C7503.1 C7504.1 C7505.1 C7506.1 C7507.1 C7508.1 C7511.1 C7512.1 C7516.1 C7521.1 C7522.1 C12380.1 C12385.1 C12387.1 C12388.1 C12389.1 C12390.1 C12391.1 C12392.1 C12393.1 C12397.1 C12400.1 C12401.1 C12403.1 C12405.1 C12406.1 C12407.1 C12408.1 C12409.1 C12413.1 C12414.1 C12415.1 C12416.1 C12417.1 C12418.1 C12419.1 C12422.1 C12423.1 C12424.1 C12425.1 C12426.1 C12427.1 C12429.1 C12431.1 C12433.1 C12434.1 C12435.1 C12436.1 C12437.1 C12438.1 C12439.1 C12440.1 C12441.1 GPU1.B26 GPU1.C25 GPU1.E23 GPU1.E26 GPU1.F14 GPU1.F21 GPU1.G13 GPU1.G14 GPU1.G15 GPU1.G16 GPU1.G18 GPU1.G19 GPU1.G20 GPU1.G21 GPU1.H24 GPU1.H26 GPU1.J21 GPU1.K21 GPU1.L22 GPU1.L24 GPU1.L26 GPU1.M21 GPU1.N21 GPU1.R21 GPU1.T21 GPU1.V21 GPU1.W21 PR8609.2 PR8612.2 PR8613.2 PR8614.2 PR8619.2 PR8622.2 R604.2 R608.2 R611.2 R612.1 R7513.2 R7539.2 R79995.1 R79997.1 R79999.1 R80058.2 RN7501.5(B) RN7501.8(B) RN7502.3(B) RN7503.4(B) RN7504.4(B) RN7505.5(B) RN7505.8(B) RN7506.5(B) RN7506.8(B) RN7507.3(B) RN7508.3(B) RN7509.4(B) RN7510.3(B) RN7511.3(B) RN7512.4(B) RN7513.4(B) RN7514.3(B) RN7515.4(B) RN7516.3(B) RN7517.4(B) VRAM1.A1 VRAM1.A8 VRAM1.B2 VRAM1.C1 VRAM1.C9 VRAM1.D2 VRAM1.D9 VRAM1.E9 VRAM1.F1 VRAM1.G7 VRAM1.H2 VRAM1.H9 VRAM1.K2 VRAM1.K8 VRAM1.N1 VRAM1.N9 VRAM1.R1 VRAM1.R9 VRAM2.A1 VRAM2.A8 VRAM2.B2 VRAM2.C1 VRAM2.C9 VRAM2.D2 VRAM2.D9 VRAM2.E9 VRAM2.F1 VRAM2.G7 VRAM2.H2 VRAM2.H9 VRAM2.K2 VRAM2.K8 VRAM2.N1 VRAM2.N9 VRAM2.R1 VRAM2.R9 VRAM3.A1 VRAM3.A8 VRAM3.B2 VRAM3.C1 VRAM3.C9 VRAM3.D2 VRAM3.D9 VRAM3.E9 VRAM3.F1 VRAM3.G7 VRAM3.H2 VRAM3.H9 VRAM3.K2 VRAM3.K8 VRAM3.N1 VRAM3.N9 VRAM3.R1 VRAM3.R9 VRAM4.A1 VRAM4.A8 VRAM4.B2 VRAM4.C1 VRAM4.C9 VRAM4.D2 VRAM4.D9 VRAM4.E9 VRAM4.F1 VRAM4.G7 VRAM4.H2 VRAM4.H9 VRAM4.K2 VRAM4.K8 VRAM4.N1 VRAM4.N9 VRAM4.R1 VRAM4.R9 VRAM5.A1 VRAM5.A8 VRAM5.B2 VRAM5.C1 VRAM5.C9 VRAM5.D2 VRAM5.D9 VRAM5.E9 VRAM5.F1 VRAM5.G7 VRAM5.H2 VRAM5.H9 VRAM5.K2 VRAM5.K8 VRAM5.N1 VRAM5.N9 VRAM5.R1 VRAM5.R9 VRAM6.A1 VRAM6.A8 VRAM6.B2 VRAM6.C1 VRAM6.C9 VRAM6.D2 VRAM6.D9 VRAM6.E9 VRAM6.F1 VRAM6.G7 VRAM6.H2 VRAM6.H9 VRAM6.K2 VRAM6.K8 VRAM6.N1 VRAM6.N9 VRAM6.R1 VRAM6.R9 VRAM7.A1 VRAM7.A8 VRAM7.B2 VRAM7.C1 VRAM7.C9 VRAM7.D2 VRAM7.D9 VRAM7.E9 VRAM7.F1 VRAM7.G7 VRAM7.H2 VRAM7.H9 VRAM7.K2 VRAM7.K8 VRAM7.N1 VRAM7.N9 VRAM7.R1 VRAM7.R9 VRAM8.A1 VRAM8.A8 VRAM8.B2 VRAM8.C1 VRAM8.C9 VRAM8.D2 VRAM8.D9 VRAM8.E9 VRAM8.F1 VRAM8.G7 VRAM8.H2 VRAM8.H9 VRAM8.K2 VRAM8.K8 VRAM8.N1 VRAM8.N9 VRAM8.R1 VRAM8.R9
+V_1P35_VGA_DISCHG: Q9633.6 R80058.1
+V_3P3_VGA: C438.2 C440.1 C443.2 C475.1 C6709.2 GPU1.AA8 GPU1.AA9 GPU1.AB8 PR583.1 PR5525.1 PR8304.2 PR8308.1 PR8327.2 PR8328.1 PR8623.1 Q54.D Q59.E R234.1 R237.1 R240.1 R586.1 R591.1 R602.2 R606.1 R607.1 R628.1 R630.1 R631.2 R633.1 R79783.1 R79983.1 R79984.2 R79987.2 R79990.1 R79991.1 U33.3 U33.7 U33.8 U9621.5
+V_VGA_CORE: C446.2 C448.1 C453.2 C454.2 C458.2 C459.1 C460.1 C461.2 C464.2 C466.2 C471.1 C472.2 C473.2 C479.2 C481.2 C482.2 C486.1 C487.2 C488.2 C837.1 C6706.2 C12377.2 C12381.1 GPU1.K10 GPU1.K12 GPU1.K14 GPU1.K16 GPU1.K18 GPU1.L11 GPU1.L13 GPU1.L15 GPU1.L17 GPU1.M10 GPU1.M12 GPU1.M14 GPU1.M16 GPU1.M18 GPU1.N11 GPU1.N13 GPU1.N15 GPU1.N17 GPU1.P10 GPU1.P12 GPU1.P14 GPU1.P16 GPU1.P18 GPU1.R11 GPU1.R13 GPU1.R15 GPU1.R17 GPU1.T10 GPU1.T12 GPU1.T14 GPU1.T16 GPU1.T18 GPU1.U11 GPU1.U13 GPU1.U15 GPU1.U17 GPU1.V10 GPU1.V12 GPU1.V14 GPU1.V16 GPU1.V18 PC8306.1 PL12.2 PR8329.1 PT32.1 PT34.1 R80057.2
A20GATE: R249.1 U109.43
A_BA0: GPU1.K25 RN7506.1(A) RN7506.2(A) VRAM1.M2 VRAM2.M2 VRAM3.M2 VRAM4.M2 VRAM5.M2 VRAM6.M2 VRAM7.M2 VRAM8.M2
A_BA1: GPU1.G25 RN7509.1(A) RN7509.2(A) VRAM1.N8 VRAM2.N8 VRAM3.N2 VRAM4.N2 VRAM5.N8 VRAM6.N8 VRAM7.N2 VRAM8.N2
A_BA2: GPU1.J24 RN7505.3(A) RN7505.4(A) VRAM1.M3 VRAM2.M3 VRAM5.M3 VRAM6.M3
AC_OK#: PR5279.2 R79855.1 U55.5
AC_OK#_C: R79855.2 U109.99
AC_PROTECT: PQ4408.G PR5288.1 PR5291.2 U55.3
ACPRESENT: R876.1 U2.BB15
AD+_2: C358.2 R484.2 R486.1 U17.4 U18.4
AD_IA: PR5290.2 R80216.1
AD_IA_HW1: PQ5006.2 R79637.1 R79859.2
AD_IA_HW1_C: R79859.1 U109.106
AD_IA_HW2: PQ5006.5 R79638.1 R79860.2
AD_IA_HW2_C: R79860.1 U109.107
AD_JK: C355.1 C358.1 C12328.1 D12.K DCIN1.1 PR5270.1 PR5284.1 R484.1 U17.1 U17.2 U17.3 U18.1 U18.2 U18.3
ADAPTOR_PSID_R: Q24.S R495.1
ADAPTOR_PSID_SIO: D13.3 R492.2 R495.2 U109.119
ADC_1V2: C12188.1 C12189.1 L9523.2 SCA1.23
ALL_PWRGD_2: Q53.D R1129.1 R1195.1
ALL_SYS_PWRGD: R1972.1 R1973.2 R1979.2 R1980.1
AMD_RST#_L: R1212.2 R80059.2 R80060.2 U9621.4
AMP_SPKR_L: R384.2 R385.1 R79835.1 U9615.4
AMP_SPKR_R: R383.2 R386.1 R79834.1 U9615.8
AMP_SWITCH_C_L: R79812.1 R79835.2
AMP_SWITCH_C_R: R79813.1 R79834.2
AUD_AZACPU_SCLK: CPU1.V3 R113.1
AUD_AZACPU_SCLK_R: R113.2 U2.AM2
AUD_AZACPU_SDI: CPU1.U1 R72.1
AUD_AZACPU_SDI_R: R72.2 U2.AN2
AUD_AZACPU_SDO: CPU1.V2 R106.1
AUD_AZACPU_SDO_R: R106.2 U2.AM1
AUD_BEEP_C: C218.2 U9.2
AUD_BEEP_R: C218.1 R370.2 R371.2 R372.1
AUD_DMIC_CLK: C216.1 L3.2 WEBCM1.4
AUD_DMIC_CLK_R: R369.1 U9.12
AUD_DMIC_CLK_R_1: L3.1 R369.2
AUD_DMIC_DATA: C217.1 R368.2 WEBCM1.5
AUD_DMIC_DATA_R: R368.1 U9.13
AUD_DVDD: C222.1 C223.1 R374.2 R375.2 U9.7
AUD_GP3: R373.2 U9.3
AUD_LINK_BCLK: C224.1 R107.1 U9.5
AUD_LINK_BCLK_R: R107.2 U2.BA9
AUD_LINK_RST_N: R108.1 R416.1 U9.6
AUD_LINK_RST_N_2: Q13.1 Q13.3
AUD_LINK_RST_N_R: C269.1 Q18.B R416.2
AUD_LINK_RST_R_N: R108.2 U2.BD8
AUD_LINK_SDIN: R376.1 U2.BE7
AUD_LINK_SDIN_1: R376.2 U9.8
AUD_LINK_SDO: C225.1 R109.1 R226.2 R228.1 R377.1 U9618.D
AUD_LINK_SDO_1: C225.2 R378.2 U9618.G
AUD_LINK_SDO_N: R377.2 U9.4 U9618.S
AUD_LINK_SDO_R: Q5.C R109.2 R153.2 U2.BB7
AUD_LINK_SDO_R1: MEJ1.2 R153.1
AUD_LINK_SYNC: R111.1 U9.9
AUD_LINK_SYNC_R: R111.2 U2.BD9
AUD_REGREF: C221.1 U9.10
B_BA2: GPU1.J27 RN7503.1(A) RN7503.2(A) VRAM3.M3 VRAM4.M3 VRAM7.M3 VRAM8.M3
BATLOW_N: R116.1 U2.BD13
BIOS_REQ: R79942.1 SCA1.105 U2.W39
BIST_DISABLE: R531.2 R533.1 R79924.1 U109.112
BIST_DISABLE_1: Q9628.5 R79924.2
BIST_EN: Q9628.3 Q9628.6 Q9629.2 R524.2
BIST_EN_INV: Q9629.3 Q9629.6 R517.2 R80233.1 SCA1.63
BIST_EN_SIO: R1826.1 R80233.2 U109.25
BIST_ENABLE: R79923.1 U109.113
BIST_ENABLE_1: Q9629.5 R523.1 R79806.2 R79923.2
BIST_PIN25: Q9650.G R80240.1 U109.24
BIST_PIN25_G: Q9648.G Q9650.D R80230.2
BKLT_ADJ: C12229.1 C12230.1 R79694.2 R79721.2
BKLT_EN: C12226.1 Q1260.C R79704.2 R79720.2 R79722.2
BKLT_EN1: Q1260.B R135.2
BOARD1: R1661.2 R1663.1 U2.U41
BOARD2: R1662.2 R79931.1 U2.M44
BOARD3: R1659.2 R1660.1 U2.U36
BQ24737_REGN: PC5237.2 PD4401.A U55.16
BUFRST_N: GPU1.D11 R79994.1
BUZZER_SPKR_R: C243.1 R370.1
CAGND: C3457.2 C12227.2 C12228.2 C12231.2 C12232.2 C12233.2 C12234.2 C12235.2 C12236.1 R79697.2 R79700.2 R79702.2 R79707.2 R79708.2 R79709.2 U120.15 U120.21
CASA#: GPU1.G26 R7513.1 R7514.1 VRAM1.K3 VRAM2.K3 VRAM3.K3 VRAM4.K3 VRAM5.K3 VRAM6.K3 VRAM7.K3 VRAM8.K3
CBN: C209.2 U9.21
CBP: C209.1 U9.24
CE: R9503.1 R9504.1 R9505.1 SCA1.118
CE#_1: R9504.2 U9501.1
CFG: R1594.2 U118.23
CHAR_CTL1: R451.1 U9625.6
CHAR_CTL2: R453.1 U9625.7
CHAR_CTL3: R454.1 U9625.8
CHAR_EN: R455.1 U2.P43 U9625.5
CHAR_ILIM_HI: R80049.1 U9625.16
CHAR_ILIM_LO: R457.1 U9625.15
CHAR_ILIM_SEL: R456.1 U9625.4
CHAR_STATUS: TP72.1 U9625.9
CHAR_USBOC#: R452.1 U9625.13
CHG_AGND: PC4432.2 PC5232.2 PC5233.2 PC5234.2 PC5245.2 PQ5006.1 PQ5006.4 PR5268.2 PR5274.2 PR5286.2 PR5468.2
CHG_SMB2_CLK: PR8625.2 R306.2 R80224.2 U55.9
CHG_SMB2_DATA: PR8626.2 R307.2 R80223.2 U55.8
CK_24M_SIO: R301.1 R1807.2
CK_100M_CPU_XDP_DN: U2.L1 XDPC1.42
CK_100M_CPU_XDP_DP: U2.L2 XDPC1.40
CK_GLAN_DN: U2.D3 U9623.16
CK_GLAN_DP: U2.F2 U9623.15
CK_M_DDR0_A_DN: CPU1.AV18 DIMM1.103
CK_M_DDR0_A_DP: CPU1.AW18 DIMM1.101
CK_M_DDR0_B_DN: CPU1.AM21 DIMM2.103
CK_M_DDR0_B_DP: CPU1.AM20 DIMM2.101
CK_M_DDR1_A_DN: CPU1.AY17 DIMM1.104
CK_M_DDR1_A_DP: CPU1.AW17 DIMM1.102
CK_M_DDR1_B_DN: CPU1.AP21 DIMM2.104
CK_M_DDR1_B_DP: CPU1.AP22 DIMM2.102
CK_PE_100M_16PORT_DN: GPU1.AD8 U2.W10
CK_PE_100M_16PORT_DP: GPU1.AE8 U2.W11
CKEA0: GPU1.F24 PR246.1 VRAM1.K9 VRAM2.K9 VRAM3.K9 VRAM4.K9
CKEA1: GPU1.K23 PR235.1 VRAM5.K9 VRAM6.K9 VRAM7.K9 VRAM8.K9
CLINK_CLK_LAN: R713.1 U2.AV2
CLINK_CLK_LAN_1: NGFF1.42 R713.2
CLINK_DATA_LAN: R716.1 U2.AV3
CLINK_DATA_LAN_1: NGFF1.40 R716.2
CLINK_RST_LAN_N: R718.1 U2.AW2
CLINK_RST_LAN_N_1: NGFF1.38 R718.2
CLK: R9501.2 SCA1.115
CLK_1: R9501.1 U9501.6
CLK_24M_SIO_C: R301.2 U109.34
CLKA0: GPU1.D24 R244.1 R245.1 VRAM1.J7 VRAM2.J7 VRAM3.J7 VRAM4.J7
CLKA0#: GPU1.D25 R241.1 R244.2 VRAM1.K7 VRAM2.K7 VRAM3.K7 VRAM4.K7
CLKA0_AND: C163.1 R241.2 R245.2
CLKA1: GPU1.N22 R194.1 R195.1 VRAM5.J7 VRAM6.J7 VRAM7.J7 VRAM8.J7
CLKA1#: GPU1.M22 R195.2 R80001.1 VRAM5.K7 VRAM6.K7 VRAM7.K7 VRAM8.K7
CLKA1_AND: C6704.1 R194.2 R80001.2
CLKOUT_PCIE1N: R711.2 U2.L7
CLKOUT_PCIE1P: R712.2 U2.L5
CLKOUT_PCIE4N: U2.D5 U14.6
CLKOUT_PCIE4P: U2.E6 U14.5
CORE_PLLVDD: C484.1 C6708.1 C6710.1 GPU1.L6 L29.2
CPU_2_PCH_TRIGGER: R66.1 U2.AK1
CPU_2_PCH_TRIGGER_R: CPU1.B3 R66.2
CPU_24MHZ_R_DN: CPU1.J9 R15.2
CPU_24MHZ_R_DP: CPU1.K9 R13.2
CPU_FAN_CTRL_SIO: R360.1 U109.6
CPU_FAN_TACH_SIO: R363.2 U109.5
CPU_THERMTRIP_N: CPU1.D11 R38.2
CPU_VAIDALERT_N: CPU1.E39 R23.1
CPU_VIDSCK_N: CPU1.E38 R25.2
CPU_VIDSOUT_N: CPU1.E40 R28.2
CPU_VSS_AB11: R247.1 U2.AB11
CPU_VSS_ABS: R246.1 U2.AB10
CPVEE: C210.1 U9.20
CR_CLKREQ_N: R458.1 U14.2
CSA0#_0: GPU1.E24 VRAM1.L2 VRAM2.L2
CSA0#_1: GPU1.C26 VRAM3.L2 VRAM4.L2
CSA1#_0: GPU1.K24 VRAM5.L2 VRAM6.L2
CSA1#_1: GPU1.M23 VRAM7.L2 VRAM8.L2
CSN1: PC4427.2 PG2.2 PR4433.1 PR4446.1 PU4401.38
CSN1A: PC4422.2 PG8.2 PR4422.1 PR4430.1 PU4401.26
CSN2: PC4426.2 PG4.2 PR4432.1 PR4445.1 PU4401.40
CSN2A: PC4421.2 PG10.2 PR4421.1 PR4428.1 PU4401.24
CSN3: PG6.2 PR4431.1 PR4468.2
CSP1: PG1.2 PR4437.2 PR4443.1
CSP1A: PG7.2 PR4429.1 PR4434.2
CSP2: PG3.2 PR4436.2 PR4442.1
CSP2A: PG9.2 PR4423.2 PR4427.1
CSP3: PG5.2 PR4435.2 PR4441.1
DACA_VDD: GPU1.W5
DACA_VREF: C12382.1 GPU1.AE2
DC_19V: C357.1 PG4907.1 PR5276.1 R485.1 U17.5 U17.6 U17.7 U17.8 U18.5 U18.6 U18.7 U18.8
DCBATOUT: C12101.1 C12314.1 F16.1 L6.1 PC24.1 PC70.2 PC5253.1 PC5254.1 PC12175.1 PC12176.1 PC12177.1 PC12178.1 PC12179.1 PC12180.1 PC12181.1 PC12182.1 PC12183.1 PC12184.1 PC12185.1 PG4905.1 PR3.2 PR5.2 PR6.2 PR75.1 PR76.1 PR78.1 PR96.2 PR97.2 PR99.2 PR100.2 PR133.2 PR134.2 PR148.1 PR149.1 PR152.1 PR178.1 PR179.1 PR180.1 PR182.1 PR205.1 PR206.1 PR5276.2 PR5304.1 PR5471.1 PR5472.1 PR5473.1 PR5474.1 PR5475.1 PR5476.1 PR5477.2 PR5478.2 PR5479.2 PR5480.2 PR5481.1 PR5482.1 PR5519.1 PR5520.1 PR5521.1 PR8610.1 PR8611.1 PR8617.1 PT35.1 PU1.5 PU1.6 PU1.7 PU1.8 PU35.11 PU5203.5 PU5203.6 PU5203.7 PU5203.8 R288.1 R507.1 R509.1 R1988.1 R1989.1 R9601.1 R9602.1 R79716.1 R79727.1 R79738.1 R79915.1
DCBATOUT_1D35V_VGA: PC8609.1 PC8612.1 PC8613.1 PR8610.2 PR8611.2 PU8602.8 PU8602.9 PU8602.22 PU8602.24
DCIN_EN: R2087.2 U118.13
DDC5V_HDMI: C12217.1 D5201.3 R5209.1 R5213.1 R5214.1 U5201.8
DDC5V_HDMI_R: D5201.2 R5217.2
DDC_WP: R5212.2 SCA1.39
DDC_WP_1: R5209.2 R5212.1 U5201.7
DDCBUF: R1598.2 R2089.1 U118.14
DDPB_CTRL_CLK: U2.BA5 U118.38
DDPB_CTRL_CLK_CONN: HDMI1.15 R2083.2 U29.1 U29.10 U118.32
DDPB_CTRL_DATA: U2.BC4 U118.39
DDPB_CTRL_DATA_CONN: HDMI1.16 R2084.2 U29.2 U29.9 U118.33
DDPC_AUX_DN_C: NGFF1.20 TP235.1
DDPC_AUX_DP_C: NGFF1.22 TP234.1
DDPC_CTRL_CLK: TP169.1 U2.BB3
DDPC_CTRL_DATA: R79944.1 U2.BD6
DDPD_CTRL_CLK: TP167.1 U2.BE5
DDPD_CTRL_DATA: R229.1 U2.BE6
DDR0_ALERT#: CPU1.AT23 R1.1
DDR1_ALERT#: CPU1.AY25 R2.1
DDR3_DRAMRST_N: C143.1 R81.1 R92.1 R925.1 U2.BC14
DDR3_DRAMRST_N_A_1: C112.1 DIMM1.30 R81.2
DDR3_DRAMRST_N_B_1: C136.1 DIMM2.30 R92.2
DDR_SHDN: R1954.2 R1957.2 U171.5 U171.6
DDR_VREF_PWR: PC99.1 PC100.1 PR199.1 PR202.1 PU40.2 PU40.20
DDR_VREF_S3: PR196.1
DDR_VTT_CNTL: CPU1.AC36 R31.2
DDR_VTT_CNTL_GATE: Q1228.2 Q1228.3 R1734.2
DDSP_B_HPD: U2.AW4 U118.3
DDSP_B_HPD_CONN: HDMI1.19 U29.4 U29.7 U118.28
DDSP_B_TX_DN_0: C12213.1 CPU1.D21
DDSP_B_TX_DN_1: C12211.1 CPU1.E22
DDSP_B_TX_DN_2: C12209.1 CPU1.A23
DDSP_B_TX_DN_3: C12215.1 CPU1.D23
DDSP_B_TX_DP_0: C12212.1 CPU1.C21
DDSP_B_TX_DP_1: C12210.1 CPU1.D22
DDSP_B_TX_DP_2: C12208.1 CPU1.B23
DDSP_B_TX_DP_3: C12214.1 CPU1.C23
DDSP_C_HPD_CONN: NGFF1.31 TP240.1
DDSP_C_TX_DN_0_C: NGFF1.32 TP231.1
DDSP_C_TX_DN_1_C: NGFF1.26 TP233.1
DDSP_C_TX_DN_2_C: NGFF1.25 TP237.1
DDSP_C_TX_DN_3_C: NGFF1.19 TP239.1
DDSP_C_TX_DP_0_C: NGFF1.34 TP230.1
DDSP_C_TX_DP_1_C: NGFF1.28 TP232.1
DDSP_C_TX_DP_2_C: NGFF1.27 TP236.1
DDSP_C_TX_DP_3_C: NGFF1.21 TP238.1
DET_HDMI#: Q7903.G R5215.2 R5216.2 R7918.2 SCA1.37 U5202.2
DET_HDMI_C: HDMI2.11 R5215.1
DGPU_PWR_EN: Q9632.5 R80054.2
DGPU_PWR_EN#: Q9632.2 Q9632.3 Q9633.2 Q9633.5 R80055.1
DIMM_CA_CPU_VREF_A: C3.1 CPU1.AB40 R3.1 R4.1
DIMM_CA_CPU_VREF_RC: C3.2 R5.1
DIMM_CA_VREF_A: C114.1 C115.1 DIMM1.126 R3.2 R83.2
DIMM_CA_VREF_A_L: R82.2 R83.1 R84.1
DIMM_CA_VREF_B: C138.1 C139.1 DIMM2.126 R4.2 R94.2
DIMM_CA_VREF_B_L: R93.2 R94.1 R95.1
DIMM_DQ_CPU_VREF_A: C1.1 C111.1 CPU1.AC40 R79.1
DIMM_DQ_CPU_VREF_A_1: C111.2 R80.1
DIMM_DQ_CPU_VREF_B: C2.1 C135.1 CPU1.AC39 R90.1
DIMM_DQ_CPU_VREF_B_1: C135.2 R91.1
DIMM_DQ_R_VREF_A: C107.1 C108.1 DIMM1.1 R77.2 R79.2
DIMM_DQ_R_VREF_A_L: R76.2 R77.1 R78.1
DIMM_DQ_R_VREF_B: C133.1 C134.1 DIMM2.1 R88.2 R90.2
DIMM_DQ_VREF_B: R87.2 R88.1 R89.1
DIMM_TMPIN2+: C12064.1 R79622.1 RT1.2 U109.86
DIMM_TMPIN2-: C12064.2 R79621.2 RT1.1
DISP_UTIL_CPU: CPU1.D14 R79778.2
DMI_IT_MR_DN0: CPU1.Y4 U2.C27
DMI_IT_MR_DN1: CPU1.AA5 U2.B28
DMI_IT_MR_DN2: CPU1.AB3 U2.B29
DMI_IT_MR_DN3: CPU1.AC5 U2.B30
DMI_IT_MR_DP0: CPU1.Y3 U2.B27
DMI_IT_MR_DP1: CPU1.AA4 U2.A28
DMI_IT_MR_DP2: CPU1.AB4 U2.C29
DMI_IT_MR_DP3: CPU1.AC4 U2.A30
DMI_MT_IR_DN0: CPU1.AC1 U2.L27
DMI_MT_IR_DN1: CPU1.AD2 U2.E24
DMI_MT_IR_DN2: CPU1.AE1 U2.G27
DMI_MT_IR_DN3: CPU1.AF3 U2.L29
DMI_MT_IR_DP0: CPU1.AC2 U2.N27
DMI_MT_IR_DP1: CPU1.AD3 U2.G24
DMI_MT_IR_DP2: CPU1.AE2 U2.E26
DMI_MT_IR_DP3: CPU1.AF2 U2.K29
DP_AUXN_C: C12175.2 R9530.1
DP_AUXP_C: C12176.2 R9527.1
DP_LANE0N_C: C12180.2 SCA1.13
DP_LANE0P_C: C12179.2 SCA1.12
DP_LANE1N_C: C12182.2 SCA1.15
DP_LANE1P_C: C12181.2 SCA1.14
DP_LANE2N_C: C12338.2 SCA1.17
DP_LANE2P_C: C12337.2 SCA1.16
DP_LANE3N_C: C12340.2 SCA1.19
DP_LANE3P_C: C12339.2 SCA1.18
DP_RCOMP: CPU1.M9 R71.1
DPD_AUXN: C12175.1 CPU1.E12 R79172.1 R79755.2
DPD_AUXP: C12176.1 CPU1.D12 R79171.2 R79756.1
DPD_LANE0N: C12180.1 CPU1.D10
DPD_LANE0P: C12179.1 CPU1.E10
DPD_LANE1N: C12182.1 CPU1.C9
DPD_LANE1P: C12181.1 CPU1.D9
DPD_LANE2N: C12338.1 CPU1.H10
DPD_LANE2P: C12337.1 CPU1.G10
DPD_LANE3N: C12340.1 CPU1.G9
DPD_LANE3P: C12339.1 CPU1.F9
DPLVDS_BL_EN: R280.1 R9528.1 R79724.1 SCA1.126 U109.54
DPLVDS_HPD: R79763.1 SCA1.110
DPLVDS_PANEL_VCC: R9545.1 R79734.2 SCA1.55
DPLVDS_PWMIN: Q9614.1 R79777.2 R79778.1
DPLVDS_PWMOUT: Q9614.4 R79723.1 SCA1.103
DQMA0: GPU1.D19 VRAM2.E7 VRAM4.E7
DQMA1: GPU1.D14 VRAM1.E7 VRAM3.E7
DQMA2: GPU1.C17 VRAM1.D3 VRAM3.D3
DQMA3: GPU1.C22 VRAM2.D3 VRAM4.D3
DQMA4: GPU1.P24 VRAM5.E7 VRAM7.E7
DQMA5: GPU1.W24 VRAM6.E7 VRAM8.E7
DQMA6: GPU1.AA25 VRAM6.D3 VRAM8.D3
DQMA7: GPU1.U25 VRAM5.D3 VRAM7.D3
DRAM_RST: GPU1.M27 R599.1 VRAM1.T2 VRAM2.T2 VRAM3.T2 VRAM4.T2 VRAM5.T2 VRAM6.T2 VRAM7.T2 VRAM8.T2
DRVON: PR81.2 PR87.2 PR93.2 PR102.2 PR109.2 PU4401.35
EAPD_DEPOP: R393.1 U9.14
EAPD_DEPOP_1: R391.1 R393.2 R394.1
EAPD_DEPOP_2: Q13.5 R394.2
EAPD_DEPOP_2_D: Q9620.6 R79871.2
EC_HDMI_PD_N: Q1249.G R2091.2 U109.105
EC_LAN_DISABLE_N: R1194.1 R79925.1 U109.58
EC_PECI: R37.1 R79739.2
EDID_RDY: R79839.2 SCA1.41 U2.T44
EDP_4_HPD: R522.1 U2.BD7
EESCL: RN9503.2(A) SCA1.56 U9502.6
EESDA: RN9503.3(A) SCA1.57 U9502.5
EQ: R1593.2 R2085.1 U118.17
EUP_DSW_SEL: R320.2 R321.1 U109.57
FALL_INT2: Q6701.2 Q6701.3 R6703.2
FAN_CTRL_POWER: PR5305.2 R79913.1 U2.AB39
FAN_OFF_D: Q1227.D R79915.2 R79916.1 R79917.1
FAN_OFF_G: Q1227.G R79913.2
FAN_OFF_G2: C12324.1 C12325.1 Q9624.G R79917.2
FB_CAL_PD_VDDQ: GPU1.D22 R611.1
FB_CAL_PU_GND: GPU1.C24 R79979.1
FB_CAL_TERM_GND: GPU1.B25 R79782.1
FB_PLLAVDD: C449.1 C456.1 C465.1 C502.1 C503.1 GPU1.F16 GPU1.H22 GPU1.P22 L27.1
FB_VREF: GPU1.D23 TP43.1
FBA_DEBUG0: GPU1.F22 R608.1
FBA_DEBUG1: GPU1.J22 R604.1
FFS_INT1: R6702.2 R79658.2 R79872.1 U2.AE45
FFS_INT1_C: R79656.1 R79658.1 U6701.11
FFS_INT1_SIO: R79872.2 U109.110
FFS_INT2: R79657.2 U2.AG43
FFS_INT2_C: Q6701.5 R6704.2 R6706.1 R79656.2 R79657.1 R79668.1 U6701.9
FFS_INT2_Q: Q6701.6 R6705.2 R6706.2 SATAP1.5
FLASH_WP: R9509.1 SCA1.108
FP_RST_N: C12242.1 R128.1 R1762.2 R1783.1 U2.AW1 XDPC1.48
FP_RST_PCH_N_CN: R1783.2 TP225.1
FWH_ID0: LPC1.6 R764.2
GC6_FB_EN: GPU1.C6 R80045.2
GPA7: R270.1 U109.52
GPIO: R79850.1 U14.28
GPIO1_FBVDDQCTL: GPU1.B2 TP260.1
GPIO2_BL_PWM: GPU1.D6 R616.1
GPIO3_PPEN_R: GPU1.C7 R622.1
GPIO4_BLEN: GPU1.F9 R615.1
GPIO5_PWM_VID_BOOT_EN: GPU1.A3 TP257.1
GPIO6_FB_CLAMP_TGL_REQ: GPU1.A4 TP18.1
GPIO7_3D_STEREO: GPU1.B6 R79981.1
GPIO8_OVERT#: GPU1.A6 Q9631.C R603.2 R79984.1
GPIO9_ALERT#: GPU1.F8 PR8319.1 R631.1
GPIO10_MEM_VREF_CTL: GPU1.C5 R619.1
GPIO11_PWM_VID: GPU1.E7 PR8324.2
GPIO12_AC_DETECT: GPU1.D7 R79987.1
GPIO13_NVVDD_PSI: GPU1.B4 R80016.2
GPIO_FB_CLAMP_GPU: GPU1.F3 PR5522.1 R80045.1
GPP_E0: TP203.1 U2.AG36
GPP_E1: TP193.1 U2.AG35
GPP_E2: TP194.1 U2.AG39
GPP_E3: R79767.1 U2.AF41
GPP_E4: TP195.1 U2.AG42
GPP_F0: TP202.1 U2.AD35
GPP_F1: TP201.1 U2.AD31
GPP_F2: R79770.2 TP200.1 U2.AD38
GPP_F3: TP199.1 U2.AC43
GPP_F4: TP204.1 U2.AB44
GPP_G23: TP144.1 U2.L43
GPU_1D05V: PC156.1 PC157.1 PC158.1 PC159.1 PR228.2 PR230.2 PR231.1 PU5302.3 PU5302.4
GPU_1D05V_EN: PC154.1 PR227.1 PU5302.8
GPU_1D05V_FB: PC157.2 PR229.1 PR231.2 PU5302.2
GPU_1D05V_PG: D5206.A PC56.1 PR5525.2 PU5302.7 PU8602.2
GPU_1D05V_VGA_EN: D5209.A PR227.2 PR583.2 PR8315.1
GPU_3D3V_S0_THERM: C475.2 Q59.B R602.1 R603.1
GPU_3D3V_S0_THERM_2: Q59.C R596.1 R597.2 R598.1
GPU_ALLPWR: R80231.1 U109.125
GPU_DMINUS: C12065.2 R79620.2 R80047.1 RT2.1
GPU_DMINUS_G: GPU1.E12 R80047.2
GPU_DPLUS: C12065.1 R79624.1 R80048.1 RT2.2 U109.85
GPU_DPLUS_G: GPU1.F12 R80048.2
GPU_PLTRST: Q9630.D Q9631.E
GPU_TESTMODE: GPU1.AD9 R192.1
GPU_THERM_SHUTDOWN_N: PR8325.1 TP99.1
GPU_THERM_SHUTDOWN_N_1: C436.1 Q6704.B R596.2
GPU_THERM_SHUTDOWN_N_2: C447.1 Q9631.B R597.1
GPU_THERMAL_INT: R263.1 U109.28
GPU_VCC3_CTL: C414.2 D5205.A Q53.G R584.2
GPU_VCC3_CTL_2: C836.1 Q54.G R1195.2
H_PECI: CPU1.G7 R37.2 R41.1
H_PM_DOWN: R79774.1 U2.AH2
H_PM_DOWN_R: CPU1.D8 R79774.2
H_PM_SYNC: CPU1.E8 R79775.2
H_PM_SYNC_0: R79775.1 U2.AJ4
H_PRDY_N: CPU1.B10 R1774.2 TP136.1 XDPC1.5
H_PREQ_N: CPU1.B9 R8.2 R1773.2 TP135.1 XDPC1.3
H_PROCHOT_N: C12125.1 PQ4408.D PR4415.2 PU4401.12 R12.2 R1821.1 R80245.2
H_PROCHOT_N_SIO: R80245.1 U109.8
H_PROCHOT_R_N: CPU1.C39 R1821.2
H_PWRGD: CPU1.F8 R1775.1 R1981.2
H_PWRGD_CPU: R1981.1 U2.AM3
H_RSTOUT_XDP_N: R1770.2 R1771.2 R1776.2 XDPC1.46
H_SKTOCC_N: CPU1.AB35 R20.2 U2.Y44
H_TCK: CPU1.F11 R32.1 R131.2 XDPC1.57
H_TDI: CPU1.G12 R43.1 R80242.2 XDPC1.56
H_TDO: CPU1.H13 R14.2 R40.1 R79769.1 XDPC1.52
H_TMS: CPU1.F13 R44.1 R80241.2 XDPC1.58
H_TRST_N: CPU1.F12 R39.1 R1789.1 XDPC1.54
H_TRST_N_R: R39.2 U2.AY5
H_VIDALERT_N: R16.2 R22.2 R23.2
H_VIDSCK: R17.2 R25.1 R27.2
H_VIDSOUT: R18.2 R28.1 R30.2
HDD_LED_5V: PWRCN1.10 R79858.2
HDMI1_CK+: D5203.4 D5203.7 R5208.2 SCA1.9 TR5204.2
HDMI1_CK+_C: HDMI2.10 TR5204.1
HDMI1_CK-: D5203.5 D5203.6 R5207.2 SCA1.10 TR5204.3
HDMI1_CK-_C: HDMI2.12 TR5204.4
HDMI1_D0+: D5203.1 D5203.10 R5204.2 SCA1.4 TR5202.2
HDMI1_D0+_C: HDMI2.7 TR5202.1
HDMI1_D0-: D5203.2 D5203.9 R5206.2 SCA1.3 TR5202.3
HDMI1_D0-_C: HDMI2.9 TR5202.4
HDMI1_D1+: D5204.2 D5204.9 R5203.2 SCA1.6 TR5203.2
HDMI1_D1+_C: HDMI2.4 TR5203.1
HDMI1_D1-: D5204.1 D5204.10 R5205.2 SCA1.5 TR5203.3
HDMI1_D1-_C: HDMI2.6 TR5203.4
HDMI1_D2+: D5204.5 D5204.6 R5201.2 SCA1.8 TR5201.2
HDMI1_D2+_C: HDMI2.1 TR5201.1
HDMI1_D2-: D5204.4 D5204.7 R5202.2 SCA1.7 TR5201.3
HDMI1_D2-_C: HDMI2.3 TR5201.4
HDMI1_DATA_IC_N0: C12213.2 U118.2
HDMI1_DATA_IC_N1: C12211.2 U118.5
HDMI1_DATA_IC_N2: C12209.2 U118.7
HDMI1_DATA_IC_N3: C12215.2 U118.10
HDMI1_DATA_IC_P0: C12212.2 U118.1
HDMI1_DATA_IC_P1: C12210.2 U118.4
HDMI1_DATA_IC_P2: C12208.2 U118.6
HDMI1_DATA_IC_P3: C12214.2 U118.9
HDMI1_SCL: R9533.2 R9534.2 R9546.1 R80062.1
HDMI1_SCL_C: C12219.1 R5210.2 R5213.2 R80062.2 U5201.6
HDMI1_SDA: R9532.2 R9535.2 R9536.1 R80061.1
HDMI1_SDA_C: C12218.1 R5211.2 R5214.2 R80061.2 U5201.5
HDMI_5V: C12216.1 D5201.1 D5202.3 HDMI2.18 R5218.1 R80225.1
HDMI_DET_SIO: Q7903.D R7916.2 U109.108
HDMI_HDCP_READY: R5218.2 R5219.1 SCA1.114 U5202.1
HDMI_HPDET: HDMI2.19 R5219.2
HDMI_IN_DET#_R: Q7903.S R7917.1
HDMI_LANE0_DN: HDMI1.3 TR16.2 U28.2 U28.9
HDMI_LANE0_DP: HDMI1.1 TR16.3 U28.1 U28.10
HDMI_LANE0_IC_DN: TR16.1 U118.29
HDMI_LANE0_IC_DP: TR16.4 U118.30
HDMI_LANE1_DN: HDMI1.6 TR17.2 U28.5 U28.6
HDMI_LANE1_DP: HDMI1.4 TR17.3 U28.4 U28.7
HDMI_LANE1_IC_DN: TR17.1 U118.26
HDMI_LANE1_IC_DP: TR17.4 U118.27
HDMI_LANE2_DN: HDMI1.9 TR18.2 U26.4 U26.7
HDMI_LANE2_DP: HDMI1.7 TR18.3 U26.5 U26.6
HDMI_LANE2_IC_DN: TR18.1 U118.24
HDMI_LANE2_IC_DP: TR18.4 U118.25
HDMI_LANE3_DN: HDMI1.12 TR19.2 U26.1 U26.10
HDMI_LANE3_DP: HDMI1.10 TR19.3 U26.2 U26.9
HDMI_LANE3_IC_DN: TR19.1 U118.21
HDMI_LANE3_IC_DP: TR19.4 U118.22
HDMI_SCL_IN: HDMI2.15 R5210.1 U5203.1
HDMI_SDA_IN: HDMI2.16 R5211.1 U5203.2
HM_VCCP: G1.2 R260.1
HM_VCCP_R: C184.1 R260.2 U109.95
HP_MUTE: R79920.1 R79950.2 SCA1.64
HP_MUTE_D: Q9620.3 R79919.2
HP_MUTE_L: Q9620.4 R79920.2
HPOL_CON: C267.1 Q16.1 R406.2 R410.2 R412.1 R414.2 UHS1.1
HPOR_CON: C268.1 Q16.2 R409.2 R411.2 R413.1 R415.2 UHS1.2
HPOUT-JD: R366.1 UHS1.6
HPOUT-L: R406.1 U9.26
HPOUT-R: R409.1 U9.27
HSI_C_DN6: C325.1 U14.8
HSI_C_DP6: C324.1 U14.7
HSI_DN6: C325.2 U2.G22
HSI_DN8: R714.2 U2.K24
HSI_DP6: C324.2 U2.E22
HSI_DP8: R717.2 U2.L24
HSI_LAN_DN1_R: C12119.1 U9623.18
HSI_LAN_DN5: C12119.2 U2.K19
HSI_LAN_DP1_R: C12118.1 U9623.17
HSI_LAN_DP5: C12118.2 U2.L19
HSO_C_DN6: C161.1 U14.4
HSO_C_DN8: C167.1 R719.2
HSO_C_DP6: C162.1 U14.3
HSO_C_DP8: C168.1 R720.2
HSO_C_LAN_DN5: C165.1 U9623.14
HSO_C_LAN_DP5: C166.1 U9623.13
HSO_DN5: C165.2 U2.D22
HSO_DN6: C161.2 U2.B22
HSO_DN8: C167.2 U2.C24
HSO_DP5: C166.2 U2.C22
HSO_DP6: C162.2 U2.A23
HSO_DP8: C168.2 U2.B24
I2CC_SCL_PU: GPU1.A9 R628.2 R80224.1
I2CC_SDA_PU: GPU1.B9 R79990.2 R80223.1
I2CS_SCL_G: GPU1.D9 R630.2 R632.1
I2CS_SDA_G: GPU1.D8 R79983.2 R79992.1
ICH_RSMRST_N_R: R291.1 U109.82
IFPA_IOVDD: GPU1.W6
IFPAB_PLLVDD_1: GPU1.V7
IFPAB_PLLVDD_2: GPU1.W7
IFPB_IOVDD: GPU1.Y6
IFPC_IOVDD: GPU1.P6
IFPC_PLLVDD_1: GPU1.M7
IFPC_PLLVDD_2: GPU1.N7
IFPD_IOVDD: GPU1.R6
IFPD_PLLVDD_1: GPU1.R7
IFPD_PLLVDD_2: GPU1.T7
IFPE_IOVDD: GPU1.H6
IFPEF_PLLVDD_1: GPU1.J7
IFPEF_PLLVDD_2: GPU1.K7
IFPF_IOVDD: GPU1.J6
IMAX: PR4474.1 PU4401.36
IMAXA: PR4462.1 PU4401.29
IMS: LVDS1.4 R79811.1 R79832.2
INIT_3V: LPC1.2 R763.2
IO_SMI_N: R254.2 U2.AV29 U109.9
ISEN1: R79693.1 U120.17
ISEN2: R79696.1 U120.16
ISEN3: R79699.1 U120.14
ISEN4: R79705.1 U120.13
ISET: R1596.2 R2086.1 U118.34
ISP_CLK1: Q9501.6 Q9502.6 R9540.2
ISP_DAT1: Q9501.3 Q9502.3 R9541.2
ISW: C12235.1 R79710.2 U120.19
ISW_1: Q1259.1 Q1259.2 Q1259.3 R79698.1 R79703.1 R79710.1
ITP_PMODE: R1770.1 U2.AT2
JACK_PSID: DCIN1.3 L21.1
JDREF: R367.1 U9.35
JTAG_TCLK: GPU1.AE5 R79985.2
JTAG_TDI: GPU1.AE6 TP40.1
JTAG_TDO: GPU1.AF6 TP42.1
JTAG_TMS: GPU1.AD6 TP258.1
JTAG_TRST: GPU1.AG4 R79988.2
KBCLK: RN3.3(A) U109.78
KBRST_N: R196.2 U2.AT17 U109.42
KDAT: RN3.4(A) U109.77
L_AD0: LPC1.5 RN1.4(A) U2.AT22 U109.38
L_AD1: LPC1.7 RN1.3(A) U2.AV22 U109.39
L_AD2: LPC1.9 RN1.2(A) U2.AT19 U109.40
L_AD3: LPC1.11 RN1.1(A) U2.BD16 U109.41
L_BKLTCTL: R79777.1 U2.W36
L_FRAME_N: LPC1.13 R198.2 R324.2 R327.1 U109.37
L_FRAME_N_R: R198.1 U2.BE16
LAN_DISABLE_N: R122.1 R79750.1 U2.AR15
LAN_DISABLE_N_1: C12120.1 Q1265.B R79747.1 R79750.2
LAN_DISABLE_N_2: Q1265.C Q1266.B R79743.2 R79747.2
LAN_DISABLE_N_3: Q1266.C Q1267.C R79744.2 R79745.1
LAN_DISABLE_N_4: C280.2 C12123.1 Q1264.G R79745.2
LAN_DISABLE_V3: C12122.1 Q1267.B R426.1 R1194.2
LAN_LEDACT_R#: R79829.2 RJ1.10
LAN_MDI0_C_DN: RJ1.2 XF3.22
LAN_MDI0_C_DP: RJ1.1 XF3.23
LAN_MDI0_DN: U9614.3 U9623.2 XF3.3
LAN_MDI0_DP: U9614.4 U9623.1 XF3.2
LAN_MDI1_C_DN: RJ1.6 XF3.19
LAN_MDI1_C_DP: RJ1.3 XF3.20
LAN_MDI1_DN: U9614.1 U9623.5 XF3.6
LAN_MDI1_DP: U9614.6 U9623.4 XF3.5
LAN_MDI2_C_DN: RJ1.5 XF3.16
LAN_MDI2_C_DP: RJ1.4 XF3.17
LAN_MDI2_DN: U11.3 U9623.7 XF3.9
LAN_MDI2_DP: U11.4 U9623.6 XF3.8
LAN_MDI3_C_DN: RJ1.8 XF3.13
LAN_MDI3_C_DP: RJ1.7 XF3.14
LAN_MDI3_DN: U11.1 U9623.10 XF3.12
LAN_MDI3_DP: U11.6 U9623.9 XF3.11
LAN_RSET: R79742.2 U9623.31
LAN_WAKE_N: R2281.1 U9623.21
LAN_XTALI: C284.1 R442.2 U9623.28 X3.1
LAN_XTALO: C283.1 R442.1 U9623.29 X3.3
LANCLK_REQ_U_N: R425.1 R79831.1 U9623.12
LANWAKE_SMC_WAKE_SCI_N: R119.1 U2.BD11
LDR: R79701.2 U120.1
LDR_1: Q1259.4 R79701.1
LDRQ#: R262.1 U109.2
LED_5VSB: LED2.A R515.2
LED_DRIVE: R205.1 U2.BD36
LEDC_ISET: R79709.1 U120.12
LINE2-VREFO: R404.1 R405.1 U9.29
LINEOUT-JD: LOUT1.Q R365.1
LINEOUT-L: R421.1 U9.19
LINEOUT-R: R422.1 U9.18
LINEOUT_C-L: L12.1 R421.2
LINEOUT_C-R: L13.1 R422.2
LINEOUT_CON-L: C271.1 L12.2 LOUT1.4 Q17.1
LINEOUT_CON-R: C272.1 L13.2 LOUT1.1 Q17.2
LINK_ACTIVITY_N: R79829.1 U9623.27 U9624.4
LINK_PWR: R79618.2 RJ1.9
LPC_0_ESPI_CLK_EC: R1807.1 U2.BC17
LPC_CLK: LPC1.1 R1983.2 U109.44
LPC_PIRQ_PU: R203.2 U2.AW17
LPC_PME#: R9556.1 R79796.1 R79837.2 R79838.2
LPC_PME_N: R253.2 R79837.1 U109.70
LPCPD_N: R1922.2 U2.BC18
LPF: C12233.1 U120.9
LPSS_GSPI0_CLK: TP176.1 U2.AW27
LPSS_GSPI0_CS_N: TP175.1 U2.AR24
LPSS_GSPI0_MISO: TP174.1 U2.BD27
