# Allegro board 14058-1.0623WZS1658.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V_CPU_EOPIO: length 3
  TOP w0.356: CPU1.AJ25 CPU1.AJ26 82.97,193.57 v5(82.57,193.97)
  BOTTOM w0.508: TP251.1 81.98,194.55 v5(82.57,193.97)
V_CPU_GT: length 84
  TOP w0.635: 80.33,230.11 80.33,231.16 ; 80.33,230.11 81.39,230.11 ; 80.33,230.11 79.28,230.11 ; 80.33,230.11 80.33,229.06 ; PT14.1 89.26,230.11 ; PT14.1 88.21,229.06 ; PT14.1 88.21,231.16 ; PT14.1 87.15,230.11 ; 84.4,236.04 PT13.1 ; PT13.1 84.4,238.15 ; PT13.1 83.34,237.1 ; PT13.1 85.45,237.1 ; PT11.1 76.52,238.15 ; PT11.1 76.52,236.04 ; PT11.1 75.47,237.1 ; PT11.1 77.58,237.1
  L3 w0.635: 80.33,230.11 80.33,231.16 ; 80.33,230.11 79.28,230.11 ; 80.33,230.11 81.39,230.11 ; 80.33,230.11 80.33,229.06 ; 76.52,236.04 PT11.1 ; PT11.1 75.47,237.1 ; PT11.1 76.52,238.15 ; PT11.1 77.58,237.1 ; 84.4,236.04 PT13.1 ; PT13.1 85.45,237.1 ; PT13.1 84.4,238.15 ; PT13.1 83.34,237.1 ; PT14.1 88.21,231.16 ; PT14.1 89.26,230.11 ; PT14.1 87.15,230.11 ; PT14.1 88.21,229.06
  L4 w0.508: v4(57.09,235.32) 54.55,237.86 54.55,246.39 v2(52.01,248.93)
  L4 w0.635: 76.52,236.04 PT11.1 ; PT11.1 75.47,237.1 ; PT11.1 76.52,238.15 ; PT11.1 77.58,237.1 ; 80.33,230.11 81.39,230.11 ; 80.33,230.11 80.33,231.16 ; 80.33,230.11 79.28,230.11 ; 80.33,230.11 80.33,229.06 ; PT14.1 88.21,231.16 ; PT14.1 88.21,229.06 ; PT14.1 89.26,230.11 ; PT14.1 87.15,230.11 ; PT13.1 85.45,237.1 ; PT13.1 84.4,238.15 ; PT13.1 83.34,237.1 ; PT13.1 84.4,236.04
  BOTTOM w0.508: v2(52.01,248.93) R79761.1
  BOTTOM w0.635: PT14.1 88.21,231.16 ; PT14.1 89.26,230.11 ; PT14.1 88.21,229.06 ; PT14.1 87.15,230.11 ; PT13.1 85.45,237.1 ; PT13.1 84.4,238.15 ; PT13.1 83.34,237.1 ; PT13.1 84.4,236.04 ; PT11.1 76.52,238.15 ; PT11.1 76.52,236.04 ; PT11.1 77.58,237.1 ; PT11.1 75.47,237.1 ; 80.33,230.11 80.33,231.16 ; 80.33,230.11 79.28,230.11 ; 80.33,230.11 81.39,230.11 ; 80.33,230.11 80.33,229.06
  vias: v1(56.76,230.19) v1(86.96,246.21) v1(96.06,236.49) v1(104.56,237.76) v2(63.61,205.91) v2(63.61,204.08) v2(65.44,205.91) v2(65.44,204.08) v2(65.44,202.26) v2(67.27,205.91) v2(67.27,204.08) v2(67.27,202.26) v2(67.27,200.43) v2(69.1,205.91) v2(69.1,204.08) v2(69.1,202.26) v2(69.1,200.43) v2(70.93,205.91) v2(70.93,204.08) v2(70.93,202.26) v2(70.93,200.43) v2(72.75,205.91) v2(72.75,204.08) v2(72.75,202.26) v2(72.75,200.43) v2(74.6,206.01) v2(74.58,204.08) v2(74.58,202.26) v2(74.58,200.43) v3(69.92,212.05) v3(69.92,197.42) v3(103.45,239.28) v4(55.82,224.9) v4(55.82,223.76) v4(55.82,222.62) v4(55.82,221.47) v4(56.08,233.29) v4(57.22,233.29) v4(58.24,235.32) v4(58.36,233.29) v4(58.87,224.9) v4(58.87,223.76) v4(58.87,222.62) v4(58.87,221.47) v4(59.38,235.32) v4(61.03,239.38) v4(62.17,239.38) v4(63.32,239.38) v4(63.77,216.68) v4(63.77,215.54) v4(65.17,216.68) v4(65.17,215.54) v4(65.35,239.51) v4(66.36,224.9) v4(66.36,223.76) v4(66.36,222.62) v4(66.36,221.47) v4(66.49,239.51) v4(66.44,216.68) v4(66.44,215.54) v4(71.7,239.51) v4(71.65,197.45) v4(72.97,238.87) v4(73.2,197.5) v4(75.13,233.41) v4(75.08,197.47) v4(76.27,233.41) v4(76.83,197.52) v4(77.1,199.16) v4(77.67,239.51) v4(78.81,239.51) v4(78.94,242.56) v4(78.99,197.47) v4(79.95,239.51) v4(80.08,243.7) v4(80.08,242.56) v4(81.22,244.84) v4(81.22,243.7) v4(81.22,242.56) v4(81.6,250.18) v4(81.73,239.64) v4(82.37,244.84) v4(82.37,243.7) v4(82.75,250.18) v4(82.87,239.64) v4(83.51,244.84) v4(83.89,250.18) v4(84.02,239.64) v4(85.16,250.43) v4(85.16,249.16) v4(85.16,248.02) v4(85.16,246.95) v4(85.16,226.94) v4(86.18,226.94) v4(86.43,250.43) v4(86.43,249.16) v4(86.43,248.02) v4(87.06,243.19) v4(87.06,242.05) v4(87.06,240.98) v4(87.45,244.46) v4(88.33,250.43) v4(88.33,249.16) v4(88.33,248.02) v4(88.97,244.46) v4(88.97,243.19) v4(88.97,242.05) v4(88.97,240.98) v4(90.75,244.46) v4(90.75,243.19) v4(90.75,242.05) v4(90.75,240.98) v4(91.89,244.46) v4(91.89,243.24) v4(91.89,242.18) v4(91.89,241.11) v4(95.7,244.46) v4(95.7,243.32) v4(95.7,242.18) v4(95.7,241.11) v4(96.84,244.46) v4(96.84,243.32) v4(96.84,242.18) v4(96.84,241.11) v4(99.13,244.51) v4(99.13,243.37) v4(99.13,242.23) v4(99.13,241.16) v4(100.4,244.46) v4(100.4,243.32) v4(100.4,242.18) v4(100.4,241.11) v4(105.73,243.32) v4(105.73,242.18) v4(105.73,241.11) v5(79.57,198.36)
V_CPU_GTX: length 7.8
  TOP w0.406: CPU1.K34 v2(65.44,201.34) ; CPU1.L33 v2(66.35,200.43) ; CPU1.J35 v2(64.52,202.26) ; CPU1.H33 v2(63.61,200.43) ; CPU1.K32 v2(65.44,199.51) ; CPU1.G34 v2(62.7,201.34) ; CPU1.M32 v2(67.27,199.51) ; CPU1.H34 v2(63.61,201.34) ; CPU1.J33 v2(64.52,200.43) ; CPU1.L31 v2(66.35,198.6) ; CPU1.F35 62.22,201.8 v2(61.77,202.25) ; CPU1.G35 v2(62.7,202.26)
V_CPU_IO: length 194.2
  TOP w0.356: CPU1.AK14 v2(83.73,182.14) ; CPU1.AJ23 82.87,191.22 82.87,191.22 v2(82.85,191.25)
  TOP w0.406: CPU1.AK24 84.18,191.77 v5(83.75,192.2) ; CPU1.P8 67.92,175.63 67.54,175.63 66.83,174.91 CPU1.M8 ; 70.47,175.21 CPU1.T8
  TOP w0.508: v4(47.59,176.26) 47.59,163.71 45.11,161.23 41.04,161.23 39.76,159.94 37.34,159.94 36.58,159.18 R55.1 R1769.1 ; v2(104.92,139.74) 110.81,145.63 110.81,227.19 v2(111.32,227.7)
  L3 w0.508: v2(104.92,139.74) 104.89,139.71 86.15,139.71 86.04,139.83 85.53,139.83 85.48,139.88 84.94,139.88 83.61,141.21 v2(82.62,141.21)
  L4 w0.508: v2(82.62,141.21) 82.62,141.72 84.24,143.34 84.24,144.15 84.63,144.54 85.44,144.54 85.87,144.97 85.87,152.67 78.63,159.9 78.63,169.44 78.8,169.61 78.8,170.12 78.79,170.13 78.79,171.06 78.53,171.32 78.53,172.05 78.91,172.43 78.91,173.87 78.52,174.27 78.52,175.63 81.35,178.46 81.35,178.55
  BOTTOM w0.508: R24.1 109.86,227.7 v2(111.32,227.7)
  vias: v2(73.48,175.63) v2(83.67,179.27) v3(48.08,175.45) v4(47.57,180.83) v4(47.57,179.92) v4(47.57,179.01) v4(47.57,178.09) v4(47.57,177.18) v4(48.48,180.83) v4(48.48,179.92) v4(48.51,179.01) v4(48.51,178.09) v4(48.51,177.18) v4(48.53,176.26) v4(72.33,177.53) v4(72.33,176.52) v4(73.35,176.52) v4(73.48,177.53) v4(80.97,191.88) v4(80.97,190.84) v4(80.97,189.88)
V_CPU_OPC: length 1.7
  TOP w0.356: CPU1.AJ30 83.16,197.23 v2(82.62,196.68) 82.99,196.31 CPU1.AJ29
V_CPU_SA: length 64.4
  TOP w0.406: CPU1.N7 v2(68.18,174.45) ; CPU1.T7 v2(70.93,174.45) CPU1.U7 ; v2(74.62,175.75) 74.62,175.4 CPU1.Y8
  TOP w0.432: CPU1.R7 69.56,174 v2(70.01,174.45) ; v2(68.18,174.45) CPU1.P7
  TOP w0.508: v2(22.57,129.86) 21.71,129.86 21.28,130.29 PC6.2 21.34,130.67 PR16.1
  TOP w0.635: 41.31,170.67 PT17.1 ; PT17.1 42.36,169.62 ; PT17.1 42.36,171.73 ; PT17.1 43.41,170.67 ; 41.31,162.8 PT18.1 ; PT18.1 42.36,163.85 ; PT18.1 43.41,162.8
  L3 w0.635: PT18.1 43.41,162.8 ; PT18.1 42.36,161.75 ; PT18.1 41.31,162.8 ; PT18.1 42.36,163.85 ; PT17.1 42.36,171.73 ; PT17.1 41.31,170.67 ; PT17.1 43.41,170.67 ; PT17.1 42.36,169.62
  L4 w0.254: PT18.1 42.19,162.8 39.3,159.91 39.3,158.17 37.34,156.21 37.34,153.15 32.32,148.13 32.32,146.52 30.74,144.94 30.74,142.46 28.29,140.01 28.29,137.55 23.93,133.2 22.57,131.84 v2(22.57,129.86)
  vias: v2(74.56,173.5) v2(75.5,173.54) v2(76.4,175.43) v2(76.41,174.45) v3(77.41,178.29) v4(36.65,169.79) v4(36.65,168.77) v4(36.77,163.31) v4(36.77,162.29) v4(37.79,169.79) v4(37.79,168.77) v4(37.92,163.31) v4(37.92,162.29) v4(41.73,168.39) v4(41.73,167.37) v4(41.73,166.36) v4(41.73,165.34) v4(42.87,168.39) v4(42.87,167.37) v4(42.87,166.36) v4(42.87,165.34) v4(75.51,177.28) v4(76.02,176.26) v4(76.52,177.15) v4(77.29,175.5) v4(77.79,176.26) v4(78.43,177.28)
V_CPU_ST_PLL: length 355.4
  TOP w0.254: v2(38.63,231.15) 38.6,231.15 38.5,231.25 R12.1 ; v2(64.33,140.35) 64.1,140.57 64.07,140.57 63.97,140.68 62.59,140.68 61.68,141.58 59.27,141.58 58.43,140.74 R1824.1 58.43,140.32 58.17,140.07 58.17,139.75 ; 58.17,139.75 R8.1 ; 58.17,139.75 58.68,139.75 59.89,140.96 v2(59.89,141.05) ; v2(32.71,144.92) 32.58,145.05 32.58,147.19 32.89,147.5 32.89,147.59 Q1234.S 34.97,147.43 36.01,147.43 36.77,146.67 R68.2 38.23,146.67 R152.1 38.42,147.74 C12056.1 37.58,148.58 C12058.2 37.71,149.97 C12057.1 ; v2(32.71,144.92) 32,144.21 22.05,144.21 20.44,142.59 20.44,141.67 20.44,141.24 v2(19.98,140.78) ; v2(32.71,144.92) 35.27,144.92 36.2,143.99 R14.1 36.2,142.68 PR1.1 36.28,142.67 37.28,141.67 40.4,141.67 40.6,141.86 40.69,141.86 41.21,142.38 41.39,142.38 v2(41.41,142.4) ; PR4448.1 PR4449.1 PR4447.1 38.61,253.52 38.91,253.81 38.91,254.96 PC4428.1 38.4,254.79 38.4,254.72 38.25,254.57 38.07,254.57 v2(37.76,254.27) ; R16.1 38.22,234.68 v2(38.52,234.38) ; v5(34.11,117.46) 33.98,117.59 31.95,117.59 31.88,117.52 R80242.1 31.44,118.22 30.8,118.86 v5(30.8,120.13) ; CPU1.V4 CPU1.V5 72.75,171.71 v5(72.75,170.75) ; R18.1 v2(42.87,231.25) ; R17.1 v2(42.87,234.68) ; v2(31.6,121.78) R79769.2
  L3 w0.254: v2(50.93,254.68) 50.06,255.56 39.06,255.56 v2(37.76,254.27) 35.95,254.27 35.19,255.03 34.75,255.03 33.71,253.99 22.68,253.99 21.91,253.22 21.91,250.29 13.04,241.41 10.49,241.41 4.56,235.49 4.56,185.95 11.63,178.89 11.63,171.32 14.05,168.9 16.02,168.9 19.35,165.57 19.35,154.79 19.88,154.26 19.88,140.87 v2(19.98,140.78) ; v2(38.63,231.15) 38.12,231.66 38.12,233.97 v2(38.52,234.38) ; v2(41.41,142.4) 44.35,142.4 46.83,139.91 57.57,139.91 58.71,141.05 v2(59.89,141.05)
  L4 w0.254: v2(42.87,234.68) 38.83,234.68 v2(38.52,234.38) ; v2(64.33,140.35) 64.33,140.37 64.89,140.93 64.89,152.15 73.24,160.5 73.24,170.28 72.76,170.75 v5(72.75,170.75) ; v2(38.63,231.15) 38.73,231.25 v2(42.87,231.25) 44.88,231.25 50.93,237.3 v2(50.93,254.68)
  BOTTOM w0.254: v5(30.8,120.13) 30.8,121.02 31.57,121.78 v2(31.6,121.78) 30.04,123.34 30.04,135.95 30.68,136.59 30.68,139.13 v3(31.39,139.84) 33.22,141.67 33.22,144.41 v2(32.71,144.92) ; R80241.1 35.88,115.68 v5(34.11,117.46) ; PR4415.1 v2(50.93,254.68)
V_CPU_VCCIO_R119BV: length 8.8
  BOTTOM w0.254: U175.6 31.9,258.18 31.64,258.43 v3(31.31,258.43) 31.06,258.18 31.06,257.22 R1970.2 ; U176.2 U176.5 30.36,256.53 R1970.2 ; R1970.2 30.49,256.53 U175.5
V_SM: length 128.5
  TOP w0.203: DIMM1.105 145.31,164.98 146.9,164.98 v5(147.67,164.22) ; v5(147.39,171.5) 146.34,170.45 DIMM1.87 ; v5(91.95,176.38) 91.59,176.74 CPU1.AW10 ; DIMM1.112 151.43,162.95 v5(150.95,163.44) ; v5(162.44,169.4) 161.69,168.65 DIMM2.93
  TOP w0.254: v5(167.17,166.38) 167.33,166.55 DIMM2.100 ; DIMM1.111 148.3,163.25 149.14,164.09 v5(149.14,164.22) ; DIMM1.94 152.4,168.35 v5(151.88,168.87) ; DIMM1.88 154.89,170.15 155.56,170.83 155.56,171.2 v5(155.57,171.21) ; v5(162.04,167.22) 161.67,166.85 DIMM2.99 ; DIMM1.106 152.16,164.75 v5(151.96,164.95) ; DIMM2.105 v5(158.44,165.05) ; v5(148.18,174.92) 148.18,174.33 146.1,172.25 DIMM1.81 ; DIMM1.117 146.5,161.45 146.62,161.33 147.27,161.33 v5(147.79,161.84) ; DIMM2.106 166.44,164.75 v5(166.43,164.76)
  TOP w0.305: v5(164.14,162.17) 164.14,162.32 163.21,163.25 DIMM2.111 ; v5(155.39,171.94) 155.38,171.95 DIMM1.82 ; v5(91.97,179.38) 91.91,179.45 91.91,179.45 CPU1.AV11 ; DIMM1.124 151.09,159.35 149.8,160.64 149.8,160.71 v5(149.6,160.91) 149.35,160.66 149.35,160.65 148.49,159.79 146.63,159.79 146.49,159.65 DIMM1.123 ; v5(155.25,166.89) 154.91,166.55 DIMM1.100 ; DIMM2.118 v5(166.96,161.15) ; DIMM2.87 159.1,170.45 v5(158.57,169.91) ; v5(167.19,174.1) 167.2,174.1 167.55,173.75 DIMM2.76 ; v5(167.14,171.95) DIMM2.82 ; v5(156.12,160.96) 155.93,161.15 DIMM1.118 151.34,161.15 v5(151.12,160.94) ; v5(167.17,168.36) 167.18,168.35 DIMM2.94 ; CPU1.AU15 90.56,183.51 90.14,183.09 v5(90.12,183.09) ; DIMM1.93 143.71,168.65 143.52,168.46 142.87,168.46 v2(142.18,169.15) ; DIMM1.76 152.49,173.75 150.79,175.45 v5(150.79,176.08) ; v5(167.17,159.68) 167.49,159.35 DIMM2.124 ; v5(158.18,171.08) 158.18,171.23 159.19,172.25 DIMM2.81 ; DIMM2.88 167.43,170.15 167.43,170.15 v5(167.18,170.15) ; v2(91.94,193.05) 92.34,192.65 CPU1.AW25 ; CPU1.AY12 93.53,180.77 93.89,180.41 v5(93.93,180.41) ; v5(147.6,176.02) 147.42,175.85 147.42,175.84 146.94,175.35 146.94,174.73 146.25,174.05 DIMM1.75 ; v2(94.19,184.85) 93.76,184.43 CPU1.AY16 ; v5(164.32,160.26) 164.32,160.28 163.15,161.45 DIMM2.117 ; v5(162.8,160.21) 162.24,159.65 DIMM2.123 ; DIMM2.75 158.42,174.05 v5(157.8,173.43) ; DIMM2.112 v5(167.12,162.95) ; DIMM1.99 v5(146.93,166.85)
  TOP w0.356: CPU1.AT18 89.28,186.65 v5(89.2,186.65) ; v2(90.14,191.3) 90.58,190.85 CPU1.AU23 ; CPU1.AY23 93.7,191.2 v5(93.9,191.2) ; CPU1.AT21 89.22,188.55 v5(89.19,188.55) ; CPU1.AV21 91.07,189.43 v5(91.06,189.43) ; CPU1.AV17 91.48,185.34 91.1,184.97 v5(91.1,184.87) ; v5(92.91,182.99) 92.51,182.6 CPU1.AW14 ; v5(90.13,182.25) 90.14,182.24 90.14,182.13 CPU1.AU13 ; CPU1.AY18 93.59,186.25 94.19,185.66 v2(94.19,184.85) ; v5(91.04,187.59) 90.61,187.17 CPU1.AU19
  TOP w0.508: v2(163.57,210.17) 163.39,210.17 162.88,210.68 PR185.1 ; R64.2 80.46,179.95 82.29,178.12 84.57,178.12 v2(84.65,178.19)
  L3 w0.508: v2(165.27,204.08) 165.27,205.62 162.93,207.96 162.93,209.71 163.39,210.17 v2(163.57,210.17)
  BOTTOM w0.508: v2(142.18,169.15) 141.29,169.15 141.17,169.28 ; 88.82,179.59 88.59,179.59 87.52,178.52 84.98,178.52 v2(84.65,178.19)
  vias: v3(92.93,177.66) v3(111.02,201.18) v3(121.25,143.98) v3(123.44,171.59) v3(127.78,195.87) v3(157.55,182.46) v3(170.53,197.6) v4(121.86,133.34) v4(121.86,132.32) v4(122.88,133.34) v4(122.98,132.32) v5(147.59,168.95) v5(149.01,168.95) v5(149.11,176.03) v5(149.03,171.69) v5(149.19,166.81) v5(149.21,161.78) v5(149.52,172.78) v5(149.59,174.81) v5(149.93,170.6) v5(150.46,168.9) v5(150.53,171.72) v5(150.94,172.78) v5(151.04,161.86) v5(151.47,166.76) v5(152.44,176.06) v5(161.87,176.77) v5(162.7,165.14) v5(162.7,162.06) v5(163.39,176.67) v5(163.57,173.67) v5(163.89,169.43) v5(164.18,167.09) v5(164.19,165.14) v5(164.73,172.05) v5(165.02,166.38) v5(165.57,171.13) v5(165.72,168.44) v5(165.88,174.87) v5(166.61,176.01) v5(168.06,176.01)
V_SM_1P5_EN: length 4.4
  BOTTOM w0.102: v3(175.81,206.55) R1801.1 174.5,206.49 R1955.2 C12167.1 R1952.1
V_SM_VTT: length 98
  TOP w0.305: DIMM2.204 168.65,135.17 167.96,134.48 v5(167.33,134.48) ; DIMM2.203 160.45,134.64 160.59,134.5 v5(161.48,134.5) ; DIMM1.204 152.05,135.35 151.55,134.85 v2(151.55,133.92) ; v2(143.73,135.93) 144,135.65 DIMM1.203
  BOTTOM w1.27: PR202.2 PR199.2 180,213.8 180,198.33 v3(174.95,193.28) 174.65,192.98 174.65,157.87 171.13,154.35 171.13,135.48 169.23,133.59 168.47,133.59 168.34,133.72
  vias: v3(146.25,130.85) v3(167.12,133.18) v4(166.31,132.07)
VBOOT/ADDR: length 7.7
  BOTTOM w0.203: PU4401.28 44.11,241.57 45.28,240.4
  BOTTOM w0.254: PR4473.1 46.23,237.16 45.99,236.92 v3(45.31,236.92) 45.28,236.94 45.28,240.4
VBOOTA/ADDRA: length 4.4
  BOTTOM w0.203: v3(45.51,241.06) 44.51,242.06 PU4401.27
  BOTTOM w0.254: v3(45.51,241.06) 46.23,240.33 PR4461.1
VCORE_VCC_SEN: length 74.9
  TOP w0.254: CPU1.C38 v2(59.04,205)
  L3 w0.254: v2(30.17,236.33) 29.53,235.7 29.53,235.06 30.25,234.34 30.25,233.98 30.12,233.85 30.12,233.49 30.48,233.13 30.84,233.13 30.97,233.26 31.33,233.26 31.69,232.9 31.69,232.55 31.56,232.41 31.56,232.05 31.92,231.69 32.27,231.69 32.41,231.83 32.77,231.83 34.61,229.98 39.03,229.98 40.51,228.51 46.6,228.51 49.31,225.79 51.38,225.79 52.01,225.16 52.01,220.6 52.27,220.34 52.27,211.03 57.66,205.63 58.4,205.63 v2(59.04,205)
  BOTTOM w0.254: PR4407.2 32.45,251.38 R79788.1 30.34,251.38 ; v2(30.17,236.33) 29.91,236.08 29.44,236.08 28.77,236.75 28.77,239.82 29.1,240.15 29.1,240.84 28.77,241.17 28.77,241.86 29.1,242.19 29.1,242.87 28.77,243.2 28.77,245.78 ; 28.77,245.78 v3(29.1,245.78) ; 28.77,245.78 28.77,250.81 29.66,251.7 30.03,251.7 30.34,251.38 ; 30.34,251.38 R79759.2
VCORE_VSS_SEN: length 75.8
  TOP w0.254: CPU1.D38 59.98,204.97 v2(59.95,204.97)
  L3 w0.254: v2(30.17,235.44) 30.17,234.97 34.77,230.36 39.19,230.36 40.67,228.89 46.75,228.89 49.47,226.17 51.54,226.17 52.39,225.32 52.39,220.76 52.65,220.5 52.65,211.19 57.82,206.01 58.82,206.01 59.62,205.21 59.74,205.21 59.95,205 v2(59.95,204.97)
  BOTTOM w0.254: 28.39,237.55 28.39,250.97 29.5,252.08 30.03,252.08 30.34,252.4 ; 28.39,237.55 v3(28.11,237.55) ; 28.39,237.55 28.39,236.59 29.28,235.7 29.91,235.7 v2(30.17,235.44) ; 30.34,252.4 R79760.1 ; 30.34,252.4 31.31,252.4 R79788.2 32.33,252.27 PC4406.2 32.52,252.53 33.09,253.1 33.79,253.1 PR4408.1
VGA_CORE_DISCHG: length 4.1
  TOP w0.102: R80057.1 99.15,131.18 97.66,132.68 v1(97.4,132.68) 97.27,132.55 Q9633.3
VIDALERT#: length 43.4
  TOP w0.102: v2(40.33,254.37) 40.79,253.91 v1(40.79,253.35) 40.79,252.67 40.46,252.34 PR4449.2 ; v2(38.63,235.44) 38.25,235.83 R22.1
  L4 w0.127: v2(40.33,254.37) 40.33,254.75 41.22,255.64 47.07,255.64 49.22,253.49 49.22,237.48 47.19,235.44 v2(38.63,235.44)
  BOTTOM w0.102: PR4467.1 39.95,253.73 40.33,254.11 v2(40.33,254.37)
VIDSCK: length 37.8
  TOP w0.102: v2(42.87,236.33) 42.36,235.83 R27.1 ; v2(41.22,254.39) 41.34,254.27 41.34,251.7 v1(40.84,251.19) PR4448.2
  L4 w0.127: v2(41.22,254.39) 41.75,253.86 42.87,253.86 43.91,254.9 47.09,254.9 48.71,253.28 48.71,237.69 47.36,236.33 v2(42.87,236.33)
  BOTTOM w0.102: v2(41.22,254.39) 41.09,254.27 PR4460.2
VIDSOUT: length 42.2
  TOP w0.102: PR4447.2 v2(39.5,254.48) ; R30.1 42.17,232.78 v2(42.87,232.78)
  L4 w0.127: v2(39.5,254.48) 39.57,254.54 39.57,255.28 40.43,256.15 47.28,256.15 49.73,253.7 49.73,237.27 45.24,232.78 v2(42.87,232.78)
  BOTTOM w0.102: PR4459.2 38.6,253.74 38.6,254.8 v3(38.63,254.82) 39.29,254.82 39.5,254.61 v2(39.5,254.48)
VOUT_INV: length 3.4
  TOP w0.305: v4(25.67,8.75) 25.67,9.05 v1(24.71,10.02)
  BOTTOM w0.305: 16.02,11.29 15.44,11.87 U120.18
  vias: v3(20.01,10.15) v3(26.74,9.77) v4(25.6,3.42) v4(26.61,8.75) v4(26.61,3.42)
VR_ENABLE: length 131.4
  TOP w0.102: v2(32.16,253.45) 32.2,253.45 32.23,253.48 32.58,253.48 32.9,253.8 R1969.1 ; R1967.1 17.21,161.92 17.21,161.92 15.61,160.31 v2(14.8,160.31)
  L3 w0.127: v2(14.8,160.31) 14.8,161.31 1.96,174.15 1.96,236.57 14.74,249.35 16.42,249.35 18.61,251.54 18.61,253.54 21.06,255.99 31.97,255.99 v2(32.84,255.13)
  BOTTOM w0.102: v2(32.84,255.13) 32.84,255.26 33.47,255.89 33.76,255.89 U175.3 v3(33.77,254.21) 33.57,254.01 33.11,254.01 32.58,253.48 32.2,253.48 32.17,253.45 v2(32.16,253.45)
VR_ENABLE_IC: length 12.2
  TOP w0.102: v2(37.37,252.83) 37.37,252.83 37.36,252.84 37.28,252.84 v1(36.72,253.4) 36.72,255.01 PC4402.1 R1966.2 PR4402.2 33.79,255 R1969.2
  BOTTOM w0.102: PU4401.2 40.11,249.84 38.32,251.62 38.32,251.88 v2(37.37,252.83)
VR_READY: length 30.8
  TOP w0.102: v2(41.88,251.8) 41.88,251.22 40.71,250.05 PR4401.2 38.87,250.68 37.79,250.68 v2(36.39,252.08) ; v2(26.23,255.13) 25.6,255.13 25.32,254.85 v1(25.32,254.04) 26.21,254.04 26.47,254.3 R1977.1 26.74,254.3 R79753.1 27.63,252.4 R79754.2 28.33,252.27 v2(28.39,252.21)
  L3 w0.127: v2(36.39,252.08) 35.71,251.4 30.78,251.4 29.98,252.21 v2(28.39,252.21)
  BOTTOM w0.102: v2(41.88,251.8) 41.88,252.42 PC4401.1 42.49,252.27 42.49,251.45 41.71,250.66 PU4401.6 ; R1979.1 R79765.1 25.6,254.37 26.1,254.88 26.1,255 v2(26.23,255.13)
VR_READY_A: length 3.2
  BOTTOM w0.102: U3.1 22.44,249.53 22.68,249.29 v3(23.82,249.29) R80229.2
VR_READY_G: length 11.8
  TOP w0.102: v2(26.36,252.46) 26.61,252.72 R1977.2
  BOTTOM w0.102: C12165.1 26.1,253.35 26.36,253.1 v2(26.36,252.46) v3(26.36,251.57) 26.36,249.16 25.95,248.75 22.57,248.75 21.79,249.54 U3.2
VR_READY_R: length 6.1
  TOP w0.102: v2(28.44,253.38) 28.85,252.97 28.85,251.65 28.58,251.38 R79754.1
  BOTTOM w0.102: U176.6 v3(28.95,254.24) 28.95,254.09 28.44,253.58 v2(28.44,253.38)
VR_READY_Y: length 4.3
  TOP w0.102: v2(20.01,251.83) 20.01,251.17 20.14,251.04 v1(21.02,251.04) 21.09,251.1 R1973.1
  BOTTOM w0.102: U3.4 20.07,251.89 v2(20.01,251.83)
VRALERTB_PU: length 12.8
  TOP w0.102: R103.1 161.61,79.36 160.83,78.57 160.69,78.57 160.09,77.97 160.09,77.59 158.98,76.48 158.3,76.48 v1(158.06,76.24) 157.82,76.48 156.65,76.48 156.38,76.74 155.73,76.74 155.05,77.43 154.43,77.43 154.37,77.49 153.15,77.49 152.83,77.17 151.9,77.17 151.6,77.47 151.58,77.47 U2.BD23
VREF: length 3.7
  BOTTOM w0.305: U120.2 12.52,14.25 12.12,13.85
  BOTTOM w0.508: 12.12,13.85 11.97,13.7 v3(11.5,13.7) 10.23,13.7 C12236.2
VREF_1: length 4.8
  TOP w0.203: v1(177.87,64.29) 178.62,64.29 179.1,63.81 U9.41
  TOP w0.508: v1(177.87,64.29) 176.8,65.36 C215.1
VREFC_U20: length 30
  TOP w0.18: v5(70.43,85.1) 70.6,85.28 70.6,85.61 70.87,85.88 71.37,85.88 71.74,85.51 72.04,85.51 72.33,85.79 72.6,85.79 VRAM2.M8 73.06,86.25 73.58,86.25 74.04,86.7 74.04,86.72
  TOP w0.203: v5(84.22,84.97) 84.28,84.97 84.81,85.5 86.34,85.5 VRAM1.M8 86.98,85.88 87.36,85.5 87.88,85.5 87.92,85.54 88.74,85.54 89.07,85.2
  TOP w0.35: 74.04,86.72 74.05,86.7 74.89,86.7 75.23,86.37 v1(76.17,86.37) 76.5,86.7 77.54,86.7 77.99,87.16 78.02,87.16 78.43,87.56 78.43,87.8 78.65,88.02 v5(78.78,88.02)
  TOP w0.508: 89.07,85.2 89.83,85.2 90.32,84.71 R613.1 C506.1 91.75,84.87 R612.2
  BOTTOM w0.18: v5(70.43,85.1) 70,85.1 68.85,86.25 68.26,86.25 VRAM4.M8 ; VRAM3.M8 81.5,86.3 80.64,86.3 80.57,86.37 80.44,86.37 v5(78.78,88.02)
  BOTTOM w0.203: VRAM3.M8 82.3,85.5 82.99,85.5 83.52,84.97 v5(84.22,84.97)
VREFC_U22: length 30.3
  TOP w0.178: v2(58.21,113.09) 57.68,113.09 56.62,114.14 56.62,114.26 56.43,114.45 56.43,115 56.04,115.39 VRAM6.M8
  TOP w0.18: v5(55.37,117.72) 55.8,117.28 55.8,116.74 55.64,116.58 55.64,116.06 55.64,116.06 55.95,115.76 55.95,115.57 VRAM6.M8 ; v5(55.25,103.57) 55.29,103.53 55.29,103.44 55.55,103.18 55.74,103.18 56.41,102.51 56.41,102.05 56.42,102.04 56.43,102.04 56.43,101.84 VRAM5.M8
  BOTTOM w0.18: v2(58.21,113.09) 58.21,113.03 57.46,112.29 57.46,111.92 57.99,111.39 57.99,111.03 v3(58.34,110.68) 58.34,110.43 56.79,108.89 56.79,107.64 56.44,107.28 56.44,106.65 VRAM7.M8 55.64,105.85 55.64,105.26 55.16,104.77 55.16,103.7 55.25,103.61 v5(55.25,103.57) ; v5(55.37,117.72) 55.37,117.85 56.14,118.63 56.14,119.02 56.41,119.29 56.41,119.91 VRAM8.M8 56.04,120.56 56.43,120.95 56.43,121.5 56.84,121.91
  BOTTOM w0.508: 56.84,121.91 56.84,123.98 57.03,124.17 C12395.1 R79776.1 56.01,125.21 R79997.2
VREFD_U20: length 40.5
  TOP w0.18: v5(79.34,89.47) 79.38,89.43 80.84,89.43 81.12,89.16 VRAM1.H1
  TOP w0.254: v5(79.34,89.47) 79.14,89.47 78.66,88.99 v1(78.65,88.99)
  TOP w0.305: VRAM2.H1 66.6,89.08 v5(66.54,89.01)
  TOP w0.508: v2(88.97,88.01) R258.1 90.82,87.98 C12386.1 91.78,87.97 R79995.2
  L3 w0.2: v5(75.86,89.06) 75.66,89.06 75.23,88.63 75.16,88.63 75.15,88.63 71.52,88.63 71.42,88.73 71.16,88.73 70.74,89.15 69.82,89.15 69.39,88.71 69.39,87.59 69.11,87.31
  L3 w0.3: v5(79.34,89.47) 78.36,89.47 78.28,89.55 76.32,89.55 75.86,89.08 v5(75.86,89.06) ; v5(66.54,89.01) 66.54,88 67.23,87.31 69.11,87.31
  L4 w0.254: v2(88.97,88.01) 88.47,88.01 87.45,86.98 85.72,86.98 85.29,86.55 84.22,86.55 83.89,86.88 83.89,87.16 83.56,87.49 83.56,88.35 83.38,88.53 81.81,88.53 81.63,88.35 80.64,88.35 80.61,88.38 79.93,88.38 79.34,88.96 v5(79.34,89.47)
  BOTTOM w0.254: VRAM3.H1 87.52,88.94 87.83,88.63 88.35,88.63 v2(88.97,88.01) ; VRAM4.H1 73.5,89.06 v5(75.86,89.06)
VREFD_U22: length 42.7
  TOP w0.356: v5(58.72,121.66) 59.24,121.15 VRAM6.H1 ; VRAM5.H1 59.45,107.26 59.45,107.76 58.89,108.32 v5(58.89,108.52)
  TOP w0.508: v5(57.47,123.23) 57.06,123.64 57.06,124.16 C12394.1 R80000.1 57.03,125.98 56.69,126.33 56.58,126.33 ; 56.58,126.33 56.43,126.33 55.95,125.84 R79999.2 ; 56.58,126.33 v1(56.53,126.27)
  L3 w0.3: v5(58.89,108.52) 59.43,109.06 59.43,110.6 59.75,110.93 59.75,114.16 v5(59.64,114.28) 59.13,114.79 59.13,117.33 59.41,117.61 59.41,118.13 59.1,118.43 58.33,118.43 57.52,119.23 57.52,121.02 58.17,121.66 v5(58.72,121.66)
  L3 w0.508: v5(58.72,121.66) 58.17,122.22 58.17,122.25 57.78,122.64 57.78,122.92 v5(57.47,123.23)
  L4 w0.254: v5(63.1,100.04) 62.29,100.85 62.29,104.71 61.46,105.55 61.46,107.95 60.87,108.55 58.91,108.55 v5(58.89,108.52)
  BOTTOM w0.3: VRAM7.H1 59.24,100.45 59.3,100.4 59.3,99.98 59.82,99.46 62.52,99.46 v5(63.1,100.04)
  BOTTOM w0.356: VRAM8.H1 59.64,114.28 v5(59.64,114.28)
VREG_PCIAUX_PCH: length 8.7
  TOP w0.254: v1(142.92,237.6) 142.97,237.6 143.29,237.29 R730.1 145.23,237.29 R727.2 146.18,237.16 v2(146.37,237.35)
  BOTTOM w0.254: Q60.C Q58.D 146.65,236.44 146.37,236.71 146.37,237.34 v2(146.37,237.35)
VREG_PCIAUX_PCH_1: length 10.2
  TOP w0.254: v2(140.79,230.24) 141.17,230.62 v1(141.17,232.98) 141.17,234.56 141.99,235.38 C518.1 143.01,235.32 C12237.2 144.21,235.38 R730.2
  BOTTOM w0.254: Q56.G v2(140.79,230.24)
VRP: length 3.9
  TOP w0.203: 180.97,63.03 180.71,63.03 180.3,62.62 U9.38
  TOP w0.254: 180.97,63.03 v1(181.68,63.74) 182.19,64.25 C208.2
VTT_EN: length 87.3
  TOP w0.102: v2(108.27,235.7) v1(109.14,235.7) 109.8,235.7 110.88,236.78 R1735.2 111.08,238.44 Q1228.6
  L3 w0.127: v2(169.59,212.71) 170.5,213.63 170.5,219.6 164.31,225.79 152.94,225.79 150.4,228.33 138.88,228.33 137.62,227.07 124.52,227.07 115.89,235.7 v2(108.27,235.7)
  BOTTOM w0.102: PU40.7 169.03,211.84 R1736.1 169.59,211.99 v2(169.59,212.71)
WAKE_N: length 407.8
  TOP w0.102: R115.2 163.52,74.78 164.61,74.78 165.07,75.23 165.07,75.58 165.44,75.94 165.82,75.94 166.21,75.55 166.37,75.55 v2(166.39,75.53) ; R708.2 v2(117.04,244.22) ; R2281.2 59.95,35.86 60.65,36.56 v2(61.66,36.56)
  L3 w0.127: v2(137.36,247.38) 137.22,247.52 132.67,247.52 129.99,244.84 117.66,244.84 v2(117.04,244.22) ; v2(119.58,26.15) 121.86,28.44 121.86,44.1 120.09,45.87 v2(120.09,49.54)
  L4 w0.127: v2(119.58,26.15) 118.97,26.76 117.13,26.76 111.88,32.01 111.88,32.33 111.88,34.91 107.67,39.12 105.43,39.12 104.93,39.62 104.93,40.54 103.76,41.71 103.52,41.71 101.97,43.25 91.98,43.25 90.68,41.95 90.68,37.78 88.18,35.28 87.27,35.28 86.96,35.59 77.88,35.59 77.29,36.18 67.25,36.18 66.87,36.56 v2(61.66,36.56) ; v2(166.39,75.53) 166.95,75.53 167.96,76.54 167.96,78.73 166.39,80.31 166.39,81.95 166.73,82.29 166.73,86.51 171.3,91.08 171.3,95.96 175.84,100.49 175.84,111.97 175.01,112.79 175.01,124.02 175.62,124.63 175.62,127.78 175.84,128 175.84,136.03 176.05,136.25 176.05,217.58 164.55,229.08 147.79,229.08 144.87,232 144.87,244.78 140.85,248.8 138.78,248.8 v2(137.36,247.38)
  BOTTOM w0.102: v2(120.09,49.54) 120.11,49.54 120.24,49.67 121.45,49.67 122.36,48.75 124.15,48.75 124.78,48.12 131.9,48.12 134.99,51.22 148.94,51.22 149.63,51.9 150.55,51.9 152.43,53.78 154.2,53.78 155.14,54.72 155.14,55.43 155.42,55.71 155.42,55.71 155.73,56.02 163.7,56.02 165.6,57.92 166.4,57.92 168.45,59.97 168.45,60.93 169.21,61.7 169.21,73.14 v3(167.4,74.94) 166.62,74.94 166.39,75.17 166.39,75.53 v2(166.39,75.53)
WEA#: length 106.3
  TOP w0.102: v5(56.7,118.87) 56.7,119.34 VRAM6.L3 ; VRAM5.L3 56.84,105.14 v5(56.63,104.93) ; v5(83.3,86.6) 83.22,86.68 VRAM1.L3 ; VRAM2.L3 69.05,86.68 69.33,86.4 v5(69.34,86.4)
  TOP w0.127: GPU1.K27 69.66,107.6 67.1,105.04 67.1,99.65 v1(65.14,97.7) 64.75,97.31 64.57,97.31 63.77,96.5 63.77,95.58 v5(63.9,95.45)
  L3 w0.127: v5(83.3,86.6) 83.84,86.6 83.97,86.47 83.97,85.94 83.87,85.85 83.53,85.85 83.5,85.81 82.27,85.81 82.15,85.94 82.15,86.47 82.02,86.6 81.77,86.6 81.64,86.47 81.64,85.97 81.51,85.84 81.26,85.84 81.13,85.97 81.13,86.47 81,86.6 80.46,86.6 79.89,86.03 79.67,86.03 79.55,86.15 79.55,86.47 79.42,86.6 78.96,86.6 78.81,86.45 v5(78.81,86.22) 78.5,86.22 78.42,86.13 77.75,86.13 77.45,86.43 74.2,86.43 73.73,85.97 71.19,85.97 70.88,86.27 70.88,86.39 70.6,86.68 69.61,86.68 v5(69.34,86.4) ; v5(56.63,104.93) 57.14,105.44 57.14,108.85 56.83,109.16 56.83,109.88 57,110.04 v5(57,111.85) 57,117.71 56.7,118.01 v5(56.7,118.87)
  L4 w0.127: v5(57,111.85) 57.09,111.75 57.09,110.64 57.65,110.08 57.65,108.11 58.87,106.89 58.87,104.99 59.41,104.45 59.41,103.5 59.95,102.97 60.97,102.97 61.13,102.81 61.13,102.53 60.98,102.37 60.37,102.37 60.02,102.03 60.02,101.68 60.62,101.08 60.62,100.77 60.59,100.74 60.59,99.5 63.9,96.2 v5(63.9,95.45) 63.9,95.45 63.9,95.33 65.75,93.48 65.75,92.05 66.59,91.21 67.46,91.21 67.49,91.18 68.05,91.18 68.39,91.53 70.02,91.53 70.04,91.51 70.44,91.51 71.87,90.08 71.87,89.66 71.87,89.65 71.87,89.31 71.87,89.3 71.87,89.01 72.13,88.76 73.42,88.76 75.39,86.79 77.04,86.79 77.36,87.11 78.38,87.11 78.81,86.68 v5(78.81,86.22)
  BOTTOM w0.102: R7541.1 56.43,96.06 56.33,96.06 R7539.1 ; v5(83.3,86.6) 83.22,86.68 VRAM1.L3 ; v5(56.7,118.87) 56.7,118.98 56.84,119.12 VRAM6.L3 ; v5(56.63,104.93) 56.84,105.14 VRAM5.L3 ; v5(69.34,86.4) 69.33,86.4 69.05,86.68 VRAM2.L3
  BOTTOM w0.127: 56.43,96.06 56.6,95.88 58.73,95.88 58.95,95.67 59.99,95.67 60.35,95.3 63.75,95.3 v5(63.9,95.45)
WEBCAM_DET: length 267.2
  TOP w0.102: v2(115.42,41.86) 115.59,42.02 115.59,43.99 115.92,44.32 115.92,46.94 115.22,47.64 113.51,47.64 112.83,48.32 112.4,48.32 112.17,48.55 U109.114 ; v2(164.41,59.32) 164.41,58.53 166.59,56.34 166.59,54.84 168.22,53.21 v2(168.22,52.95) ; WEBCM1.7 170.15,209.31 169.87,209.03 v1(169.87,207.5) 169.68,207.31 PC2.1 R475.2 169.68,203.71 171.72,201.66 171.72,194.98 175.25,191.45 182.24,191.45 v2(183.46,190.23)
  L3 w0.127: v2(183.46,190.23) 183.46,161.69 200.46,144.68 200.46,138.58 191.16,129.27 189.87,129.27 184.77,124.16 184.77,121.81 185.32,121.25 185.32,91.71 184.41,90.79 181.66,90.79 180.64,89.77 178,89.77 177.23,89.01 177.23,85.48 174.95,83.19 174.95,82.25 172.52,79.83 172.52,78.47 172.52,78.05 171.83,77.36 171.83,76.71 167.57,72.45 165.92,72.45 164.66,71.19 164.66,60.79 164.41,60.54 v2(164.41,59.32)
  L4 w0.127: v2(115.42,41.86) 116.49,40.79 119.19,40.79 120.54,42.15 129.06,42.15 130.36,40.84 132.54,40.84 134.67,42.98 143.9,42.98 145.35,44.43 154.68,44.43 154.92,44.19 161.12,44.19 163.09,46.16 163.09,48.14 167.89,52.95 v2(168.22,52.95)
WP#_1: length 6.5
  TOP w0.102: U9501.3 55.7,7.73 55.29,7.33 55.29,6.44 54.89,6.04 v1(54.58,6.04) 54.62,6.08 R9508.1 R9507.2 R9509.2
WP_PRO: length 10.8
  TOP w0.102: v2(42.36,46.9) 42.01,47.25 SCA1.40
  BOTTOM w0.102: v2(42.36,46.9) 40.63,46.9 39.82,46.09 38.8,46.09 38.52,45.81 v3(35.65,45.81) 35.3,45.81 35.12,45.63 34.39,45.63 34.05,45.97 RN9503.1
XCLK_RBIAS: length 5.3
  TOP w0.102: R159.2 132.31,64.53 v1(131.31,64.53) 131.21,64.63 131.21,66.14 U2.E1
XDP_PCUDERBUG_3: length 11.1
  TOP w0.102: R10.2 50.46,135.18 49.54,136.1 48.3,136.1 v1(48.2,136) 48.08,135.88 46.78,135.88 46.57,135.67 45.8,135.67 R1782.2 45.22,136.26 v2(43.12,136.26)
  BOTTOM w0.102: v2(43.12,136.26) 42.74,136.26 42.42,135.94 XDPC1.1
XDP_PLTRST_N: length 7.2
  TOP w0.102: R1792.2 R1793.2 C12243.1 43.82,124.7 v1(44.14,124.7) 44.14,124.8 44.52,125.18 44.52,125.72 v2(44.39,125.84)
  BOTTOM w0.102: v2(44.39,125.84) 44.06,125.51 XDPC1.41
XDP_PRS: length 6.1
  TOP w0.102: v2(37.15,120.33) v1(35.63,120.33) 34.25,120.33 R1780.1 R1832.2
  BOTTOM w0.102: XDPC1.60 36.7,120.83 37.15,120.38 v2(37.15,120.33)
XDP_PWR_DEBUG: length 71.2
  TOP w0.102: R1766.2 41.92,136.07 43,137.15 44.14,137.15 45.45,138.46 v2(45.45,139.05) 45.45,140.66 44.65,141.46 44.65,144.78 47.78,147.92 51.28,147.92 v2(51.5,147.69) ; v2(38.93,156.68) 38.83,156.58 R1769.2
  L3 w0.127: v2(54.62,136.45) 52.65,138.42 46.09,138.42 v2(45.45,139.05) ; v2(51.5,147.69) 49.09,147.69 46.93,149.85 46.93,151.88 44.27,154.55 41.98,154.55 39.82,156.7 38.95,156.7 v2(38.93,156.68)
  BOTTOM w0.102: v2(54.62,136.45) v3(54.62,134.96) 53.04,133.39 49.95,133.39 46.3,129.73 46.3,124.95 45.66,124.32 44.9,124.32 44.71,124.51 XDPC1.45
XDP_PWRGD: length 9.1
  TOP w0.102: v2(45.27,126.61) 45.78,126.1 R1777.2 R1778.2 R1775.2
  BOTTOM w0.102: v2(45.27,126.61) 45.38,126.49 45.38,125.06 v3(45.15,124.83) 44.85,125.13 44.85,126.03 44.58,126.3 44.2,126.3 43.91,126.01 XDPC1.39
XDP_VR_READY: length 15.1
  TOP w0.102: v2(46.81,129.6) 46.81,130.16 47.31,130.67 R1779.2 R1791.2 R79874.2 47.92,128.35 C12241.1
  BOTTOM w0.102: v2(46.81,129.6) 46.81,124.32 46.49,124.01 v3(46.42,124.01) 45.98,124.01 45.94,123.96 44.75,123.96 44.7,124.01 XDPC1.47
XRF_TDC2: length 21.2
  TOP w0.508: 77.16,16.24 77.14,16.23 XF3.4 ; 77.16,16.24 80.11,16.24 ; 77.16,16.24 74.11,16.24 ; 80.11,16.24 80.46,16.24 v2(82.24,18.02) C12334.1 ; 80.11,16.24 XF3.1 ; 74.11,16.24 71.71,16.24 71.2,15.73 XF3.10 ; 74.11,16.24 74.17,16.18 XF3.7
  BOTTOM w0.508: v3(81.32,18.02) v2(82.24,18.02)
XTAL_24M_PCH_IN: length 13.7
  TOP w0.102: U2.A6 128.79,67.93 127.96,67.93 127.83,67.8 126.84,67.8 125.05,69.59 R178.1 124.1,70.65 v1(123.89,70.85) 123.57,70.85 123.13,71.3 C157.1 122.74,71.28 120.89,71.28 X1.3
XTAL_24M_PCH_OUT: length 11.2
  TOP w0.102: U2.A5 130.15,68.89 128.96,67.7 128.35,67.7 127.74,67.09 126.69,67.09 125.08,68.71 R178.2 123.92,68.88 C158.1 123.13,69.63 v1(122.88,69.89) 122.7,70.06 X1.1
XTAL_OUTBUFF: length 3.3
  TOP w0.102: GPU1.C10 84.4,101.85 84.78,102.23 v5(84.78,102.23)
  BOTTOM w0.102: R621.1 85.69,101.01 v3(85.89,101.2) 85.87,101.21 85.55,101.54 85.44,101.54 84.78,102.19 v5(84.78,102.23)
XTAL_SSFOUT: length 4.6
  TOP w0.102: GPU1.A10 84.57,100.05 84.57,99.77 84.89,99.45 85.05,99.45 v2(85.36,99.15)
  BOTTOM w0.102: v2(85.36,99.15) 85.58,99.15 85.91,99.48 86.51,99.48 R629.1 87.98,100.06 v3(88,100.04)
XTALIN: length 15.4
  TOP w0.102: GPU1.C11 84.06,101.32 84.06,100.08 84.36,99.77 84.36,99.53 85.72,98.18 85.77,98.18 v1(86.07,97.88) 86.94,97.01 88.66,97.01 91.01,94.66 C12383.1 91.57,94.66 92.4,93.84 93.54,93.84 94.3,93.08 X5.1
XTALOUT: length 11.1
  TOP w0.102: GPU1.B10 84.78,100.64 84.78,100.16 85.28,99.66 85.46,99.66 87.39,97.73 87.65,97.73 v1(87.7,97.78) 88.47,97.78 90.08,96.17 90.36,96.17 90.85,95.68 C511.1 92.37,95.68 X5.3
N1584333: length 3.5
  TOP w0.254: PR4803.2 23.25,164.58 R79948.1 21.91,164.26 21.91,163.75 PR147.2 v1(23.21,163.44)
N38680596: length 7
  TOP w0.102: v2(26.43,52.87) 26.43,52.58 R79731.1
  BOTTOM w0.102: Q9648.D 29.38,55.59 28.47,54.67 27.51,54.67 27.25,54.4 27.25,53.45 v3(27.12,53.33) 26.66,52.87 v2(26.43,52.87)

## Copper pours and planes (outline as drawn)
12V_FAN on TOP: 10.61,162.93 10.48,163.05 10.48,165.34 9.72,166.1 9.59,166.1 9.34,166.36 9.34,167.12 9.59,167.37 10.1,167.37 10.48,167.75 10.48,169.91 9.34,171.06 9.34,177.15 10.36,178.17 13.66,178.17 14.67,177.15 14.67,175.5 14.29,175.12 12.77,175.12 12.26,174.61 12.26,173.72 13.28,172.71 13.79,172.71 14.29,173.21 16.07,173.21 16.22,173.06 16.22,172.05 16.1,171.92 15.46,171.92 15.23,171.69 15.23,170.75 15.69,170.29 15.69,168.52 15.56,168.39 14.8,168.39 14.55,168.64 14.55,169.28 14.17,169.66 12.77,169.66 12.52,169.4 12.52,165.21 12.77,164.96 13.15,164.96 13.28,164.83 13.28,163.05 13.15,162.93 ; 4 cut-outs
12V_FAN on BOTTOM: 10.86,162.67 10.61,162.93 10.61,164.83 10.99,165.21 12.52,165.21 13.15,164.58 13.15,162.93 12.9,162.67
12V_S on TOP, BOTTOM: 13.79,160.9 13.66,161.02 13.66,164.96 13.79,165.09 15.69,165.09 15.94,164.83 15.94,161.15 15.69,160.9
12V_S0 on TOP: 12.64,158.36 11.63,159.37 11.63,162.29 11.88,162.55 13.02,162.55 13.28,162.29 13.28,160.26 13.79,159.75 15.06,159.75 15.31,159.5 15.31,158.48 15.18,158.36
+3V_VA on TOP: 182.57,50.02 182.19,50.41 182.19,51.29 182.06,51.42 182.06,53.58 181.81,53.83 181.81,54.6 182.82,55.61 183.71,55.61 183.97,55.36 183.97,51.93 183.33,51.29 183.33,50.28 183.08,50.02 ; 6 cut-outs
+19V_AMP_PVCC on BOTTOM: 176.09,30.97 176.09,31.61 175.46,32.24 173.42,32.24 172.92,31.74 166.06,31.74 165.42,32.37 162.5,32.37 162.25,32.63 162.25,33.39 162.63,33.77 170,33.77 171.01,32.75 172.41,32.75 173.93,34.28 177.11,34.28 177.36,34.02 177.36,33.51 177.74,33.13 177.74,31.1 177.62,30.97 ; 6 cut-outs
+V1P0A_VCCAMPHYPLL on TOP: 128.59,90.03 128.21,90.41 128.21,91.55 127.83,91.93 127.83,94.47 128.09,94.73 129.48,94.73 131.26,92.95 131.26,91.05 130.24,90.03 ; 2 cut-outs
+VCCPFUSE_3P3 on TOP: 154.12,61.2 152.23,63.09 152.23,67.49 152.04,67.68 151.53,67.68 151.28,67.93 151.28,68.44 151.4,68.57 152.16,68.57 152.85,67.88 152.85,64.5 153.17,64.18 153.17,63.37 153.61,62.93 153.92,62.93 155.01,61.84 155.01,61.25 154.96,61.2 ; 1 cut-out
+VCCPGPPD on TOP: 150.18,88 149.8,88.38 149.8,89.27 152.22,91.68 153.23,91.68 154.37,90.54 154.37,89.39 154.17,89.19 151.45,89.19 151.15,88.89 151.15,88.56 151.03,88.44 151.03,88.21 150.82,88
+VCCPGPPD on BOTTOM: 152.34,89.27 152.22,89.39 151.96,89.39 151.71,89.65 151.71,90.54 151.83,90.66 154.25,90.66 154.37,90.54 154.37,89.52 154.12,89.27
AGND on L2GND: outline of 123 points within 91.45,2.59 203.98,80.44
AGND on L5GND: 174.39,35.23 174.12,35.5 174.12,36.01 173.76,36.37 171.34,36.37 171.07,36.64 171.07,37.91 170.06,38.93 170.06,39.91 171.07,40.93 171.07,47.79 172.36,49.07 175.54,49.07 178.06,51.6 178.06,56.3 178.2,56.44 180.74,56.44 181.11,56.8 181.11,61.28 180.74,61.64 176.39,61.64 175.89,61.14 175.41,61.14 175.14,61.41 175.14,61.88 175.52,62.26 175.52,68.49 177.31,70.28 178.46,70.28 178.84,70.66 179.73,70.66 180.09,71.03 180.09,72.04 180.36,72.31 181.63,72.31 182.25,72.93 182.25,79.03 183.66,80.44 195.44,80.44 198.11,77.77 200.3,77.77 202.97,80.44 203.98,80.44 203.98,69.93 203.91,69.55 203.7,69.23 203.6,69.14 201.19,69.14 199.03,71.3 196.59,71.3 196.32,71.03 194.43,69.14 187.7,69.14 186.44,67.88 186.44,66.33 186.95,65.82 186.95,60.61 187.71,59.85 187.71,42.36 187.7,42.34 182.11,42.34 181.62,41.85 181.62,35.88 181.22,35.48 176.14,35.48 175.89,35.23
AGND on L5GND: 92.1,30.53 91.45,31.18 91.45,41.82 92.35,42.72 101.72,42.72 101.99,42.45 101.99,40.67 102.73,39.93 104.13,39.93 104.27,39.79 104.27,38.9 104.91,38.26 104.91,36.48 105.54,35.85 105.54,30.8 105.27,30.53
GND on TOP: 10.48,187.95 10.23,188.2 10.23,190.61 10.48,190.87 10.86,190.87 10.99,190.74 10.99,188.2 10.74,187.95
GND on TOP: outline of 238 points within 1.02,1.02 203.98,268.98 ; 11 cut-outs
GND on TOP: 91.76,81.52 91.38,81.9 91.38,83.3 91.26,83.43 90.75,83.43 90.49,83.68 90.49,84.06 90.75,84.31 92.65,84.31 93.03,83.93 93.03,83.43 93.29,83.17 93.92,83.17 94.18,82.92 94.18,82.16 93.54,81.52 ; 5 cut-outs
GND on TOP: 11.75,200.01 11.12,200.65 7.18,200.65 6.93,200.9 6.93,204.2 7.18,204.46 11.63,204.46 13.91,206.74 13.91,208.77 14.29,209.16 14.29,211.19 14.67,211.57 18.48,211.57 18.74,211.31 18.74,209.54 18.48,209.28 18.48,204.96 16.96,204.96 16.71,204.71 16.71,203.44 13.28,200.01 ; 1 cut-out
GND on TOP: 65.98,260.59 65.73,260.84 65.73,261.35 65.98,261.61 68.14,261.61 68.27,261.48 68.78,261.48 68.9,261.35 68.9,261.1 68.65,260.84 67.89,260.84 67.63,260.59
GND on TOP: 54.43,79.62 51.76,82.28 51.76,83.55 52.01,83.81 58.62,83.81 59.12,83.3 59.12,81.52 58.87,81.27 56.97,81.27 55.31,79.62 ; 1 cut-out
GND on TOP: 77.54,181.47 75.85,183.15 70.25,183.15 69.67,183.73 69.67,186.3 69.79,186.42 76.56,186.42 77.16,185.82 80.15,185.82 80.41,185.57 80.41,183.79 80.02,183.41 79.48,183.41 78.81,182.74 78.81,181.98 78.3,181.47 ; 2 cut-outs
GND on TOP: 77.36,189.25 77.01,189.6 77.01,191.22 76.85,191.38 71.32,191.38 71.06,191.63 69.79,191.63 69.61,191.81 69.61,194.58 69.74,194.71 80.02,194.71 80.28,194.46 80.28,193.19 79.9,192.81 79.01,192.81 78.63,192.43 78.63,189.38 78.5,189.25 ; 1 cut-out
GND on TOP: 92.14,259.96 91.89,260.21 91.89,260.59 92.14,260.84 93.67,260.84 93.92,260.59 95.19,260.59 95.45,260.34 95.45,260.08 95.32,259.96
GND on TOP: 7.44,218.3 7.05,218.68 7.05,226.68 7.44,227.06 18.61,227.06 18.87,226.81 18.87,225.28 18.48,224.9 18.48,220.71 16.96,220.71 16.71,220.46 16.71,218.68 16.33,218.3 ; 1 cut-out
GND on TOP: 84.02,22.72 83.64,23.1 83.64,26.4 83.89,26.66 83.89,27.42 84.02,27.55 87.06,27.55 87.57,27.04 87.57,23.1 87.19,22.72 ; 2 cut-outs
GND on TOP: 3.47,5.07 3.12,5.42 3.12,9.13 3.37,9.38 6.67,9.38 6.93,9.13 6.93,5.32 6.67,5.07
GND on TOP: 36.14,68.19 34.87,69.46 31.82,69.46 31.57,69.71 31.57,72.76 32.33,73.52 34.36,73.52 34.87,74.03 41.73,74.03 41.85,73.9 41.85,70.6 40.07,70.6 39.82,70.34 39.82,68.44 39.57,68.19 ; 2 cut-outs
GND on TOP: 152.22,208.77 151.83,209.16 151.83,213.22 154.37,213.22 154.76,213.6 154.76,214.49 154.37,214.87 154.12,214.87 153.87,215.12 153.87,216.27 154.37,216.78 160.98,216.78 161.23,216.52 161.23,212.58 157.42,208.77
GND on TOP: 14.93,24.88 14.67,25.13 14.67,27.04 15.44,27.8 19.5,27.8 19.75,27.55 19.75,26.15 19.37,25.77 18.23,25.77 17.34,24.88
GND on TOP: 24.2,125.72 23.95,125.97 23.95,127.24 24.45,127.75 25.22,127.75 25.98,128.51 27.63,128.51 28.39,127.75 28.39,125.84 28.26,125.72 ; 3 cut-outs
GND on TOP: 66.87,19.29 66.24,19.93 66.24,23.74 67.76,25.26 67.76,30.09 69.41,31.74 72.08,31.74 72.97,30.85 72.97,26.4 72.21,25.64 72.21,23.99 73.73,22.47 78.81,22.47 79.19,22.08 79.19,19.54 78.94,19.29
GND on TOP: 63.7,67.8 62.05,69.46 62.05,71.74 62.68,72.38 68.52,72.38 70.55,70.34 70.55,67.93 70.43,67.8 ; 2 cut-outs
GND on TOP: 115.13,4.56 114.75,4.94 114.75,9.38 115,9.64 117.67,9.64 119.07,11.04 130.63,11.04 131.39,10.27 135.71,10.27 136.85,11.42 142.44,11.42 143.71,12.69 143.71,15.23 145.74,17.26 146.88,17.26 147.52,16.62 147.52,15.48 149.68,13.32 149.68,8.75 150.06,8.37 152.09,8.37 152.34,8.11 152.34,7.1 153.61,5.83 162.5,5.83 163.39,6.72 163.39,8.24 163.77,8.62 163.77,10.53 163.52,10.78 163.52,15.35 163.14,15.73 162.63,15.73 162.12,15.23 161.49,15.23 159.84,16.88 157.93,16.88 157.8,16.75 157.42,16.75 157.17,17 157.17,17.64 157.49,17.96 158.12,17.96 160.85,20.69 160.85,25.51 161.87,26.53 162.12,26.53 163.14,25.51 165.93,25.51 166.31,25.13 166.31,20.31 167.84,18.78 172.54,18.78 172.92,19.16 172.92,23.86 173.17,24.12 173.68,24.12 173.93,23.86 173.93,20.05 174.31,19.67 175.2,19.67 176.22,20.69 176.22,25.77 177.74,27.29 179.27,27.29 180.28,26.28 180.28,25.89 177.87,23.48 177.87,15.1 181.81,11.16 181.81,5.32 181.04,4.56 ; 3 cut-outs
GND on TOP: 182.44,102.35 182.06,102.73 182.06,104.76 183.33,106.03 190.06,106.03 191.59,104.51 191.59,102.6 191.33,102.35 ; 2 cut-outs
GND on TOP: 39.01,84.24 37.03,86.22 37.03,90.92 38.3,92.19 40.07,92.19 40.71,91.55 40.71,84.44 40.51,84.24
GND on TOP: 73.35,261.48 72.97,261.86 72.97,262.75 73.35,263.13 76.4,263.13 76.65,262.88 76.65,261.61 76.52,261.48
GND on TOP: 57.73,123.81 57.6,123.94 57.6,125.72 57.22,126.1 55.7,126.1 55.44,125.84 55.44,124.95 55.31,124.83 50.36,124.83 50.11,125.08 50.11,125.97 51.48,127.34 61.77,127.34 61.99,127.11 62.55,127.11 62.93,127.49 62.93,128.13 63.32,128.51 64.2,128.51 64.46,128.26 64.46,127.37 64.59,127.24 66.11,127.24 66.49,127.62 67.38,127.62 67.76,127.24 67.76,126.48 68.14,126.1 68.14,125.08 67.89,124.83 66.49,124.83 65.6,125.72 61.66,125.72 61.41,125.46 61.41,124.95 61.28,124.83 58.74,124.83 58.49,124.57 58.49,124.07 58.24,123.81 ; 16 cut-outs
GND on TOP: 135.25,67.75 134.82,68.19 134.54,68.19 134.23,67.88 133.88,67.88 133.8,67.8 133.6,67.8 133.52,67.88 133.52,69.23 132.45,70.29 132.45,70.32 132.48,70.34 132.53,70.34 132.53,71.74 132.78,72 134.74,72 135.71,71.03 135.71,70.85 134.71,69.86 134.71,68.74 134.82,68.64 135.32,68.64 135.43,68.54 135.43,68.44 135.71,68.16 135.71,67.88 135.58,67.75
GND on TOP: 144.85,27.93 143.33,29.45 143.33,37.45 142.44,38.34 142.44,38.85 142.69,39.1 142.69,39.86 142.44,40.12 137.61,40.12 137.23,40.5 137.23,44.06 137.86,44.69 154.81,44.69 154.96,44.54 154.96,42.05 154.68,41.77 148.91,41.77 148.53,41.39 148.53,37.83 148.91,37.45 149.68,37.45 149.8,37.32 149.8,31.36 150.31,30.85 151.33,30.85 151.71,30.47 151.71,28.56 151.07,27.93 ; 4 cut-outs
GND on TOP: 151.83,115.05 151.45,115.43 151.45,118.6 152.47,119.62 155.52,119.62 156.03,119.11 156.03,115.56 155.52,115.05
GND on TOP: 112.34,38.47 112.34,39.1 112.08,39.36 110.81,39.36 110.69,39.48 110.69,40.12 110.94,40.37 112.97,40.37 113.61,39.74 116.15,39.74 116.27,39.86 116.53,39.86 116.78,39.61 116.78,39.23 116.02,38.47 ; 1 cut-out
GND on TOP: 12.13,234.81 12.01,234.94 12.01,235.7 12.13,235.83 14.04,235.83 14.17,235.7 14.17,235.06 13.91,234.81
GND on TOP: 169.74,121.78 169.74,124.57 169.36,124.95 168.6,124.95 167.71,124.07 166.57,124.07 166.57,126.48 167.2,127.11 172.92,127.11 174.69,125.34 174.69,122.16 174.31,121.78
GND on TOP: 28.52,144.64 27.88,145.27 27.88,149.08 29.15,150.35 29.15,152.26 30.04,153.15 30.04,154.29 33.34,154.29 33.34,152.64 33.47,152.51 34.74,152.51 35.12,152.13 35.12,150.1 34.61,149.59 32.84,149.59 32.45,149.21 32.45,147.76 32.1,147.41 32.1,144.92 31.82,144.64
GND on TOP: 13.66,11.8 13.4,12.05 13.4,12.81 13.02,13.19 12.77,13.19 12.26,13.7 12.26,15.73 12.77,16.24 13.53,16.24 14.17,15.61 14.17,13.78 14.52,13.42 14.52,12.2 14.12,11.8
GND on TOP: 84.91,253.22 84.4,253.73 84.4,257.54 86.48,259.62 87.67,259.62 87.93,259.37 87.93,258.46 88.46,257.92 88.46,253.61 88.08,253.22
GND on TOP: 74.75,178.17 74.36,178.55 74.36,180.2 74.62,180.45 75.38,180.45 75.51,180.58 78.17,180.58 78.56,180.2 78.56,179.95 78.17,179.56 76.4,179.56 76.27,179.44 76.27,178.55 75.89,178.17
GND on TOP: 151.33,88 151.25,88.07 151.25,88.25 151.38,88.38 151.38,88.76 151.53,88.91 153.71,88.91 153.82,88.81 153.82,88.35 153.64,88.17 151.68,88.17 151.63,88.12 151.58,88.12 151.45,88
GND on TOP: 146.88,108.7 146.75,108.83 146.75,111.37 147.01,111.62 150.69,111.62 150.95,111.37 150.95,109.59 150.06,108.7
GND on TOP: 65.98,254.24 65.98,255.76 65.73,256.02 64.97,256.02 64.71,256.27 64.71,257.54 65.47,258.3 69.41,258.3 69.67,258.56 70.68,258.56 70.81,258.43 70.81,257.92 70.43,257.54 70.43,255.76 70.17,255.51 69.54,255.51 69.28,255.26 69.28,254.24 ; 1 cut-out
GND on TOP: 150.82,127.24 150.18,127.88 150.18,131.81 150.31,131.94 155.26,131.94 157.17,130.03 157.17,129.15 155.26,127.24
GND on TOP: 112.85,252.08 112.59,252.34 112.59,256.27 112.97,256.65 118.69,256.65 119.07,256.27 119.07,252.34 118.81,252.08
GND on TOP: 13.53,185.03 11.88,186.68 11.88,186.93 12.13,187.18 12.9,187.18 13.15,187.44 13.15,189.44 13.79,190.08 13.79,190.11 14.55,190.87 14.55,192.52 14.93,192.9 16.2,192.9 17.6,194.3 18.61,194.3 18.74,194.17 18.74,192.77 18.48,192.52 18.48,188.45 16.96,188.45 16.71,188.2 16.71,186.55 17.34,185.91 17.34,185.41 17.09,185.15 16.71,185.15 16.58,185.03 ; 1 cut-out
GND on TOP: 83.28,18.02 82.9,18.4 82.87,18.4 82.87,20.41 83.2,20.74 86.73,20.74 87.37,20.1 87.37,18.45 86.94,18.02
GND on TOP: 43,108.19 42.74,108.44 42.74,113.02 43.12,113.4 44.9,113.4 45.79,112.51 45.79,111.11 45.66,110.98 44.9,110.98 44.27,110.35 44.27,108.7 43.76,108.19 ; 4 cut-outs
GND on TOP: 130.73,69.53 131.03,69.53 131.18,69.38 131.18,68.39 131.77,67.8 131.77,66.97 131.51,66.71 130.96,66.71 130.83,66.84 129.58,66.84 129.13,66.38 128.29,66.38 128.16,66.51 128.16,67.02 128.49,67.35 129,67.35 130.27,68.62 130.5,68.62 130.63,68.74 130.63,69.43
GND on TOP: 98.24,260.97 98.24,262.5 97.99,262.75 96.59,262.75 96.21,263.13 96.21,264.53 96.59,264.91 103.32,264.91 103.57,264.65 103.57,263.38 103.94,263.02 104.55,263.02 104.79,262.77 104.79,262.24 104.67,262.11 103.45,262.11 102.3,260.97 ; 1 cut-out
GND on TOP: 10.36,206.62 10.29,206.68 10.31,206.69 10.31,209.59 10.51,209.79 10.84,209.79 10.94,209.69 10.94,206.89 10.97,206.87 10.97,206.72 10.86,206.62
GND on TOP: 17.21,174.48 16.58,175.12 16.58,177.41 16.96,177.79 22.29,177.79 22.68,177.41 22.68,175.25 22.55,175.12 21.41,175.12 20.77,174.48
GND on TOP: 188.35,21.83 187.97,22.21 187.97,58.1 188,58.56 188.11,59.02 188.11,65.06 188.11,65.06 188.11,65.19 186.89,66.41 186.89,67.68 187.9,68.69 194.51,68.69 196.41,70.6 199.08,70.6 200.98,68.69 202.38,68.69 202.64,68.43 202.64,68.18 201.87,67.4 201.55,67.19 201.17,67.12 198,67.12 197.23,66.97 196.58,66.53 196.54,66.53 195.78,65.77 195.78,65.14 195.52,64.88 194.51,64.88 193.49,65.9 191.46,65.9 190.19,64.63 190.19,62.6 191.59,61.2 191.59,60.57 191.46,60.44 190.34,60.44 189.7,59.8 189.7,59.65 189.17,58.95 188.98,58.1 188.98,22.08 188.79,21.89 188.79,21.83 ; 1 cut-out
GND on TOP: 113.99,81.27 113.23,82.03 113.23,85.97 114.37,87.11 114.37,95.24 114.62,95.49 115.26,95.49 115.51,95.24 115.51,94.86 115.77,94.6 116.53,94.6 116.78,94.86 116.78,96.25 120.08,96.25 120.21,96.13 120.21,94.47 120.34,94.35 122.12,94.35 122.24,94.22 122.24,93.84 119.58,91.17 119.58,87.11 116.15,83.68 116.15,81.39 116.02,81.27 ; 3 cut-outs
GND on TOP: 33.47,76.31 32.58,77.2 32.58,78.98 32.71,79.11 36.26,79.11 36.65,79.49 37.74,79.49 37.86,79.36 37.86,76.87 36.44,76.87 35.88,76.31 ; 2 cut-outs
GND on TOP: 45.92,100.95 45.66,101.21 45.66,104.38 45.79,104.51 46.55,104.51 46.81,104.76 47.19,104.76 47.31,104.63 47.31,102.73 46.55,101.97 46.55,101.08 46.42,100.95
GND on TOP: 91.64,246.11 91.26,246.49 91.26,249.67 91.64,250.05 95.57,250.05 96.34,249.29 96.34,246.49 95.95,246.11
GND on TOP, BOTTOM: 60.39,235.83 60.01,236.21 60.01,238.11 60.52,238.62 72.21,238.62 73.09,237.73 73.09,236.33 72.59,235.83
GND on BOTTOM: 6.17,67.42 5.15,68.44 5.15,81.9 7.31,84.06 12.9,84.06 17.34,88.51 19.75,88.51 20.39,87.87 20.39,86.98 17.47,84.06 15.82,84.06 14.67,82.92 14.67,82.16 13.02,80.5 11.25,80.5 10.1,79.36 8.45,79.36 8.2,79.11 8.2,72.88 8.45,72.63 10.74,72.63 12.26,71.11 12.26,68.57 11.12,67.42
GND on BOTTOM: 71.82,120.89 71.44,121.27 71.44,122.03 72.08,122.67 72.08,124.7 72.21,124.83 73.22,124.83 73.6,124.45 74.75,124.45 74.87,124.32 74.87,122.67 75.25,122.29 75.25,121.02 75.13,120.89 ; 3 cut-outs
GND on BOTTOM: 69.54,182.87 68.9,183.5 68.9,185.28 69.92,186.3 76.18,186.3 76.9,185.57 80.28,185.57 80.53,185.31 80.53,183.76 80.46,183.76 79.57,182.87 ; 4 cut-outs
GND on BOTTOM: 11.75,200.01 11.12,200.65 7.18,200.65 6.93,200.9 6.93,204.2 7.18,204.46 11.63,204.46 13.91,206.74 13.91,208.9 14.29,209.28 16.71,209.28 16.83,209.16 16.83,208.65 16.71,208.52 16.71,207.25 16.96,207 18.48,207 18.48,203.69 16.96,203.69 13.28,200.01
GND on BOTTOM: 26.61,32.88 26.49,33.01 26.49,35.67 27.5,36.69 30.3,36.69 30.68,36.31 32.07,36.31 32.2,36.18 32.2,34.91 31.82,34.53 30.04,34.53 29.03,35.55 28.14,35.55 27.63,35.04 27.63,33.13 27.37,32.88
GND on BOTTOM: 83.76,105.4 83.64,105.52 83.64,105.9 84.27,106.54 84.27,108.57 84.4,108.7 84.78,108.7 85.29,108.19 85.29,108.06 85.54,107.81 86.43,107.81 86.56,107.94 86.56,110.98 86.94,111.37 87.7,111.37 87.95,111.62 87.95,112.76 87.45,113.27 87.45,114.03 87.95,114.54 87.95,115.18 87.7,115.43 87.7,116.19 88.08,116.57 90.11,116.57 91.13,115.56 93.54,115.56 94.18,114.92 94.18,113.4 93.8,113.02 91.51,113.02 91.13,112.64 89.6,112.64 88.84,111.87 88.84,111.24 87.57,109.97 87.57,109.08 88.33,108.32 88.33,107.68 87.57,106.92 85.41,106.92 84.27,105.78 84.27,105.52 84.14,105.4 ; 19 cut-outs
GND on BOTTOM: 47.44,188.71 46.93,189.22 46.93,191.12 47.31,191.5 49.09,191.5 49.35,191.25 49.35,189.09 48.96,188.71
GND on BOTTOM: 115.13,86.35 114.37,87.11 114.37,94.09 114.62,94.35 117.93,94.35 118.18,94.6 118.18,96 121.48,96 121.48,95.11 122.24,94.35 122.24,93.84 119.58,91.17 119.58,86.98 118.94,86.35
GND on BOTTOM: 47.44,204.46 46.93,204.96 46.93,206.87 47.31,207.25 49.09,207.25 49.35,207 49.35,204.84 48.96,204.46
GND on BOTTOM: 167.4,121.83 167.07,122.16 165.8,122.16 165.68,122.29 165.68,123.38 166.31,124.01 166.31,125.46 167.46,126.61 173.17,126.61 173.3,126.48 173.3,124.95 173.04,124.7 172.15,124.7 171.77,124.32 171.77,121.83
GND on BOTTOM: 47.44,196.58 46.93,197.09 46.93,199 47.31,199.38 49.09,199.38 49.35,199.12 49.35,196.96 48.96,196.58
