# Allegro board 14058-1.0623WZS1658.brd (continued)
## Nets (continued)
USB3_TX2_C_DP: C350.1 U2.A12
USB3_TX2_EMI_DN: C349.2 L17.1
USB3_TX2_EMI_DP: C350.2 L17.4
USB_EN: C372.1 C373.1 Q29.4 R508.2
USB_EN1: Q30.G Q31.D R509.2 R512.1
USB_EN2: Q30.D R507.2 R508.1 R510.1
USB_OC0_R_N: R1812.1 U2.AD43
USB_OC4_R_N: R1817.1 U2.Y43
USB_OC5_R_N: R1815.1 U2.Y41
USB_OC6_R_N: R1816.1 U2.W44
USB_OC7_R_N: R1820.1 U2.W43
USB_PCH_DN1: TR1.4 U2.AF5
USB_PCH_DN2: R80050.1 U2.AD5 U9625.2
USB_PCH_DN2_M: R80050.2 R80051.1
USB_PCH_DN3: TR3.4 U2.AG8
USB_PCH_DN4: TR4.1 U2.AE1
USB_PCH_DN5: TR5.4 U2.AC2
USB_PCH_DN6: TR6.4 U2.AF2
USB_PCH_DN8: TR13.4 U2.AL8
USB_PCH_DN8_NN: C522.1 TOUCH2.4 TR13.3
USB_PCH_DN9: TR7.4 U2.AA1
USB_PCH_DN9_NN: TR7.3 WEBCM1.2
USB_PCH_DN10: TR12.4 U2.AJ8
USB_PCH_DN10_NN: NGFF1.5 TR12.3
USB_PCH_DP1: TR1.1 U2.AG7
USB_PCH_DP2: R80052.1 U2.AD7 U9625.3
USB_PCH_DP2_M: R80052.2 R80053.1
USB_PCH_DP3: TR3.1 U2.AG10
USB_PCH_DP4: TR4.4 U2.AE2
USB_PCH_DP5: TR5.1 U2.AC3
USB_PCH_DP6: TR6.1 U2.AF3
USB_PCH_DP8: TR13.1 U2.AL7
USB_PCH_DP8_PP: C523.1 TOUCH2.3 TR13.2
USB_PCH_DP9: TR7.1 U2.AA2
USB_PCH_DP9_PP: TR7.2 WEBCM1.1
USB_PCH_DP10: TR12.1 U2.AJ7
USB_PCH_DP10_PP: NGFF1.3 TR12.2
USBDN2_CHAR: R80051.2 TR2.1 U9625.11
USBDP2_CHAR: R80053.2 TR2.4 U9625.10
USBOC01*: C338.1 R467.2 R469.1 U2.AD42
USBOC89*: C334.1 R463.2 R464.1 U2.AD39
USBOC1011*: C12164.1 R452.2 R470.2 R472.1 U2.AC44
USBP1N_EXT: D9.4 SSUSB1.2 TR1.3
USBP1P_EXT: D9.3 SSUSB1.3 TR1.2
USBP2N_EXT: D9.6 SSUSB2.2 TR2.2
USBP2P_EXT: D9.1 SSUSB2.3 TR2.3
USBP3N_EXT: D10.3 TR3.3 USB1.2
USBP3P_EXT: D10.4 TR3.2 USB1.3
USBP4N_EXT: D10.1 TR4.2 USB2.2
USBP4P_EXT: D10.6 TR4.3 USB2.3
USBP5N_EXT: D11.4 TR5.3 USB3.2
USBP5P_EXT: D11.3 TR5.2 USB3.3
USBP6N_EXT: D11.6 TR6.3 USB4.2
USBP6P_EXT: D11.1 TR6.2 USB4.3
USBVCC01: C339.1 C342.1 C343.1 C344.1 C345.1 D9.5 F14.2 R470.1 SSUSB1.1 SSUSB2.1 TC3.1 TC4.1 U9625.12
USBVCC89: C331.1 C332.1 C333.1 C340.1 D10.5 F18.2 R463.1 R465.2 R468.2 USB2.1 USB4.1
USBVCC1011: C341.1 C356.1 C12329.1 C12330.1 D11.5 F19.2 R465.1 R467.1 R468.1 TC2.1 USB1.1 USB3.1
USBVCCTP: C520.1 F12.2 TOUCH2.5
V_1P5_HDMI: C3366.1 C12202.1 C12203.1 C12204.1 C12205.1 C12206.1 C12207.1 R2081.1 U118.12 U118.19 U118.20 U118.31 U118.40 U119.2
V_1P05_LAN: C286.1 C287.1 C288.1 C289.1 C290.1 C291.1 C292.1 C12154.1 C12336.1 U9623.3 U9623.8 U9623.22 U9623.24 U9623.30
V_1P5_PCH: R375.1
V_3_CARD: C329.2 C330.1 C12161.2 MEMCD1.4 U14.12
V_3P0_BAT_VREG: D2.3 R138.1 R146.1 R408.2 R1835.1 U2.BA22
V_3P3_A: C185.1 C193.1 C194.1 C195.1 C371.1 C384.1 C11835.1 L1.2 PR7.1 PR175.1 PR176.1 PR177.1 PR5279.1 PR5291.1 PR8625.1 PR8626.1 R116.2 R119.2 R120.2 R122.2 R123.2 R305.1 R308.2 R309.2 R310.2 R311.2 R312.2 R313.2 R319.1 R320.1 R389.1 R390.1 R407.1 R745.1 R876.2 R1793.1 R79687.2 R79780.2 R79934.1 R79975.2 R80217.1 U2.BA24 U2.W15 U6.8 U21.6 U21.7 U22.6 U22.7 U109.1 U109.32 U109.64
V_3P3_A_B: D2.1 R894.1 R80217.2
V_3P3_PCIVAUX: C514.1 C515.1 C516.1 C517.1 NGFF1.2 NGFF1.4 NGFF1.72 NGFF1.74 Q56.D Q57.G R723.2 R725.1 R728.1 TC6.1
V_5_CODEC: C211.1 C212.1 C226.1 L4.1 U9.39
V_5_LCD1: L62.1 U1.4
V_5_LCD2: F17.1 L62.2 R79735.2
V_5HDD: C489.1 C490.1 C491.1 R692.2 R693.2 SATAP1.1 SATAP1.3 TC5.1
V_5P0_A: C362.1 C376.1 D5.K L4.2 PC104.1 PR167.1 PR170.1 PR171.1 PR172.1 PR173.1 PR174.1 PU44.7 Q29.5 Q29.6 Q29.7 Q29.8 R80219.2 R80221.2 U21.1 U21.2 U21.4 U22.1 U22.2 U22.4
V_5P0_HDMI_CONN: C419.1 HDMI1.18 L25.1
V_5P0_HDMI_CONN_L: F7.2 L25.2
V_19_INV: C12224.1 C12225.1 F16.2 L61.1 R79706.1 R79716.2
V_CPU_CORE: C4.1 C5.1 C6.1 C7.1 C8.1 C9.1 C10.1 C11.1 C12.1 C13.1 C14.1 C15.1 C16.1 C17.1 C18.1 C19.1 C20.1 C21.1 C22.1 C23.1 C24.1 C25.1 C26.1 C27.1 C28.1 C29.1 C30.1 C31.1 C32.1 C33.1 C34.1 C35.1 C36.1 CPU1.A25 CPU1.A26 CPU1.A27 CPU1.A28 CPU1.A29 CPU1.A30 CPU1.AJ11 CPU1.AJ12 CPU1.AJ13 CPU1.AJ14 CPU1.AJ15 CPU1.AJ16 CPU1.AJ17 CPU1.AJ18 CPU1.AJ19 CPU1.AJ20 CPU1.AJ21 CPU1.AJ22 CPU1.B25 CPU1.B27 CPU1.B29 CPU1.B31 CPU1.B32 CPU1.B33 CPU1.B34 CPU1.B35 CPU1.B36 CPU1.B37 CPU1.C25 CPU1.C26 CPU1.C27 CPU1.C28 CPU1.C29 CPU1.C30 CPU1.C32 CPU1.C34 CPU1.C36 CPU1.D25 CPU1.D27 CPU1.D29 CPU1.D31 CPU1.D32 CPU1.D33 CPU1.D34 CPU1.D35 CPU1.D36 CPU1.E24 CPU1.E25 CPU1.E26 CPU1.E27 CPU1.E28 CPU1.E29 CPU1.E30 CPU1.E32 CPU1.E34 CPU1.E36 CPU1.F23 CPU1.F24 CPU1.F25 CPU1.F27 CPU1.F29 CPU1.F31 CPU1.F32 CPU1.F33 CPU1.F34 CPU1.G23 CPU1.G24 CPU1.G25 CPU1.G26 CPU1.G27 CPU1.G28 CPU1.G29 CPU1.G30 CPU1.G32 CPU1.H22 CPU1.H23 CPU1.H25 CPU1.H27 CPU1.H29 CPU1.H31 CPU1.H32 CPU1.J21 CPU1.J22 CPU1.J23 CPU1.J24 CPU1.J25 CPU1.J26 CPU1.J27 CPU1.J28 CPU1.J29 CPU1.J30 CPU1.J31 CPU1.K16 CPU1.K18 CPU1.K20 CPU1.K21 CPU1.K23 CPU1.K25 CPU1.K27 CPU1.K29 CPU1.K31 CPU1.L14 CPU1.L15 CPU1.L16 CPU1.L17 CPU1.L18 CPU1.L19 CPU1.L20 CPU1.L21 CPU1.L22 CPU1.L23 CPU1.L24 CPU1.L25 CPU1.L26 CPU1.L27 CPU1.L28 CPU1.L29 CPU1.L30 CPU1.M13 CPU1.M14 CPU1.M16 CPU1.M18 CPU1.M20 CPU1.M22 CPU1.M24 CPU1.M26 CPU1.M28 CPU1.M30 G1.1 PG2.1 PG4.1 PG6.1 PL1.2 PL2.2 PL3.2 PT2.1 PT3.1 PT4.1 PT5.1 PT6.1 R1823.1 R79759.1
V_CPU_EOPIO: CPU1.AJ25 CPU1.AJ26 TP251.1
V_CPU_GT: C52.1 C53.1 C54.1 C55.1 C56.1 C57.1 C58.1 C59.1 C60.1 C61.1 C62.1 C63.1 C64.1 C67.1 C68.1 C69.1 C70.1 C71.1 C72.1 C73.1 C74.1 C75.1 C76.1 C77.1 C78.1 C79.1 C80.1 C81.1 C82.1 C83.1 C12444.1 C12445.1 CPU1.AA34 CPU1.AA35 CPU1.AA36 CPU1.AA37 CPU1.AA38 CPU1.AB33 CPU1.AB34 CPU1.G36 CPU1.G37 CPU1.G38 CPU1.G39 CPU1.G40 CPU1.H36 CPU1.H38 CPU1.H40 CPU1.J36 CPU1.J37 CPU1.J38 CPU1.J39 CPU1.J40 CPU1.K36 CPU1.K38 CPU1.K40 CPU1.L34 CPU1.L35 CPU1.L36 CPU1.L37 CPU1.L38 CPU1.L39 CPU1.L40 CPU1.M33 CPU1.M34 CPU1.M36 CPU1.M38 CPU1.M40 CPU1.N34 CPU1.N35 CPU1.N36 CPU1.N37 CPU1.N38 CPU1.N39 CPU1.N40 CPU1.P33 CPU1.P34 CPU1.P36 CPU1.P38 CPU1.P40 CPU1.R34 CPU1.R35 CPU1.R36 CPU1.R37 CPU1.R38 CPU1.R39 CPU1.R40 CPU1.T33 CPU1.T34 CPU1.T36 CPU1.T38 CPU1.T40 CPU1.U34 CPU1.U35 CPU1.U36 CPU1.U37 CPU1.U38 CPU1.U39 CPU1.U40 CPU1.V33 CPU1.V34 CPU1.V36 CPU1.V38 CPU1.V40 CPU1.W34 CPU1.W35 CPU1.W36 CPU1.W37 CPU1.W38 CPU1.Y33 CPU1.Y34 CPU1.Y36 CPU1.Y38 PG8.1 PG10.1 PL4.2 PL5.2 PT11.1 PT12.1 PT13.1 PT14.1 R79761.1
V_CPU_GTX: CPU1.F35 CPU1.G34 CPU1.G35 CPU1.H33 CPU1.H34 CPU1.J33 CPU1.J35 CPU1.K32 CPU1.K34 CPU1.L31 CPU1.L33 CPU1.M32 TP227.1
V_CPU_IO: C86.1 C87.1 C88.1 C89.1 C90.1 C91.1 CPU1.AJ23 CPU1.AK11 CPU1.AK14 CPU1.AK24 CPU1.M8 CPU1.P8 CPU1.T8 CPU1.U8 CPU1.W8 PR137.1 PR138.1 PR140.1 PR141.1 PR142.1 PR144.1 R24.1 R55.1 R63.1 R71.2 R1769.1
V_CPU_OPC: CPU1.AJ27 CPU1.AJ28 CPU1.AJ29 CPU1.AJ30 CPU1.AK27 TP253.1
V_CPU_SA: C84.1 C85.1 CPU1.AA6 CPU1.AA7 CPU1.AB6 CPU1.AB7 CPU1.AB8 CPU1.AC7 CPU1.AC8 CPU1.N7 CPU1.P7 CPU1.R7 CPU1.T7 CPU1.U7 CPU1.V7 CPU1.W7 CPU1.Y6 CPU1.Y7 CPU1.Y8 PC6.2 PG12.1 PL6.2 PR16.1 PT17.1 PT18.1 R1985.2 R1986.2
V_CPU_ST_PLL: C12056.1 C12057.1 C12058.2 CPU1.V4 CPU1.V5 PC4428.1 PR1.1 PR4415.1 PR4447.1 PR4448.1 PR4449.1 Q1234.S R8.1 R12.1 R14.1 R16.1 R17.1 R18.1 R68.2 R152.1 R1824.1 R79769.2 R80241.1 R80242.1
V_CPU_VCCIO_R119BV: R1970.2 U175.5 U175.6 U176.2 U176.5
V_SM: C37.1 C38.1 C39.1 C40.1 C41.1 C42.1 C43.1 C44.1 C45.1 C47.1 C48.1 C49.1 C50.1 C51.1 C92.1 C93.1 C94.1 C95.1 C96.1 C97.1 C98.1 C99.1 C100.1 C101.1 C102.1 C103.1 C106.1 C113.1 C116.1 C117.1 C118.1 C119.1 C120.1 C121.1 C122.1 C123.1 C124.1 C125.1 C126.1 C127.1 C132.1 C12148.1 CPU1.AT18 CPU1.AT21 CPU1.AU13 CPU1.AU15 CPU1.AU19 CPU1.AU23 CPU1.AV11 CPU1.AV17 CPU1.AV21 CPU1.AW10 CPU1.AW14 CPU1.AW25 CPU1.AY12 CPU1.AY16 CPU1.AY18 CPU1.AY23 DIMM1.75 DIMM1.76 DIMM1.81 DIMM1.82 DIMM1.87 DIMM1.88 DIMM1.93 DIMM1.94 DIMM1.99 DIMM1.100 DIMM1.105 DIMM1.106 DIMM1.111 DIMM1.112 DIMM1.117 DIMM1.118 DIMM1.123 DIMM1.124 DIMM2.75 DIMM2.76 DIMM2.81 DIMM2.82 DIMM2.87 DIMM2.88 DIMM2.93 DIMM2.94 DIMM2.99 DIMM2.100 DIMM2.105 DIMM2.106 DIMM2.111 DIMM2.112 DIMM2.117 DIMM2.118 DIMM2.123 DIMM2.124 PC155.1 PR185.1 PR194.2 PR195.2 PR197.2 PR198.2 PR200.2 PR201.2 PR203.2 PR204.2 PU5302.5 PU5302.9 R64.2 R76.1 R82.1 R87.1 R93.1 R925.2
V_SM_1P5_EN: C12167.1 R1801.1 R1952.1 R1955.2
V_SM_VTT: C109.1 C110.1 C130.1 C131.1 DIMM1.203 DIMM1.204 DIMM2.203 DIMM2.204 PR199.2 PR202.2
VBOOT/ADDR: PR4473.1 PU4401.28
VBOOTA/ADDRA: PR4461.1 PU4401.27
VCORE_VCC_SEN: CPU1.C38 PR4407.2 R79759.2 R79788.1
VCORE_VSS_SEN: CPU1.D38 PC4406.2 PR4408.1 R79760.1 R79788.2
VGA_CORE_DISCHG: Q9633.3 R80057.1
VID_PLLVDD: GPU1.N6
VIDALERT#: PR4449.2 PR4467.1 R22.1
VIDSCK: PR4448.2 PR4460.2 R27.1
VIDSOUT: PR4447.2 PR4459.2 R30.1
VOUT_INV: C12098.1 C12100.1 C12103.1 C12107.1 C12108.1 CONVT1.3A CONVT1.3B CONVT1.4A CONVT1.4B D32.K U120.18
VR_ENABLE: R1967.1 R1969.1 U175.3
VR_ENABLE_IC: PC4402.1 PR4402.2 PU4401.2 R1966.2 R1969.2
VR_READY: PC4401.1 PR4401.2 PU4401.6 R1977.1 R1979.1 R79753.1 R79754.2 R79765.1
VR_READY_A: R80229.2 U3.1
VR_READY_G: C12165.1 R1977.2 U3.2
VR_READY_R: R79754.1 U176.6
VR_READY_Y: R1973.1 U3.4
VRALERTB_PU: R103.1 U2.BD23
VREF: C12236.2 U120.2
VREF_1: C215.1 U9.41
VREFC_U20: C506.1 R612.2 R613.1 VRAM1.M8 VRAM2.M8 VRAM3.M8 VRAM4.M8
VREFC_U22: C12395.1 R79776.1 R79997.2 VRAM5.M8 VRAM6.M8 VRAM7.M8 VRAM8.M8
VREFD_U20: C12386.1 R258.1 R79995.2 VRAM1.H1 VRAM2.H1 VRAM3.H1 VRAM4.H1
VREFD_U22: C12394.1 R79999.2 R80000.1 VRAM5.H1 VRAM6.H1 VRAM7.H1 VRAM8.H1
VREG_PCIAUX_PCH: Q58.D Q60.C R727.2 R730.1
VREG_PCIAUX_PCH_1: C518.1 C12237.2 Q56.G R730.2
VRP: C208.2 U9.38
VTT_EN: PU40.7 Q1228.6 R1735.2 R1736.1
WAKE_N: R115.2 R708.2 R2281.2
WEA#: GPU1.K27 R7539.1 R7541.1 VRAM1.L3 VRAM2.L3 VRAM3.L7 VRAM4.L7 VRAM5.L3 VRAM6.L3 VRAM7.L7 VRAM8.L7
WEBCAM_DET: PC2.1 R475.2 U109.114 WEBCM1.7
WP#_1: R9507.2 R9508.1 R9509.2 U9501.3
WP_PRO: RN9503.1(A) SCA1.40 U9502.7
XCLK_RBIAS: R159.2 U2.E1
XDP_PCUDERBUG_3: R10.2 R1782.2 XDPC1.1
XDP_PLTRST_N: C12243.1 R1792.2 R1793.2 XDPC1.41
XDP_PRS: R1780.1 R1832.2 XDPC1.60
XDP_PWR_DEBUG: R1766.2 R1769.2 XDPC1.45
XDP_PWRGD: R1775.2 R1777.2 R1778.2 XDPC1.39
XDP_VR_READY: C12241.1 R1779.2 R1791.2 R79874.2 XDPC1.47
XRF_TDC2: C12334.1 XF3.1 XF3.4 XF3.7 XF3.10
XTAL_24M_PCH_IN: C157.1 R178.1 U2.A6 X1.3
XTAL_24M_PCH_OUT: C158.1 R178.2 U2.A5 X1.1
XTAL_OUTBUFF: GPU1.C10 R621.1
XTAL_SSFOUT: GPU1.A10 R629.1
XTALIN: C12383.1 GPU1.C11 X5.1
XTALOUT: C511.1 GPU1.B10 X5.3
N1584333: PR147.2 PR4803.2 R79948.1
N38680596: Q9648.D R79731.1

Pads without a net: CPU1 A5 A6 A12 A14 A16 A18 AL15 AL25 AL26 AM15 AM25 AM26 AN17 AN20 AN21 AP15 AP19 AP20 AP25 AP26 AR25 AR26 AT16 AT33 AU12 AU16 AU29 AU31 AU33 AV10 AV13 AV16 AV24 AV25 AV31 AV33 AW16 AW29 AW31 AW33 AY10 AY31 B4 B5 B7 B8 B11 B12 B13 B14 B15 B16 B17 B18 C3 C4 C6 C7 C11 C13 C15 C17 C19 D2 D3 D5 D6 D18 D19 D20 E1 E2 E4 E5 E18 E20 F2 F3 F5 F6 G1 G2 G4 G5 H2 H3 H5 H6 J4 J5; D5202 2; DIMM1 77 122 125; DIMM2 77 122 125; GPU1 A7 AA1 AA2 AA3 AA4 AA5 AA6 AB1 AB2 AB3 AB4 AB5 AB6 AB18 AB19 AB21 AC3 AC4 AC17 AC18 AC19 AC20 AC21 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD17 AD20 AD23 AE1 AE3 AE4 AE15 AE16 AE18 AE19 AE21 AE23 AE24 AF2 AF3 AF4 AF15 AF16 AF18 AF19 AF21 AF24 AG3 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B3 B7 B19 C1 C2 C3 C4 C8 C9 C18 D4 D5 D10 D16 D17 D18 E6 E9 E10 F4 F5 F7 F10 G1 G2 G3 G4 G5 G6 G7 H3 H4 J1 J2 J3 J4 J5 J26 K1 K2 K3 K4 K5 K6 L3 L4 M1 M2 M3 M4 M5 N1 N2 N3 N4 N5 P3 P4 R1 R2 R3 R4 R5 T1 T2 T3 T4 T5 T6 T24 U3 U4 U6 U24 V1 V2 V3 V4 V5 V6 V24 V25 W1 W2 W3 W4 Y3 Y4; HDMI1 13 14; HDMI2 13 14; LPC1 10; NGFF1 64; PU5301 2 3; PU8602 7; RN9503 4 5; SCA1 21 22 24 25 26 27 28 29 30 42 43 47 48 65 66 67 69 70 71 72 96 97 98 99 100 101; TOUCH2 6 7; U2 A9 A14 A16 A21 A35 AA45 AB2 AB3 AB35 AD2 AD3 AH44 AJ11 AJ13 AJ33 AJ35 AJ38 AJ39 AJ42 AJ43 AJ44 AK44 AK45 AL35 AL36 AL42 AL43 AL44 AM43 AN29 AN42 AR38 AR39 AR41 AR44 AR45 AT31 AT42 AT43 AT44 AU41 AU43 AU44 AV4 AV43 AY2 B10 B13 B14 B15 B16 B19 B20 B21 B23 B31 B32 B33 B35 B36 B38 BA4 BB22 BB38 BC19 BC22 BC23 BC38 BD18 BD21 BD22 BD38 BE21 BE39 C13 C14 C15 C19 C20 C23 C31 C32 C33 C36 C38 D7 D8 D13 D39 E5 E11 E17 E20 E29 E35 E37 E45 F45 G4 G11 G13 G15 G17 G19 G29 G31 G33 G35 G37 G44 G45 H13 H15 H31 H33 H40 H42 H43 H44 J45 K13 K15 K17 K22 K31 K37 K44 L17 L22 L31 L37 L39 N2 N3 N7 N8 N29 N31 N38 N39 N42 N43 P1 P2 P3 P24 P27 P29 P31 R2 R3 R4 R7 R8 R11 R13 R24 R27 R43 R44 T45 U2 U3 U5 U7 U13 V1 V2 W2 W3 W7 W13 Y5; U9 15 17 37 45 46; U29 5 6; U55 11 15 18; U109 50 97 98 101 127; U6701 2 3; U9619 17 18 19 20; U9624 3; VRAM1 J1 J9 L1 L9 M7; VRAM2 J1 J9 L1 L9 M7; VRAM3 J1 J9 L1 L9 M7; VRAM4 J1 J9 L1 L9 M7; VRAM5 J1 J9 L1 L9 M7; VRAM6 J1 J9 L1 L9 M7; VRAM7 J1 J9 L1 L9 M7; VRAM8 J1 J9 L1 L9 M7

## Via types
v1: diameter 0.762, hole 0.381, TOP to BOTTOM, 798 vias
v2: diameter 0.559, hole 0.305, TOP to BOTTOM, 3609 vias
v3: diameter 0.66, hole 0.33, TOP to BOTTOM, 1203 vias
v4: diameter 0.711, hole 0.406, TOP to BOTTOM, 1399 vias
v5: diameter 0.508, hole 0.254, TOP to BOTTOM, 1710 vias
v6: diameter 0.889, hole 0.305, TOP to BOTTOM, 4 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
3V3_VDD33: length 15.7
  TOP w0.356: GPU1.G10 84.29,105.17 83.56,105.17 v2(83.08,105.65) 82.72,105.29 GPU1.G12 ; GPU1.G9 85.2,105.36 85.7,105.86 v5(85.84,105.86) 86.04,105.66 GPU1.G8
  L3 w0.356: v5(85.84,105.86) 85.59,105.61 83.11,105.61 v2(83.08,105.65)
  BOTTOM w0.508: C6705.1 C12379.1 85.84,106.85 85.84,106.84 85.74,106.73 85.74,106.71 85.02,105.99 C12378.1 ; C6705.1 87.11,106.55 C492.2 88.09,106.55 88.72,107.17 C6724.1 89.79,107.87 R606.2 ; C6705.1 86.75,106.73 86.75,105.87 v3(86.66,105.78) 86.51,105.62 86.07,105.62 v5(85.84,105.86)
3V3AUX: length 143.3
  TOP w0.33: v5(83.99,104.62) 83.96,104.59 83.9,104.59 83.56,104.26 GPU1.F11
  TOP w0.508: v2(121.56,117.36) 123.49,117.36 124.12,117.99 125.31,117.99 126.78,116.52 148.71,116.52 v2(150.46,118.27)
  L3 w0.508: v2(105.45,109.61) 104.03,108.19 98.49,108.19 97.05,106.75 97.05,106.34 96.05,105.35 95.32,105.35 94.02,106.64 92.98,106.64 91.89,105.55 88.93,105.55 88.89,105.59 87.25,105.59 86.29,104.62 v5(83.99,104.62)
  L4 w0.508: v2(169.59,130.06) 167.34,127.81 156.04,127.81 153.36,125.13 153.36,123.73 152.32,122.69 152.32,121.96 150.46,120.11 v2(150.46,118.27)
  BOTTOM w0.203: 191.59,137.9 U14.27
  BOTTOM w0.508: v2(105.45,109.61) 105.45,111.36 105,111.82 105,112.43 109.92,117.36 v2(121.56,117.36) ; R79852.2 188.28,136.7 188.28,134.3 v3(189.6,132.98) 189.76,132.83 R79842.2 ; R79842.2 192.21,132.29 190.51,130.59 183.78,130.59 182.57,131.81 172.08,131.81 171.52,131.25 170.77,131.25 v2(169.59,130.06) ; R79842.2 192.3,132.92 C12163.1 192.3,134.69 C12162.2 R79850.2 191.85,136.13 191.85,137.64 191.59,137.9
12V_FAN: length 6.3
  TOP w0.635: 12.1,176.27 FANC3.2 ; FANC3.2 13.28,177.45 ; FANC3.2 14.46,176.27
  BOTTOM w0.508: R361.1 8.01,175.15 8.6,175.75 v2(10.35,175.75)
  vias: v4(10.99,164.2) v4(10.99,163.18)
12V_S: length 11.7
  TOP w1.016: v4(17.47,172.45) 17.47,173.24 Q9624.D
  BOTTOM w1.016: F21.2 14.22,164.78 13.66,165.34 13.66,167.12 16.45,169.91 16.45,171.44 v4(17.47,172.45)
  vias: v3(15.56,161.28) v4(15.55,164.43) v4(15.56,163.44)
12V_S0: length 33.6
  L3 w1.27: v4(4.31,137.4) 4.51,137.6 4.51,138.54 6.11,140.14 9.22,140.14 10.92,141.85 13.71,141.85 14.8,142.93 v4(14.8,158.86)
  BOTTOM w1.27: v4(4.31,137.4) 5.83,135.88 PR5301.2
  vias: v1(13.4,159.55)
+3V_VA: length 4.8
  TOP w0.203: U9.23 180.3,55.31 181.16,54.46 181.79,54.46 181.81,54.47 ; 181.74,56.25 181.53,56.46 U9.25
  TOP w0.508: 181.74,56.25 182.5,55.49 182.5,55.3 182.7,55.1
  vias: v1(182.36,54.09)
+5VL: length 2.7
  BOTTOM w0.102: PG13.2 33.77,74.79 34.3,74.79 v3(34.58,75.07) 34.23,75.42 PR163.1
+19V_AMP_AVCC: length 5
  TOP w0.305: 167.18,33.9 167.68,34.4 U10.12
  TOP w0.508: v1(166.01,35.09) 165.85,34.94 165.85,34.07 R380.2 165.93,33.9 167.18,33.9
+19V_AMP_PVCC: length 9.1
  TOP w0.305: U10.13 168.22,33.9 167.93,33.6 v2(167.93,32.65) 168.68,33.4 U10.14 ; U10.27 175.34,33.4 175.65,33.7 v4(175.65,33.82) 175.41,33.82 175.33,33.9 U10.28
  TOP w0.508: R380.1 165.95,32.65 v2(167.93,32.65)
  vias: v3(169.06,32.35) v3(174.19,33.23)
+DVDDIO_AUDIO: length 9
  TOP w0.254: U2.BA15 149.75,73.75 149.37,74.13 149.11,74.13 v2(148.97,74.28)
  BOTTOM w0.254: C12061.1 153.04,72.54 153.16,72.66 153.16,73.49 152.86,73.79 152.76,73.79 v3(152.27,74.28) 151.55,74.28 151.07,73.8 149.65,73.8 149.17,74.28 v2(148.97,74.28)
  BOTTOM w0.508: C12061.1 154.29,72 R886.2
+P1V0_PRIME_PCH_FUSE_2V8: length 33.1
  TOP w0.102: U2.AL22 v5(144.87,76.64)
  BOTTOM w0.102: R892.1 138.45,97.23 v3(138.45,96.2) 140.12,94.52 140.12,90.58 139.85,90.3 139.85,89.34 139.46,88.96 139.46,86.74 139.4,86.68 139.4,84.79 139.69,84.5 140.05,84.5 140.66,85.11 140.66,85.4 140.94,85.68 141.45,85.68 142.13,85 143.52,85 145.02,83.5 145.02,82.45 144.19,81.62 144.19,80.73 144.2,80.72 144.2,79.97 144.2,79.97 144.2,79.76 144.21,79.76 144.21,79.09 144.8,78.5 145.26,78.5 145.66,78.09 145.66,77.3 146.21,76.75 146.21,76.37 145.96,76.12 145.39,76.12 v5(144.87,76.64)
+V1P0A_VCCAMPHYPLL: length 8.3
  TOP w0.305: 130.74,90.6 131.29,90.06 131.29,89.67 131.23,89.62 131.23,88.87 131.19,88.83 131.19,88.76 U2.C45 131.2,88.57 131.2,88.49 131.24,88.45 U2.C44 131.14,88.07 131.14,88.01 130.9,87.77 130.88,87.77 U2.B43 130.62,87.65 130.46,87.81 U2.A43 130.15,87.9 130.08,87.9 129.84,88.14 129.84,88.21 129.42,88.63 128.92,88.63 128.54,89.01 128.54,90.21 129.1,90.77
  vias: v1(129.36,92.32)
+V1P0A_VCCAPLL: length 13.8
  TOP w0.254: U2.AN19 146.19,76.19 145.82,76.55 v2(145.78,76.55) ; U2.AJ5 U2.AL5 145.24,69.01 v2(145.61,69.38)
  BOTTOM w0.254: v2(145.78,76.55) 145.78,76.66 R889.2 144.54,77.06 144.54,77.01 144.38,76.85 144.38,75.01 144.7,74.7 144.7,73.88 144.16,73.35 144.16,72.93 144.46,72.63 144.49,72.63 145.01,72.11 145.01,71.46 145.1,71.36 145.1,70.28 145.1,70.28 145.1,69.85 145.58,69.38 v2(145.61,69.38) 145.61,68.58 v3(145.6,68.57)
+V1P0A_VCCF24_1P0: length 9.9
  TOP w0.254: U2.K3 134.72,67.77 134.63,67.68 U2.K2 134.94,67.11 134.94,66.85 135.58,66.22 135.58,65.9 136.37,65.11 136.37,64.4 136.04,64.07 136.04,63.31 135.64,62.91 C11839.1 v1(134.46,62.91) 134.33,62.79 R159.1 132.81,62.18 R890.2
+VCCFUSEPRG: length 41.8
  TOP w0.432: CPU1.V6 v5(72.75,173.54)
  TOP w0.508: v2(64.33,141.21) 62.96,142.58 v1(62.93,142.58) 62.93,142.61 62.43,143.12 R1822.2
  L4 w0.356: v2(64.33,141.21) 64.33,152.39 72.21,160.26 72.21,166.68 71.84,167.05 71.84,167.51 72.21,167.88 72.21,171.37 72.41,171.58 72.41,173.19 v5(72.75,173.54)
+VCCFUSEPRG_R: length 3.5
  TOP w0.102: R1824.2 R1823.2 v1(57.54,143.04) 57.54,143.08 57.65,143.19 58.53,143.19 R1822.1
+VCCPFUSE_3P3:
  vias: v1(152.6,64.4)
+VCCPGPPA: length 15.3
  TOP w0.102: U2.BA31 149.75,81.92 149.54,81.71 149.54,81.66 149.22,81.34 v2(149.17,81.34)
  BOTTOM w0.102: v2(149.17,81.34) 149.22,81.34 149.86,81.99 150.83,81.99 150.95,82.1 151.97,82.1 152.56,82.69 152.56,82.81 153.6,83.86 154.79,83.86 156.82,85.89 159.25,85.89 v3(159.84,86.47) 159.96,86.6 159.96,87.78 R1730.1
+VCCPGPPD:
  vias: v1(152.57,91.27) v4(153.74,89.9)
+VCCPLL_OC_R: length 6.2
  TOP w0.508: R64.1 79.25,179.55 80.14,178.66 R65.1 80.14,178.04 v2(81.27,176.91) CPU1.AJ9
  BOTTOM w0.508: v3(80.43,176.92) 81.26,176.92 v2(81.27,176.91)
AGND: length 68.3
  TOP w0.203: U9.22 179.9,55.24 180.92,54.23 v2(180.92,53.96) ; U9.28 182.37,58.04 183.28,57.14 v2(183.46,57.14) ; v2(178.5,63.69) 178.71,63.48 178.71,62.78 178.7,62.77 U9.42
  TOP w0.305: v2(180.03,43.8) 180.49,44.26 U9615.6 ; v2(172.53,38.04) 172.15,37.66 U10.4
  TOP w0.508: C266.2 190.89,77.96 v2(191.33,77.96) ; v2(191.46,73.7) 191.45,73.71 C264.2 ; v2(191.53,80) R419.2 190.25,80.31 R418.2 189.43,79.42 R412.2 C267.2 ; R382.1 179.27,42.15 v2(178.76,42.66) ; R413.2 188.99,70.53 v2(188.87,70.41) ; R424.2 v2(102.56,31.51) ; R397.1 178.67,37.72 v2(178.67,38.17) ; v2(167.46,36.33) 167.46,35.7 C246.2 ; v2(175.53,48.35) 174.96,48.92 R79821.2 C231.2 ; C229.2 184.88,54.04 184.54,54.38 C207.2 185.34,55.1 v2(185.39,55.15) ; v2(185.45,64.93) 185.39,64.93 185.3,64.84 R367.2 ; R379.2 171.37,47.47 v2(171.49,47.59) ; C12153.2 181.36,51.99 C230.2 181.36,53.52 v2(180.92,53.96) ; v2(176.49,68.82) 176.8,68.5 C215.2 ; v2(180.16,68.19) C214.2 ; C12127.2 186.44,52.32 R79827.1 186.44,49.83 v2(186.38,49.77) ; v2(182.19,71.36) 182.16,71.39 Q14.S ; v2(183.18,78.08) 183.15,78.08 R420.2 ; C272.2 101.48,35.36 v2(101.42,35.29) ; Q7.S 186.35,56.13 186.73,55.74 v2(186.73,55.26) ; C268.2 v2(191.66,70.53) ; R423.2 v2(92.27,34.02) ; R386.2 184.75,44.56 v2(184.88,44.44) ; C208.1 182.19,68.11 v2(182.06,68.24) ; v2(172.53,38.04) 172.48,38.08 R399.2 172.48,40.75 R387.1 ; C210.2 179.48,51.17 179.99,50.66 v2(179.99,50.39) ; R79824.2 181.36,40.21 v2(181.15,39.99) ; R79825.2 170.31,38.98 v2(170.57,38.72) ; v2(184.22,68.19) C206.1 ; C249.1 176.23,40.54 v2(177.03,40.54) C250.1 ; v1(178.47,49.2) C11359.2 C11358.2 176.41,49.45 v2(176.98,50.02) ; v2(180.16,70.53) R79822.2 ; R385.2 171.65,44.77 v2(171.79,44.91) ; R417.2 187.58,80.31 v2(187.39,80.12) ; C213.2 178.38,67.25 v2(178.26,67.37) ; v2(102.94,39.65) 103.88,39.65 C270.2 ; v2(101.42,38.28) C271.2 ; R79823.2 v2(186.19,66.99)
  BOTTOM w0.508: C226.2 182.52,67.6 182.06,68.06 v2(182.06,68.24) ; v2(182.06,62.47) 182.5,62.91 C211.2 182.52,63.37 C212.2
AV12: length 4.6
  BOTTOM w0.203: U14.10 189.99,144.48 189.45,145.02
  BOTTOM w0.508: 188.8,145.52 188.99,145.32 189.15,145.32 189.45,145.02 ; 188.8,145.52 188.79,145.53 188.22,145.53 C12155.2 R79843.1 ; 188.8,145.52 v3(188.8,145.52)
DV12S: length 13.9
  L3 w0.508: v2(190.77,147.59) 190.54,147.81 186.63,147.81 v2(185.87,147.05)
  BOTTOM w0.203: 192.09,146.7 192.09,145.9 191.59,145.4 U14.14
  BOTTOM w0.508: v2(190.77,147.59) 190.77,148.25 C12157.1 190.59,148.72 C12158.2 191.69,148.59 v3(191.69,147.74) 192.09,147.33 192.09,146.7 ; v2(185.87,147.05) R79843.2
DV33_18: length 4
  BOTTOM w0.203: U14.18 193.53,142.74 193.87,143.08 193.87,143.78
  BOTTOM w0.508: 193.87,143.78 194.51,144.41 v3(195.01,144.41) 195.04,144.39 C12159.2
GND: length 2846.8
  TOP w0.102: U2.A18 130.38,75.43 131.16,75.43 131.53,75.07 U2.D17 ; U2.B6 130.49,69.67 130.08,69.67 129.47,69.06 128.86,69.06 128.47,68.67 v2(127.7,68.67) 126.84,68.67 125.55,69.96 125.55,72 124.38,73.16 v2(123.77,73.16) 123.23,73.16 122.24,74.15 119.4,74.15 v2(119.09,73.85) 118.84,73.6 118.84,69.1 119.7,68.24 120.19,68.24 v2(120.67,68.72) 121.89,67.5 123.87,67.5 124.33,67.96 124.83,67.96 125.67,67.12 v5(125.88,67.12) 125.88,66.94 126.41,66.41 128.72,66.41 v2(129.15,66.84)
  TOP w0.127: U2.A32 130.5,82.39 130.64,82.25 131.28,82.25 U2.D31 ; v2(129.15,66.84) 129.38,67.07 130.56,67.07 U2.B1
  TOP w0.14: CPU1.AM39 CPU1.AM40 86.05,206.41 86.05,206.49 v5(86.43,206.87) ; CPU1.AP40 88.33,206.86 v5(88.33,206.87) ; CPU1.AH38 82.36,204.52 v5(82.79,204.09) ; v5(83.72,203.2) 83.76,203.2 CPU1.AK37 ; CPU1.AN4 86.01,171.18 v5(86.47,170.73)
  TOP w0.152: U2.AU45 148.25,89.01 148.25,89.01 v2(148.33,89.09) ; v2(129.61,83.88) 129.61,83.3 130.25,82.66 U2.A32 ; U2.P45 136.51,89.48 v2(136.67,89.65) ; U2.AC45 141.05,89.2 v2(140.96,89.29) ; U2.AK4 144.5,68.64 144.93,68.64 U2.AL4 ; U2.BB34 149.8,83.44 v2(149.74,83.51) ; U2.AC1 141.07,66.38 140.75,66.07 140.75,65.79 v2(140.66,65.7) ; v2(153.33,75.73) 153.18,75.58 151.88,75.58 U2.BE18 ; U2.BB21 150.48,76.72 v5(150.82,76.72) ; v2(152.99,82.63) 152.94,82.63 152.65,82.33 151.94,82.33 U2.BE32 ; v2(140.1,87.65) 140.1,87.56 140.01,87.47 U2.AA42 ; U2.AE42 142.29,87.5 v2(142.13,87.66) ; U2.D31 131.73,81.79 U2.D30 132.21,81.35 v2(132.27,81.4) ; U2.V45 138.78,89.09 138.8,89.11 v2(138.8,89.3) ; U2.BB25 150.66,78.9 150.77,79.01 v2(150.84,79.01) ; v2(149.93,81.34) 150.1,81.17 U2.BB30 ; v2(152.47,77.8) 152.42,77.86 U2.BE23 ; U2.D12 131.74,71.59 U2.D10 ; U2.D12 131.4,72.25 v2(131.25,72.11) ; U2.D12 131.84,72.25 U2.E13 ; U2.BB16 150,74.35 149.95,74.31 v2(149.93,74.31) ; v2(137.63,69.31) 137.56,69.25 U2.T4 138.23,68.52 U2.U4 138.63,68.12 U2.V3 ; U2.A37 130.32,84.76 U2.B37 U2.C37 ; U2.BE28 152.93,80.13 v2(152.95,80.15) ; U2.D16 131.74,74.97 U2.D17 131.95,75.38 v2(132.04,75.38) 132.04,75.53 131.66,75.92 U2.D19 131.66,76.72 U2.D21 ; U2.BB11 150.49,71.97 v2(150.87,71.97) ; v2(144.64,87.65) 144.56,87.57 U2.AK42 ; U2.T2 U2.T1 138.16,66.44 v2(138.16,65.52) ; U2.AM45 145.6,88.9 v2(145.23,89.27) ; U2.BE14 152.49,73.31 152.52,73.28 v2(152.65,73.28) ; U2.D36 131.73,84.06 U2.D35 131.87,83.49 v2(132.45,83.49) ; v2(129.45,79.35) 129.75,79.35 130.03,79.07 U2.A25 U2.B25 U2.D25 131.73,78.41 U2.D24 ; U2.AH45 143.59,88.66 v2(143.95,89.02) ; U2.AB4 139.91,68.45 U2.AA4 139.39,68.52 U2.W4 ; U2.AG4 142.8,68.39 142.51,68.39 142.38,68.52 U2.AE4 ; v2(146.55,68.04) 146.55,68.12 146.66,68.23 U2.AP4 ; v2(152.68,70.81) 152.48,71.01 U2.BE9 ; U2.AH1 143.34,67 143.5,66.84 143.5,65.49 142.41,64.4 v2(142.39,64.4) ; v2(135.31,87.63) 135.31,87.56 135.47,87.4 U2.M42
  TOP w0.165: CPU1.AM17 v5(85.56,184.88)
  TOP w0.178: v2(145.1,75.43) 144.87,75.21 U2.AL17 ; U2.AN22 146.19,77.67 v2(146.11,77.75) ; U2.AE4 142,68.42 142,68.1 142,68.09 v2(142,68.07)
  TOP w0.18: 67.41,90.19 67.49,90.27 67.49,91.08 VRAM2.E2
  TOP w0.203: v5(69.23,113.19) 69.56,113.52 71.06,113.52 GPU1.U26 ; v2(120.89,51.95) 120.83,52.01 U109.4 ; U118.8 v2(159.92,49.11) ; U109.71 104.96,60.81 v2(105.23,61.07) ; U2.AR42 146.81,87.2 v2(146.81,87.63) ; v2(118.05,63.23) 117.42,63.23 116.98,63.67 U109.35 ; 157.38,45.88 U118.15 ; U2.BE40 152.29,85.89 v2(152.39,85.89) ; U2.AG13 142.83,72.74 v2(142.29,73.28) ; v2(164.53,45.54) 164.37,45.54 164.31,45.48 U118.35 ; v5(150.74,187.84) 151.22,187.36 151.93,187.36 152.12,187.55 DIMM1.38 ; CPU1.AU7 CPU1.AT7 ; GPU1.AC26 70.98,118.57 69.74,118.57 v5(69.59,118.71) ; v2(132.48,85.25) 132.48,84.93 132.16,84.61 131.8,84.61 131.65,84.76 U2.C37 ; GPU1.P26 71.18,110.93 71.05,111.05 70.11,111.05 v5(70.02,110.96) ; U2.AU1 147.91,66.43 v2(148.1,66.25)
  TOP w0.216: v5(84.62,184.84) 84.2,184.43 CPU1.AK16 ; CPU1.AV26 CPU1.AU25
  TOP w0.254: U2.N10 136.81,71.38 U2.R10 137.05,71.22 137.5,71.68 v2(137.58,71.68) ; v5(162.62,183.7) 162.42,183.9 162.42,183.91 162.08,184.25 DIMM2.49 ; U2.AD4 141.64,68.43 v2(142,68.07) ; U2.E15 132.22,73.62 131.97,73.37 v2(131.97,73.32) 131.66,73.63 U2.D15 ; U2.A44 U2.B45 ; U2.B45 130.6,89.29 v2(130.69,89.38) ; U2.B45 130.73,88.53 U2.B44 ; U2.AV24 148.47,78.81 v5(148.68,79.02) 148.47,79.22 U2.AV27 ; U2.E31 132.27,81.85 v2(132.27,81.4) ; U2.AM22 145.55,77.18 v2(146.11,77.75) ; U2.L13 136.03,72.1 v2(136.03,71.95) ; v2(134.28,86.88) 134.65,87.25 U2.K42 134.4,87.58 U2.K43 ; U2.F44 132.63,88.14 133.13,87.65 133.21,87.65 v2(133.27,87.59) 133.17,87.59 132.86,87.28 U2.G42 ; v5(167.18,151.67) 167.3,151.55 DIMM2.150 ; U2.L15 135.27,73.87 v2(135.7,74.29) 136.03,73.95 U2.N15 ; v2(144.82,79.09) 144.67,79.23 144.32,79.23 U2.AJ26 ; U2.P19 136.69,76.09 136.37,76.42 v2(136.37,76.59) 136.31,76.53 136.15,76.53 135.93,76.31 U2.N19 ; CPU1.A15 v2(56.12,181.31) ; 138.11,70.9 U2.U8 ; 138.11,70.9 U2.U10 U2.U11 ; 138.11,70.9 137.48,70.9 v2(137.46,70.88) ; U2.R29 136.65,80.2 v2(136.34,80.2) ; DIMM1.49 147.22,184.25 147.56,183.91 v5(147.56,183.73) ; v5(151.9,158.81) 151.9,158.69 152.44,158.15 DIMM1.128 ; CPU1.V1 72.3,167.38 v2(72.4,167.28) ; v2(142.3,85.59) 142.63,85.26 U2.AG38 ; v5(83.96,99.6) 83.57,99.99 83.57,101.01 GPU1.B11 ; U2.P17 136.88,74.76 136.88,74.55 v2(137.55,73.89) ; U2.AW29 149.39,80.8 v2(149.93,81.34) ; U2.H35 134,83.58 134,83.44 v2(134.01,83.44) 134.17,83.44 134.4,83.66 U2.K36 ; v2(77.67,167.63) 77.67,167.71 77.78,167.83 77.78,168.42 ; CPU1.C24 v5(58.12,190) ; v5(70.93,170.8) CPU1.T4 ; CPU1.AR1 CPU1.AR2 ; U2.AM19 145.43,75.77 v2(145.1,75.43) ; v5(58.11,179.06) 58.58,178.58 CPU1.C12 ; U2.AD36 v2(140.97,84.5) ; U2.U33 138.35,82.87 v2(138.78,82.44) ; U2.AW13 148.89,72.93 148.89,73.1 v2(148.71,73.28) 148.16,73.28 U2.AT15 ; 150.76,155.97 v5(150.16,155.37) ; 150.76,155.97 151.14,156.35 DIMM1.134 ; 150.76,155.97 152.13,155.97 152.35,155.75 DIMM1.136 ; DIMM2.156 167.57,149.75 v5(167.14,150.18) ; U2.AA25 U2.Y26 ; RN7501.7 52.36,89.19 v5(52.04,89.52) 52.21,89.69 53.4,89.69 RN7501.6 ; v5(59.99,87.54) 60.06,87.54 60.62,86.98 RN7504.3 ; U2.H29 133.93,81.09 v2(133.93,81.28) ; DIMM1.14 151.94,194.75 151.74,194.95 151.28,194.95 v5(150.77,194.44) ; U2.W4 139,68.43 138.78,68.65 v2(138.78,68.67) ; v2(143.77,80.54) 144.14,80.17 U2.AJ28 ; U2.T42 137.74,87.57 v2(137.81,87.65) ; v5(147.52,151.65) 147.52,151.64 147.02,151.14 146.35,151.14 146.25,151.25 DIMM1.151 ; U2.AN31 146.09,82.09 v2(146.37,82.38) ; v2(137.48,82.49) 137.42,82.55 137.32,82.55 U2.R33 ; CPU1.B24 v5(57.21,190) ; GPU1.AF5 88.56,120.85 88.56,122.16 v5(88.71,122.31) ; v2(66.91,167.85) 66.9,167.85 66.85,167.91 ; U2.R22 U2.P22 136.12,77.76 136.11,77.76 v2(136.09,77.78) 136.09,77.76 135.93,77.61 U2.N22 ; U2.AM17 145.43,75.1 v2(145.1,75.43) ; 164.15,197.17 163.23,196.25 DIMM2.9 ; U2.D33 132.25,82.88 U2.E33 132.3,82.84 132.61,82.54 132.61,82.53 v2(132.61,82.53) ; CPU1.F40 62.3,206.43 62.3,207.07 v2(62.36,207.13) ; v2(148.09,75.49) 148.47,75.49 149.06,76.08 U2.AW19 ; v2(145.1,75.43) 144.87,75.66 U2.AL19 ; v5(147.56,187.24) 147.56,187.57 147.28,187.85 DIMM1.37 ; v2(139.93,69.18) 139.96,69.18 140.23,68.91 U2.AB5 ; v2(139.93,69.18) 139.86,69.25 139.86,69.27 139.72,69.42 139.72,69.87 139.29,70.3 U2.W8 ; v2(139.93,69.18) 140.39,69.63 U2.AB7 U2.AB8 ; U2.C28 131.33,80.28 U2.D29 131.91,80.35 v2(131.91,80.13) 131.91,79.88 U2.D27 ; v2(133.79,79.07) 133.65,79.21 U2.H27 U2.K27 ; DIMM2.46 166.98,185.15 166.98,185.15 ; CPU1.AD40 78.7,206.4 v5(78.25,206.84) ; U2.R5 136.92,68.96 v2(136.42,69.47) 136.42,69.46 136.05,69.09 U2.N5 136.03,69.03 U2.N4 ; GPU1.AF8 86.04,122.01 85.92,122.13 85.92,122.52 v2(85.89,122.54) ; U2.BC2 150.88,67.17 U2.BC1 U2.BB1 U2.BA1 ; U2.B40 130.71,86.52 131.15,86.08 v2(131.44,86.08) 131.44,86.55 131.2,86.79 U2.C42 130.42,87.14 U2.A42 ; U2.N24 135.93,78.52 136.09,78.68 v2(136.09,79.06) ; CPU1.W3 v5(72.75,169.88) ; v2(152.52,84.72) 152.5,84.7 U2.BE37 ; U2.AJ10 144.08,71.36 145.07,71.36 U2.AL10 ; U2.AV31 148.36,81.92 v2(147.91,82.37) 147.91,82.43 U2.AV33 ; v5(146.88,189.65) 146.87,189.65 DIMM1.31 ; U2.H17 133.75,75.08 v2(134.05,75.37) ; U2.D10 131.66,71.45 U2.C10 ; v2(70.81,167.74) 70.53,168.02 70.53,168.45 CPU1.T1 ; DIMM2.55 161.62,182.45 161.78,182.61 162.97,182.61 164.04,183.69 v5(164.04,183.7) ; v2(149.76,89.8) 149.52,89.56 U2.AY45 ; U2.AD11 142.2,71.96 v2(142.31,71.85) 142.38,71.92 142.79,71.92 U2.AG11 ; U2.N35 136.03,84.31 U2.N36 135.97,84.45 135.21,84.45 v2(135.2,84.44) 135.25,84.4 135.25,84.15 U2.M35 ; CPU1.A24 v5(56.29,190) ; v2(134.49,86.14) 134.13,85.78 U2.J39 ; v5(164.09,151.88) 164.09,151.93 162.97,153.05 DIMM2.145 ; U2.AL4 145.35,68.67 145.88,68.67 U2.AN4 146.45,68.09 146.5,68.09 v2(146.55,68.04) ; DIMM2.172 167.17,144.95 ; DIMM2.11 164.13,195.65 v5(165.03,196.55) ; v2(68.78,167.5) 68.64,167.64 CPU1.P1 ; v2(135.22,83.3) 134.86,82.94 U2.K33 ; v2(136.41,86.33) 136.11,86.63 U2.N41
  TOP w0.3: VRAM1.M9 87.81,85.88 87.95,86.02 v5(88.23,86.02)
  TOP w0.305: U6701.13 35.25,112.56 35.5,112.3 35.5,111.87 v2(35.63,111.74) 35.43,111.54 34.69,111.54 34.22,112.01 U6701.12 ; DIMM1.60 151.92,180.95 151.5,180.53 v5(151.5,180.29) ; v2(149.48,34.09) 149.55,34.02 HDMI1.5 ; 143.38,82.66 143.31,82.66 142.86,82.21 U2.AG32 ; 143.38,82.66 v2(143.47,82.66) ; 143.38,82.66 143.07,82.98 U2.AG33 ; v5(89.19,171.75) 89.67,171.26 CPU1.AU4 ; v5(166.38,146.29) 166.84,145.83 167.37,145.83 167.69,146.15 DIMM2.168 ; v5(161.99,191.37) 161.91,191.45 DIMM2.25 ; U2.AD33 U2.AD32 141.16,82.21 141.05,82.32 v2(140.95,82.32) 140.85,82.32 140.75,82.21 U2.AB32 ; U2.AT36 147.42,84.56 U2.AU36 148,84.07 U2.AU35 148.14,83.41 v2(148.07,83.34) 148.02,83.4 U2.AR34 ; v5(163.36,137.88) 163.19,138.05 DIMM2.195 ; U2.H19 133.65,75.77 v2(134.05,75.37) ; v5(148.97,196.29) 148.33,195.65 DIMM1.11 ; U2.AG31 143.26,81.66 v2(143.47,81.86) ; GPU1.H5 88.59,105.96 v5(88.99,106.36) ; DIMM1.32 152.38,189.35 v5(151.98,189.75) ; U2.W31 139.53,81.66 v2(139.77,81.42) ; v2(79.59,167.75) 79.61,167.78 CPU1.AF1 ; DIMM1.54 151.94,182.75 151.07,181.88 v5(151.07,181.85) ; DIMM2.43 163.64,186.05 163.89,186.3 v5(163.9,186.3) ; U2.AL33 144.86,82.95 v2(144.59,82.67) 145.07,82.19 U2.AL32 ; RN7502.4 60.68,93.22 60.9,93 R599.2 60.32,92.43 60.2,92.32 60.13,92.32 60.03,92.21 v5(59.99,92.21) ; DIMM2.138 167.74,155.15 167.14,155.75 ; CPU1.AR22 CPU1.AR23 ; U55.14 73.98,35.93 74.03,35.88 v2(74.03,35.7) ; NGFF1.18 134.15,233 v2(134.18,233.03) ; U10.21 172.15,30.84 v2(171.9,30.59) 171.65,30.84 U10.20 ; SCA1.11 42.55,33.46 v2(41.85,34.15) ; DIMM1.170 149.34,145.55 149,145.9 v5(149,146.27) ; DIMM1.44 152.25,185.75 152.01,185.51 v5(151.96,185.51) 152.31,185.15 DIMM1.46 ; v2(141.44,76.67) 141.06,77.05 U2.AC21 ; v2(141.44,76.67) 141.82,76.3 U2.AE20 ; v2(141.44,76.67) 141.44,76.68 U2.AE21 ; v2(141.44,76.67) 141.07,76.3 U2.AC20 ; U2.AR33 146.81,82.82 v2(146.37,82.38) ; CPU1.AM31 86.01,198.13 v5(86.43,197.71) 86.91,197.23 CPU1.AN30 ; Q9620.1 180.36,30.09 v2(180.49,30.21) ; DIMM1.156 152.17,149.75 151.98,149.56 v5(151.98,149.41) ; U2.BD43 151.39,88.17 U2.BD44 ; U2.V23 139.11,78.23 v2(139.11,78.24) 139.11,78.25 U2.V25 ; U2.AR5 147.33,68.96 147.74,69.38 v2(147.85,69.38) ; DIMM1.25 146.58,191.45 147.26,192.14 147.26,192.3 v5(147.43,192.47) ; DIMM1.190 150.67,139.55 v5(149.72,138.6) ; v2(142.99,79) 143.36,78.62 U2.AH25 ; v2(142.99,79) 142.99,79.01 U2.AH26 ; v2(142.99,79) 142.61,79.38 U2.AF26 ; v2(142.99,79) 142.62,78.62 U2.AF25 ; DIMM2.72 v5(167.15,177.35) ; U2.AH21 v2(143.01,76.7) 143,76.7 142.98,76.7 U2.AF21 ; v2(143.77,80.54) 143.39,80.17 U2.AH28 ; v2(143.77,80.54) 143.77,80.56 U2.AJ29 ; v2(143.77,80.54) 143.38,80.93 U2.AH29 ; DIMM1.138 151.99,155.15 151.79,155.35 v5(151.69,155.35) ; v5(167.19,182.75) DIMM2.54 ; DIMM1.20 154.19,192.95 154.22,192.92 v5(155.18,192.92) ; D5203.8 v2(159.4,13.96) 158.76,13.96 R5206.1 ; U2.U18 138.3,75.19 138.3,75.17 v2(138.33,75.14) ; U10.9 169.15,36.05 168.48,36.05 v2(168.36,35.93) 168.36,35.79 168.75,35.4 U10.10 ; U2.AL13 144.99,72.82 v2(144.67,73.14) ; v5(146.83,146.01) 146.83,146.18 146.56,146.45 DIMM1.167 ; v2(27.76,137.91) 27.23,137.39 PU28.16 ; U6701.15 36.12,113.78 v2(36.39,114.04) 36.15,114.28 U6701.16 ; U2.W38 138.85,85.26 138.77,85.34 v2(138.75,85.34) 138.29,85.34 U2.U38 ; U2.Y29 139.51,81.16 v2(139.77,81.42) ; U10.17 169.72,31.56 169.31,31.15 v2(169.31,30.82) ; PU24.6 93.16,261.98 v2(93.8,262.62) ; U2.AE18 141.82,75.52 v2(141.44,75.15) 141.07,75.52 U2.AC18 ; v2(134.49,86.14) 134.88,86.54 U2.L41 ; v5(147.34,157.63) 147.26,157.63 146.27,156.65 DIMM1.133 ; v2(143.79,75.14) 143.58,74.93 143.56,74.93 U2.AH17 ; v2(143.79,75.14) 144.16,74.77 U2.AJ17 ; v2(143.79,75.14) 144.16,75.5 U2.AJ18 ; U2.U14 138.04,73.48 v2(137.69,73.13) ; CPU1.AN5 86.02,172.17 v5(86.43,172.58) ; v2(139.89,75.12) 140.27,74.75 U2.AA17 ; v2(139.89,75.12) 139.89,75.13 U2.AA18 ; v2(139.89,75.12) 139.52,74.75 U2.Y17 ; v2(139.89,75.12) 139.51,75.5 U2.Y18 ; U173.4 17.71,157.99 17.47,158.23 v2(16.71,158.23) ; DIMM1.26 151.98,191.15 150.75,192.38 v5(150.75,192.48) ; DIMM2.179 161.27,142.85 161.82,142.3 162.26,142.3 v5(162.77,142.81) ; v2(143.47,81.86) 143.82,82.21 U2.AJ32 ; v2(143.47,81.86) 143.68,81.66 U2.AJ31 ; CPU1.R6 69.16,173.48 v5(69.16,173.54) ; U2.AM15 145.29,73.75 v2(144.67,73.14) ; v5(167.19,187.55) DIMM2.38 ; v2(142.22,80.54) 141.85,80.17 U2.AE28 ; v2(142.22,80.54) 142.22,80.56 U2.AF29 ; v2(142.22,80.54) 142.59,80.17 U2.AF28 ; v2(142.22,80.54) 141.84,80.93 U2.AE29 ; v5(147.54,147.84) 147.03,148.35 146.47,148.35 146.37,148.25 DIMM1.161 ; HDMI2.2 149.48,9.52 149.47,9.51 ; DIMM1.144 150.72,153.35 150.21,153.86 v5(149.5,153.86) 149.27,153.63 149.27,153.61 148.63,152.97 146.21,152.97 146.13,153.05 DIMM1.145 ; DIMM1.63 147.79,180.05 149.01,181.27 v5(149.01,181.32) ; DIMM1.71 148.82,177.65 149.35,178.19 v5(149.35,178.22) 148.12,179.45 DIMM1.65 ; DIMM1.172 151.71,144.95 v5(151.63,144.87) ; HDMI1.8 149.56,35.52 v2(149.49,35.59) ; U2.AT9 147.77,71.49 U2.AT10 147.29,71.54 v2(147.1,71.35) ; v5(162.67,154.22) 162.04,154.85 DIMM2.139 ; v2(134.18,234.53) 134.15,234.5 NGFF1.24 ; v2(40.23,104.38) 40.65,104.38 41.16,103.88 PU8602.4 ; v5(164.93,154.16) 164.93,154.15 165.83,153.24 167.67,153.24 167.77,153.35 DIMM2.144 ; v5(78.19,169.87) 78.66,170.34 CPU1.AE3 ; NGFF1.30 v2(130.99,236) ; DIMM1.43 146.59,186.05 146.65,185.99 v5(146.75,185.99) ; U2.AR7 147.38,69.85 v2(147.85,69.38) ; U10.8 169.54,36.74 169.49,36.69 v2(169.46,36.69) ; U2.AH23 143.36,77.85 v2(142.99,78.22) 142.62,77.85 U2.AF23 ; v2(147.1,71.35) 146.64,71.81 U2.AP11 ; v2(147.1,71.35) 147.14,71.31 U2.AR9 ; DIMM2.128 v5(167.17,158.15) ; U2.AU7 147.85,69.7 v2(147.85,69.38) ; DIMM2.133 161.88,156.65 161.88,156.65 v5(161.99,156.65) ; NGFF1.36 v2(130.99,237.5) ; CPU1.AJ1 82.36,167.02 v2(82.44,166.94) ; v2(136.41,86.33) 136.54,86.2 136.54,85.61 U2.R38 ; DIMM1.28 151.95,190.55 151.02,191.48 150.76,191.48 150.69,191.55 ; DIMM2.134 166.86,156.35 166.4,156.81 v5(166.4,156.91) ; v2(30.07,36.46) 30.07,36.47 29.58,36.95 SCA1.85 ; v2(145.73,80.28) 146.19,79.82 U2.AN27 ; v2(145.73,80.28) 145.73,80.39 145.38,80.74 ; v2(145.73,80.28) 145.43,79.97 U2.AM27 ; v2(139.77,81.42) 140.24,80.95 U2.AA29 ; v2(142.29,73.28) 142.09,73.48 U2.AD14 ; DIMM1.9 147.81,196.25 v5(149.25,197.69) ; U2.U32 138.06,82.16 137.74,82.49 v2(137.48,82.49) 137.48,81.91 137.74,81.66 U2.U31 ; v5(151.24,138.57) 152.06,137.75 DIMM1.196 ; v2(23.11,51.75) 22.86,51.5 LVDS1.7 ; DIMM1.19 146.23,193.25 146.44,193.46 148.27,193.46 v5(149.25,194.44) ; U2.AF20 142.61,76.2 142.91,75.9 v2(142.99,75.9) ; 162.92,150.65 DIMM2.153 ; 162.92,150.65 162.92,150.35 162.62,150.05 DIMM2.155 ; 162.92,150.65 162.92,150.67 163.92,151.66 163.92,151.7 v5(164.09,151.88) ; DIMM2.63 161.4,180.05 162,180.65 ; U2.AA21 139.89,76.68 v2(139.89,76.67) ; CPU1.AA3 75.04,169.66 v5(74.84,169.46) ; U2.AH18 143.01,75.9 v2(142.99,75.9) ; PU9.6 v2(12.64,207.89) ; U2.H22 133.65,77.79 133.61,77.82 v2(133.61,77.91) 133.61,77.95 133.65,77.98 U2.H24 ; CPU1.AV5 90.65,172.17 v2(91.05,171.77) 91.08,171.77 91.48,172.17 CPU1.AW5 ; NGFF1.69 v2(123.4,245.75) ; CPU1.AT39 v2(90.11,205.9) 89.67,206.34 CPU1.AT40 ; v2(94.66,195.24) 93.92,194.5 93.49,194.5 93.47,194.48 CPU1.AY27 ; v5(71.59,105.58) 71.6,105.58 71.98,105.96 GPU1.H25 ; v5(161.94,188.07) 161.71,187.84 160.46,187.84 DIMM2.37 ; v5(147.59,149.46) 147.01,150.05 DIMM1.155 ; U2.Y20 139.52,76.3 v2(139.89,76.67) ; v5(163,146.44) 162.52,145.96 161.93,145.96 161.44,146.45 DIMM2.167 ; NGFF1.45 v2(123.4,239.75) ; NGFF1.63 v2(123.4,244.25) ; CPU1.AT36 CPU1.AT37 89.64,203.63 v5(89.24,204.04) 89.67,204.47 CPU1.AT38 ; v2(139.89,76.67) 140.27,76.3 U2.AA20 ; NGFF1.23 v2(123.4,234.25) ; DIMM1.48 151.87,184.55 151.19,183.88 v5(151.19,183.73) ; U28.8 153.01,33.06 v2(152.92,33.15) ; v2(20.52,44.54) 20.6,44.54 20.64,44.5 LVDS1.14 ; DIMM2.71 163.12,177.65 164.43,178.96 164.43,179.01 v5(164.61,179.18) ; U2.U29 138.34,80.57 v2(138.34,80.57) ; v5(151.88,140.87) 151.89,140.87 152.37,141.35 DIMM1.184 ; CPU1.A15 57.2,180.86 58.03,180.86 58.49,180.4 CPU1.C14 ; CPU1.AR36 88.69,202.71 v5(88.23,203.18) 87.84,203.56 CPU1.AP37 ; v2(138.34,80.57) 138.72,80.95 U2.V29 ; v2(138.34,80.57) 138.34,80.55 U2.U28 ; CPU1.G22 v5(61.78,188.17) ; v2(139.13,76.7) 139.5,77.07 U2.Y21 ; v2(139.13,76.7) 139.11,76.7 U2.V21 ; v2(139.13,76.7) 139.13,76.68 138.75,76.3 U2.V20 U2.V18 ; HDMI2.17 150.02,17.02 149.55,16.55 v2(149.55,16.34) ; 145.38,80.74 U2.AM29 ; 145.38,80.74 145.32,80.8 U2.AL29 ; v5(91.03,169.91) 90.58,169.47 CPU1.AV2 ; v5(161.91,194.99) 161.85,195.05 DIMM2.13 ; U2.AF18 142.62,75.52 v2(142.99,75.9) ; U2.BC2 150.89,67.52 U2.BD2 ; CPU1.AN1 86.01,168.39 86.53,167.87 v2(86.53,167.42) ; U2.Y26 139.15,79.76 139.15,79.78 v2(139.14,79.79) 139.15,79.79 139.15,79.81 U2.Y28 ; v5(151.25,196.29) 151.51,196.55 DIMM1.8 ; CPU1.AD37 78.7,203.6 v5(79.18,203.12) ; DIMM2.48 167.28,184.55 166.98,184.85 166.98,185.71 v5(167.02,185.75) 167.03,185.75 DIMM2.44 ; U9619.22 103.99,101.84 103.68,102.14 103.12,102.14 v2(102.56,101.59) ; v5(167.18,147.84) 167.29,147.95 DIMM2.162 ; v5(161.93,147.97) 161.65,148.25 DIMM2.161 ; D5204.8 162.12,8.5 162.25,8.62 v2(162.27,8.62) ; v5(92.08,205.1) 91.52,204.54 CPU1.AV38 ; D5203.3 161.99,13.96 162.23,13.72 v2(162.23,13.71) ; CPU1.AB39 76.87,205.49 v2(77.29,205.9) ; v2(131.98,89.24) 131.92,89.18 131.92,89.04 131.71,88.83 131.71,88.77 U2.D45 ; v5(151.96,146.29) 152.1,146.15 DIMM1.168 ; v2(149.49,37.09) 149.56,37.02 HDMI1.11 ; v2(142.99,75.9) 142.99,75.91 U2.AH20 ; U2.U15 137.71,74.04 v2(137.55,73.89) 137.55,74.29 137.96,74.7 U2.U17 ; DIMM2.185 159.12,141.05 v5(158.94,141.24) ; U2.AN7 146.2,69.83 v2(146.63,70.25) 146.29,70.59 U2.AN8 ; CPU1.AY5 92.41,172.14 v5(92.89,171.66) ; v2(45.04,107.28) 44.76,107 PU8602.19 ; NGFF1.39 v2(123.4,238.25) ; PWRCN1.4 36.38,18.92 v2(35.88,19.42) ; U2.AD8 141.73,70.62 142.13,71.03 142.13,71.08 142.31,71.26 v2(142.31,71.85) ; U2.AN39 146.54,85.45 v2(146.6,85.45) ; DIMM2.28 167.74,190.55 v5(167.14,191.15) 167.29,191.15 167.3,191.15 DIMM2.26 ; DIMM2.184 167.36,141.35 v5(167.17,141.16) ; v5(167.17,194.75) DIMM2.14 ; DIMM1.61 147.05,180.65 147.54,181.14 v5(147.54,181.34) ; 167.14,155.75 DIMM2.136 ; 167.14,155.75 v5(167.12,155.75) ; v2(31.41,25.67) 31.69,25.67 32.01,25.99 SCA1.107 ; DIMM1.153 147.29,150.65 148.25,149.69 148.25,149.52 v5(148.3,149.47) ; DIMM2.31 161.83,189.65 v5(161.95,189.53) ; U2.AB15 U2.AB14 140.04,73.48 v2(139.69,73.14) 139.35,73.48 U2.W14 ; CPU1.AC3 76.87,170.34 v2(77.31,170.78) 77.78,171.25 CPU1.AD4 ; CPU1.J3 v5(63.61,169.88) ; HDMI2.8 149.89,12.52 149.68,12.31 149.01,12.31 v2(148.84,12.13) ; U10.24 173.65,31 v2(174.07,30.58) ; CPU1.AN6 CPU1.AM5 ; v2(57.67,187.6) 57.79,187.71 CPU1.C22 ; DIMM2.32 v5(167.14,189.35) ; v2(144.67,73.14) 144.28,73.53 U2.AJ14 U2.AJ15 ; v5(161.99,193.13) 161.88,193.25 DIMM2.19 ; v5(148.13,158.86) 147.63,159.36 146.96,159.36 146.05,158.45 DIMM1.127 ; NGFF1.7 v2(123.4,230.25) ; U2.AB31 140.83,81.66 v2(140.96,81.53) 141.06,81.43 U2.AC29 ; CPU1.AM19 86.21,187.17 86.22,187.18 86.66,187.18 86.67,187.17 CPU1.AN19 86.95,187.17 v2(87.39,186.73) ; R5208.1 157.08,14.25 156.79,13.96 v2(156.76,13.96) ; NGFF1.33 v2(123.4,236.75) ; v5(164.98,180.71) 164.93,180.65 162,180.65 ; v5(164.32,141.16) 164.32,141.01 ; 164.32,141.01 164.32,140.4 163.78,139.85 DIMM2.189 ; 164.32,141.01 163.76,140.45 DIMM2.187 ; CPU1.AF40 80.16,206.74 v5(80.08,206.74) ; DIMM1.2 151.43,198.35 v5(150.77,197.69) ; v2(159.57,8.88) 159.95,8.5 D5204.3 ; 162,180.65 DIMM2.61 ; CPU1.AR2 CPU1.AR3 87.83,170.35 87.83,171.24 CPU1.AR4 87.82,171.25 v5(87.38,171.68) ; DIMM1.162 152.27,147.95 152.26,147.94 v5(151.99,147.94) ; v5(89.25,185.77) 89.58,185.44 89.58,185.43 CPU1.AT17 ; v2(32.81,115.84) 32.72,115.75 U6701.5 ; CPU1.AH40 82.37,206.38 v5(82.37,207) ; v5(167.19,196.55) DIMM2.8 ; CPU1.AD39 78.7,205.43 v5(78.26,205) 78.7,204.56 CPU1.AD38 ; SCA1.61 31.51,49.54 v2(31.82,49.85) ; PU4.6 v2(12.64,189.09) ; U2.AE25 141.83,78.62 141.47,78.26 v2(141.45,78.26) 141.44,78.26 141.42,78.26 U2.AC25 ; CPU1.AV34 CPU1.AU34 ; v2(44.65,48.25) 44.62,48.25 44.27,47.89 44.27,47.87 43.88,47.48 SCA1.38 ; v5(147.92,153.91) 146.98,154.85 DIMM1.139 ; CPU1.AY9 92.18,175.82 92.15,175.86 91.66,175.86 91.63,175.82 CPU1.AW9 ; CPU1.AJ35 83.21,201.8 v5(82.82,201.41) ; v5(162.67,151.88) 162.67,151.85 162.07,151.25 DIMM2.151 ; NGFF1.29 v2(123.4,235.75) ; CPU1.AT31 CPU1.AT30 ; U29.8 153.85,40.09 v2(152.85,40.09) 152.78,40.02 HDMI1.17 ; U2.AL24 144.82,78.56 v2(144.82,79.09) 144.87,79.09 145.43,78.53 U2.AM24 ; DIMM1.55 148.88,182.45 ; v5(167.19,192.95) DIMM2.20 ; v5(170.06,137.97) 169.84,137.75 DIMM2.196 ; DIMM1.66 152.11,179.15 152.03,179.07 149.86,179.07 v2(149.04,179.89) ; CPU1.AH36 82.3,202.77 82.3,203.57 CPU1.AH37 ; v2(148.09,75.49) 148.47,75.1 U2.AV17 ; DIMM1.3 146.57,198.05 146.74,198.22 147.19,198.22 v5(147.72,197.69) ; NGFF1.57 v2(123.4,242.75) ; v2(140.97,84.5) 140.4,85.07 140.39,85.08 U2.AB38 ; CPU1.AF36 80.46,202.78 80.46,203.56 CPU1.AF37 ; DIMM2.190 v5(167.14,139.55) ; v5(57.17,86.04) 57.97,86.84 RN7503.3 ; v5(150.88,178.15) 150.92,178.15 151.72,177.35 DIMM1.72 ; U2.R14 136.82,73.37 136.44,73.37 136.34,73.27 136.11,73.27 v2(136.09,73.25) ; v5(156.65,158.81) 157.01,158.45 DIMM2.127 ; v5(167.17,144.94) 167.77,145.55 DIMM2.170 ; v2(182.57,39.36) 183.13,39.36 183.7,38.79 Q13.4 ; v2(67,258.94) 67,258.94 PU19.6 ; DIMM1.150 152.05,151.55 v5(151.95,151.65) ; NGFF1.75 v2(123.4,247.25) ; U2.AL38 144.99,85.24 v2(144.64,84.88) 144.25,84.5 U2.AJ36 ; v5(69.1,169.88) CPU1.R3 ; 77.78,168.42 CPU1.AD1 ; U2.W33 139.29,82.87 138.86,82.44 v2(138.78,82.44) 139.01,82.21 U2.W32 ; v2(33.5,111.33) 33.22,111.6 U6701.10 ; PU28.7 v2(23.56,136.39) ; CPU1.C10 v5(58.12,177.2) ; v5(161.96,144.65) DIMM2.173 ; DIMM2.65 161.63,179.45 161.89,179.72 162.67,179.72 163.01,179.38 163.01,179.33 v5(163.16,179.18) ; DIMM2.3 v5(161.91,198.05) ; v2(149.46,32.59) 149.53,32.52 HDMI1.2 ; U2.AW9 149.09,70.67 v2(149.09,70.02) 149.05,69.98 149.05,69.96 U2.AV6 ; PU14.6 v2(13.15,233.4) ; v5(147.72,194.44) 147.11,195.05 DIMM1.13 ; v5(167.19,179.15) DIMM2.66 ; DIMM2.60 v5(167.17,180.95) ; 149.67,11.02 HDMI2.5 ; U26.8 v2(155.75,36.61) ; v5(167.17,143.15) DIMM2.178
  TOP w0.33: v5(147.44,143.27) 147.43,143.26 147.43,143.18 146.96,142.71 146.51,142.71 146.37,142.85 DIMM1.179 143.46,142.85 ; 143.42,139.85 DIMM1.189 148.59,139.85 v5(149.59,140.85) ; DIMM1.3 143.25,198.05 ; DIMM2.14 170.43,194.75 ; DIMM2.44 170.41,185.75 ; DIMM1.9 143.15,196.25 ; DIMM1.161 143.76,148.25 ; 143.47,138.05 DIMM1.195 146.37,138.05 146.8,137.62 v5(146.8,137.55) ; DIMM1.63 143.05,180.05 ; DIMM1.145 143.23,153.05 ; CPU1.K15 v5(64.52,181.77) ; DIMM2.128 169.95,158.15 ; DIMM1.11 143.11,195.65 ; DIMM2.170 170.1,145.55 ; DIMM2.72 170.3,177.35 ; DIMM1.167 143.87,146.45 ; DIMM2.178 170.47,143.15 ; DIMM1.55 142.78,182.45 ; v5(148.96,143.33) 148.96,143.33 148.96,144.37 148.71,144.61 v5(148.71,144.68) 148.64,144.61 147.41,144.61 147.37,144.65 DIMM1.173 143.57,144.65 ; DIMM2.54 170.49,182.75 ; DIMM1.31 143.53,189.65 ; DIMM1.49 143.47,184.25 ; DIMM2.162 170.24,147.95 ; DIMM2.150 170.07,151.55 ; DIMM2.168 170.26,146.15 ; DIMM1.43 143.32,186.05 ; 143.61,141.05 DIMM1.185 146.69,141.05 146.7,141.06 v5(146.72,141.06) ; DIMM2.144 170.17,153.35 ; DIMM1.65 143.34,179.45 ; DIMM2.26 170.28,191.15 ; DIMM1.127 143.61,158.45 ; DIMM1.151 143.59,151.25 ; DIMM2.134 170.48,156.35 ; DIMM2.190 170.24,139.55 ; DIMM2.32 170.13,189.35 ; DIMM2.136 170.19,155.75 ; DIMM2.60 170.11,180.95 ; v5(149.93,143.33) 150.32,143.33 150.5,143.15 DIMM1.178 ; 170.37,198.35 DIMM2.2 168.65,199.32 ; DIMM2.8 170.15,196.55 ; DIMM1.155 143.63,150.05 ; DIMM2.156 170.35,149.75 ; DIMM2.184 170.36,141.35 ; DIMM1.71 143.44,177.65 ; DIMM1.61 143.26,180.65 ; DIMM2.138 170.22,155.15 ; DIMM1.133 143.63,156.65 ; DIMM1.37 143.23,187.85 ; DIMM1.139 143.25,154.85 ; DIMM2.46 170.12,185.15 ; DIMM1.19 143.23,193.25 ; 143.58,140.45 DIMM1.187 147.62,140.45 148.01,140.83 148.01,140.89 v5(148.17,141.06) ; DIMM1.153 143.62,150.65 ; DIMM2.172 170.19,144.95 ; DIMM1.13 143.19,195.05 ; DIMM2.66 170.66,179.15 ; DIMM2.38 170.23,187.55 ; DIMM2.48 169.96,184.55 ; DIMM1.2 153.45,199.72 ; DIMM1.25 143.25,191.45 ; DIMM2.20 170.43,192.95
  TOP w0.356: GPU1.AC8 86.07,118.42 v5(86.46,118.03) 86.46,117.96 86.84,117.58 GPU1.AB7 ; v5(64,107.99) 64,107.96 64.04,107.92 VRAM5.B1 ; v5(88.1,118.77) 88.12,118.75 88.12,118.69 88.44,118.37 GPU1.AC5 ; v5(88.99,107.99) 88.99,108.05 88.61,108.44 GPU1.L5 ; VRAM6.G9 60.04,114.63 v5(60.42,114.25) 60.84,114.67 VRAM6.F9 ; CPU1.AT13 89.17,181.18 v5(89.17,181.16) ; VRAM2.G9 73.85,89.88 74,90.02 v5(74.03,90.02) ; CPU1.D40 v2(59.95,205.91) CPU1.D39 ; v5(66.47,89.72) 66.93,89.72 VRAM2.G1 67.1,89.88 67.41,90.19 ; VRAM5.J2 58.43,106.25 v5(58.03,106.65) ; VRAM2.E8 v5(73.09,91.88) VRAM2.D8 ; VRAM2.M9 73.83,85.88 73.84,85.89 74.32,85.89 v5(74.39,85.96) ; CPU1.AR21 88.76,188.9 88.66,188.81 88.66,188.29 88.76,188.2 CPU1.AR20 ; v2(134.54,71.68) 135.02,72.16 U2.L12 ; CPU1.AK8 83.27,174.91 v5(82.79,174.42) ; CPU1.W6 73.22,173.08 73.65,173.52 v5(73.65,173.57) ; CPU1.AP5 86.93,172.14 v5(87.38,171.68) 87.84,172.14 CPU1.AR5 ; CPU1.H1 v2(63.15,167.87) ; CPU1.AP14 87.84,182.6 v5(87.42,183.01) ; VRAM5.T1 52.84,107.35 52.61,107.57 v5(52.61,108.09) ; CPU1.AN16 86.93,184.41 v5(86.47,183.95) ; GPU1.AD12 GPU1.AD13 81.92,119.27 81.57,119.62 v5(81.5,119.62) ; CPU1.K14 v5(65.44,180.85) CPU1.K15 ; CPU1.AP11 87.8,179.85 v5(87.38,179.43) 86.95,179.85 CPU1.AN11 86.8,179.85 86.73,179.78 86.21,179.78 86.14,179.85 CPU1.AM11 ; v2(83.72,194.03) 83.72,194.03 84.18,193.57 CPU1.AK26 ; VRAM6.J2 58.44,120.28 v5(58.84,120.68) ; CPU1.AT11 89.62,179.85 v5(89.22,180.26) ; CPU1.AH40 82.36,206.22 82.28,206.15 82.28,205.56 82.36,205.48 CPU1.AH39 ; CPU1.AT24 89.64,191.74 v5(89.18,192.2) 88.76,191.77 CPU1.AR24 ; v2(79.17,171.7) CPU1.AE5 ; v5(82.75,197.85) 82.98,197.85 CPU1.AJ31 ; CPU1.G6 v5(61.78,173.54) CPU1.F7 ; CPU1.AD36 78.77,202.71 v5(79.18,203.12) 79.59,202.71 CPU1.AE36 ; CPU1.AP24 87.87,191.74 v5(88.29,191.31) 88.76,190.85 CPU1.AR23 ; CPU1.AV9 90.58,175.84 v5(91.05,176.3) 91.5,175.86 CPU1.AW9 ; VRAM1.T1 80.57,82.68 80.46,82.57 80.46,82.6 80.5,82.64 80.5,82.63 v5(80.46,82.59) ; v5(66.26,85.74) 66.49,85.96 66.66,85.96 66.69,85.99 66.98,85.99 VRAM2.M1 ; VRAM1.G8 v5(87.12,90.28) ; v5(87.12,90.28) VRAM1.G9 ; v5(87.12,90.28) VRAM1.F9 ; 60.44,101.04 60.84,100.65 VRAM5.F9 61.64,101.45 VRAM5.E8 61.65,101.44 62.42,101.44 62.42,101.45 VRAM5.D8 62.44,101.46 62.82,101.84 62.83,101.84 v5(62.84,101.85) ; 60.44,101.04 60.43,101.04 VRAM5.G9 60.04,100.27 v5(59.88,100.11) ; 60.44,101.04 60.44,101.04 VRAM5.G8 ; CPU1.J12 64.46,178.96 64.49,178.96 v5(64.52,179) ; v2(145.51,71.67) 145.13,72.05 U2.AL11 ; v2(145.51,71.67) 145.94,72.1 U2.AN11 ; v2(145.51,71.67) 145.81,71.67 146.05,71.43 U2.AN10 ; v2(145.51,71.67) 145.36,71.67 145.13,71.44 U2.AL10 ; CPU1.AT8 88.75,174.91 v5(88.29,174.45) 88.74,174 CPU1.AT7 ; v5(82.84,200.41) 83.27,200.84 CPU1.AJ34 ; v5(59.65,120.69) 59.68,120.71 59.78,120.71 60.04,120.97 VRAM6.G1 ; v2(84.65,186.73) 84.21,187.17 CPU1.AK19 ; v5(82.31,93.48) 82.71,93.88 VRAM1.B3 ; CPU1.N33 68.64,199.75 v2(69.1,199.28) ; GPU1.AB11 83.96,117.18 v5(84.02,117.18) ; CPU1.AT10 88.76,176.67 v5(89.18,176.24) 88.77,175.82 CPU1.AT9 ; v5(65.24,115.08) 65.23,115.08 64.84,114.69 VRAM6.A9 ; GPU1.AE20 76.16,120.02 76.54,120.4 v5(76.54,120.41) 76.49,120.41 76.12,120.78 GPU1.AF20 ; v5(62.02,105.85) 62.02,105.87 61.64,106.24 VRAM5.E2 ; CPU1.F1 v2(61.32,167.87) ; GPU1.AC2 91.49,118.37 91.51,118.35 v5(91.8,118.35) ; CPU1.AL21 85.1,189.03 v2(84.69,189.44) ; VRAM1.B9 88.09,93.88 v5(88.15,93.81) ; 66.85,167.91 66.85,168.47 CPU1.M1 ; v2(56.25,182.69) 56.71,183.14 CPU1.A17 ; CPU1.AW32 92.41,199.08 v5(92.9,199.56) ; v5(88.18,94.8) 88.05,94.68 VRAM1.A9 ; v5(74,108.02) GPU1.L23 ; v5(82.32,91.88) 81.92,91.48 VRAM1.E2 VRAM1.E1 ; CPU1.AK25 v2(84.64,193.11) ; VRAM2.P9 73.77,84.28 v5(74.04,84.01) ; VRAM2.B3 68.68,93.88 v5(68.29,93.48) ; U2.AU39 148.2,85.26 v2(148.4,85.06) ; CPU1.AK28 84.16,195.4 v5(83.71,195.85) ; CPU1.G8 62.71,174.44 v5(62.71,174.41) ; VRAM2.T1 67.06,82.68 66.57,82.18 v5(66.57,82.05) ; GPU1.K13 82.08,106.84 v5(82.49,106.43) ; CPU1.AT14 89.63,182.6 v5(89.21,183.01) ; v5(80.71,120.42) 80.73,120.42 81.08,120.08 GPU1.AE14 ; VRAM1.D8 v5(87.12,91.88) VRAM1.E8 ; CPU1.AN36 v5(86.43,202.22) CPU1.AM35 ; GPU1.AC22 GPU1.AD22 GPU1.AD21 75.31,119.22 v5(75.7,119.61) ; GPU1.N10 85.08,109.93 v5(84.62,110.39) 84.09,110.92 GPU1.P11 ; v5(59.95,185.43) CPU1.E19 ; v5(54.62,114.09) 54.44,114.27 VRAM6.P9 ; VRAM6.D8 v5(62.04,115.08) VRAM6.E8 ; v5(90.59,115.45) 90.59,115.5 90.97,115.88 GPU1.Y2 ; v2(86.48,189.39) 86.48,189.46 CPU1.AN22 87.04,190.03 87.04,190.71 CPU1.AN23 ; v2(83.68,191.3) 83.71,191.3 CPU1.AK23 ; GPU1.AB17 78.59,117.58 78.28,117.26 78.28,117.23 v5(78.23,117.18) ; v2(93.26,106.01) 93.22,105.96 GPU1.H2 ; v5(84.66,192.23) 85.1,191.79 CPU1.AL24 ; GPU1.L2 91.38,108.44 v5(91.64,108.7) ; VRAM5.G1 60.04,107.62 ; CPU1.AB5 75.78,171.99 75.78,171.99 v5(75.5,171.71) ; GPU1.E11 83.56,103.42 v5(83.95,103.8) ; GPU1.AF1 91.78,121.42 v2(92.02,121.65) ; v2(57.97,185.86) 57.98,185.86 58.01,185.88 CPU1.C20 ; CPU1.AN8 86.04,174.91 v5(86.5,174.45) 86.04,174 CPU1.AN7 ; VRAM5.A9 VRAM5.B9 64.04,100.48 v5(63.73,100.17) ; CPU1.AK40 84.18,206.45 v5(83.76,206.87) ; v2(148.4,85.06) 148.83,85.49 U2.AY38 ; v2(148.4,85.06) 148.62,84.84 U2.AW37 ; v5(72.97,82.03) 73.01,82.03 73.49,82.5 VRAM2.T9 ; CPU1.A13 56.39,179.48 55.95,179.92 v2(55.95,179.95) ; v5(86.46,182.15) 86.91,182.6 CPU1.AN14 ; VRAM2.D1 67.49,91.88 v5(67.49,91.87) 67.48,91.87 VRAM2.E1 ; VRAM6.J8 v5(58.04,115.88) ; GPU1.R10 85.07,111.92 v5(84.59,112.4) 84.08,112.91 GPU1.T11 ; v5(80.44,93.89) 80.45,93.88 VRAM1.B1 ; v5(63.64,115.08) 64.04,114.68 VRAM6.B9 ; CPU1.AT25 89.77,192.75 90.48,192.75 CPU1.AU25 ; v5(72.29,175.58) 72.29,174.92 CPU1.V8 ; CPU1.L13 v5(66.35,179.94) ; GPU1.AG2 90.98,122.06 v4(91.23,122.31) ; CPU1.AL11 v5(84.64,179.4) ; 59.06,170.82 59.06,170.82 v5(59.06,170.8) ; 78.21,120.42 78.6,120.81 GPU1.AF17 ; 78.21,120.42 v5(78.19,120.42) ; 78.21,120.42 78.23,120.42 78.6,120.05 GPU1.AE17 ; v5(54.25,108.39) 54.25,108.32 54.44,108.13 VRAM5.P1 ; v2(64.95,167.6) 64.98,167.63 CPU1.K1 ; v5(80.39,85.92) 80.46,85.92 80.5,85.88 VRAM1.M1 ; VRAM1.E1 v5(80.5,91.48) ; VRAM1.E1 VRAM1.D1 ; VRAM6.T9 52.84,114.67 52.45,114.28 52.45,114.27 v5(52.44,114.26) ; CPU1.AJ32 83.19,199.06 v5(82.75,198.61) ; U173.1 20.85,159.55 v2(20.9,159.5) ; v5(64.45,121.58) 64.45,121.48 64.06,121.08 VRAM6.B1 ; CPU1.AY30 93.33,197.28 v2(92.89,197.72) 92.41,197.24 CPU1.AW30 ; VRAM6.E1 61.64,121.07 v5(62.04,120.68) 62.05,120.69 62.05,120.69 VRAM6.D1 ; VRAM1.J2 81.92,88.28 v5(82.32,87.89) ; CPU1.AK7 83.27,173.97 v5(82.77,173.47) ; v5(81.48,117.18) 81.48,117.18 GPU1.AB14 ; v5(64.24,104.92) 64.24,105.29 64.08,105.45 VRAM5.B3 ; v5(58.04,101.84) 58.43,101.45 VRAM5.J8 ; v5(90.59,113.83) 90.59,113.82 90.59,113.79 GPU1.U2 ; v5(88.93,113.82) 88.92,113.81 88.92,113.74 GPU1.U5 ; v5(89.22,180.26) 88.82,179.85 CPU1.AR11 ; v5(89.22,180.26) 89.67,180.71 CPU1.AT12 ; VRAM6.E2 61.64,120.28 v5(61.24,120.68) ; CPU1.L3 v5(65.44,169.88) ; CPU1.AR18 88.77,186.25 v5(89.25,185.77) 88.83,185.34 CPU1.AR17 ; v5(85.62,103.03) 85.65,103.03 GPU1.E8 ; v5(66.31,84.06) 66.53,84.28 VRAM2.P1 ; CPU1.AK15 84.18,183.46 v2(84.63,183.02) ; 58.45,172.05 58.75,171.75 v5(59.04,171.75) ; CPU1.AT15 89.67,183.47 v5(89.21,183.01) ; CPU1.R3 CPU1.P4 ; CPU1.E21 60.41,186.8 v5(59.99,187.22) ; VRAM6.P1 54.44,121.8 v5(54.44,121.81) ; CPU1.AR19 88.7,187.17 v5(88.28,187.59) ; v5(88.21,111.34) 88.58,110.97 GPU1.P5 ; v5(58.12,177.2) 57.91,177.2 57.91,177.2 57.43,177.2 56.97,177.65 CPU1.A11 ; v5(71.57,115.44) 71.57,115.49 71.18,115.88 GPU1.Y26 ; VRAM5.M9 56.04,100.1 55.31,99.38 v5(55.25,99.38) ; CPU1.AK17 84.18,185.35 v2(84.65,185.81) 84.21,186.25 CPU1.AK18 ; v5(73.16,116.3) 73.58,115.88 GPU1.Y23 ; CPU1.AJ33 83.21,199.97 v5(82.75,199.5) ; VRAM2.F9 v5(73.09,90.28) 72.69,89.88 VRAM2.G8 ; v5(65.44,170.8) CPU1.K4 ; CPU1.AD8 CPU1.AE8 v2(79.15,175.37) ; VRAM1.T9 v5(88.08,82.68) ; CPU1.AC6 76.9,173.08 v2(77.36,173.54) 77.78,173.96 CPU1.AD7 ; CPU1.AK29 84.13,196.31 v5(83.69,196.76) ; VRAM6.T1 52.84,121.53 v5(52.72,121.65) ; v5(57.21,173.54) CPU1.A7 ; 83.56,120.03 GPU1.AE11 ; v5(72.29,87.88) 72.31,87.88 72.69,88.26 VRAM2.J8 ; v5(81.52,90.28) 81.13,89.89 81.12,89.89 VRAM1.G1 80.52,89.88 v5(80.51,89.89) ; v5(56.17,107.83) 56.17,107.45 56.04,107.32 VRAM5.M1 ; v5(66.49,93.58) 66.78,93.88 VRAM2.B1 ; v5(83.74,197.7) 84.18,197.25 CPU1.AK30 ; CPU1.AY7 92.57,174 92.57,174.01 v2(92.99,174.43) ; v2(108.91,240.02) 108.96,239.97 Q1228.4 ; VRAM1.P1 80.55,84.28 v5(80.43,84.16) ; v5(73.63,121.82) 73.59,121.78 73.59,120.86 GPU1.AF23 ; VRAM6.G8 60.04,115.48 60.44,115.08 v5(60.44,115.04) ; CPU1.N3 v5(67.27,169.88) ; CPU1.J6 v5(63.61,173.54) ; CPU1.AW36 92.43,202.71 92.97,203.25 v5(93.54,203.25) ; v5(89.21,183.01) 88.8,182.6 CPU1.AR14 ; CPU1.AM38 86.01,204.51 v5(86.47,204.06) 86.04,203.63 CPU1.AM37 ; v5(61.78,183.6) CPU1.G17 ; GPU1.AB20 v5(76.52,117.18) ; GPU1.Y5 88.58,115.9 88.93,116.24 88.97,116.24 v5(88.98,116.25) ; CPU1.C18 58.18,183.65 v5(58.11,183.65) ; GPU1.P2 90.98,110.98 v5(90.62,111.34) ; v5(76.57,119.6) 76.94,119.22 GPU1.AD19 GPU1.AD18 ; CPU1.AN9 86.06,175.82 v5(86.53,176.29) 86.09,176.74 CPU1.AN10 ; CPU1.AL14 85.09,182.6 v5(84.67,182.17) 84.18,181.69 CPU1.AK13 ; v5(76.58,100.63) 76.19,101.02 GPU1.B20 ; VRAM6.M9 56.04,114.22 56.18,114.08 v5(56.18,114.08) ; CPU1.L6 v5(65.44,173.54) ; v5(67.27,170.8) CPU1.M4 ; CPU1.AM14 v5(85.56,182.14) ; v5(71.82,173.54) 71.82,173.52 CPU1.U6 ; CPU1.AW34 CPU1.AV34 ; v2(83.73,180.31) CPU1.AK12 ; VRAM6.M1 56.04,121.79 v5(56.01,121.82) ; CPU1.E13 59.97,179.92 v5(59.97,179.93) ; VRAM1.J8 v5(86.32,87.88) ; CPU1.AR16 88.76,184.41 v5(89.21,183.96) ; VRAM5.E1 61.64,107.05 v5(62.03,106.65) 62.43,107.05 VRAM5.D1 ; v5(85.53,114.38) 85.08,113.93 GPU1.U10 ; CPU1.U3 v5(70.93,169.88) ; GPU1.AD16 79.44,119.24 v5(79.82,119.62) 80.22,119.22 GPU1.AD15 ; GPU1.AB24 72.78,117.57 v5(72.4,117.95) ; VRAM1.P9 v5(88.12,84.28) ; CPU1.G3 v5(61.78,169.88) ; CPU1.AK20 v2(83.73,188.54)
  TOP w0.381: CPU1.U33 v2(72.3,199.31) ; CPU1.AM34 CPU1.AM35 ; CPU1.AR30 88.76,197.29 v5(88.34,197.71) ; CPU1.M27 v2(67.27,191.83) ; v5(92.75,169.8) 92.75,170 CPU1.AY3 ; CPU1.AR32 88.76,199.15 v5(89.22,199.62) ; CPU1.C8 v5(58.12,174.45) ; CPU1.C35 v2(59.95,201.34) ; CPU1.R33 70.47,199.32 v2(70.46,199.31) ; CPU1.E6 60.7,172.79 60.7,172.72 v5(60.82,172.6) ; U9621.3 99.83,111.68 99.76,111.62 99.76,111.37 v2(99.64,111.24) ; v5(89.21,201.35) 89.67,200.88 CPU1.AT34 ; v5(89.21,201.35) 88.76,201.8 CPU1.AR35 ; v5(89.21,201.35) 88.76,200.89 CPU1.AR34 ; CPU1.K30 v2(65.44,194.57) ; CPU1.F22 v5(60.87,188.17) CPU1.E23 ; CPU1.E35 v2(61.78,201.34) ; CPU1.C31 v2(59.95,197.68) ; CPU1.K24 v2(65.44,189.08) ; CPU1.AG1 CPU1.AG2 80.55,169.42 v5(81,169.87) 80.54,170.34 CPU1.AG3 ; v5(88.34,197.71) 87.85,197.23 CPU1.AP30 ; v5(88.34,197.71) 88.76,198.13 CPU1.AR31 ; 81.02,202.28 80.58,202.71 CPU1.AF36 ; 81.02,202.28 81.02,202.29 CPU1.AG36 ; 81.02,202.28 v5(81.02,202.22) ; CPU1.L32 v2(66.35,199.51) CPU1.K33 ; CPU1.M35 v2(68.18,201.34) ; v5(86.49,192.23) 86.49,192.22 ; 86.49,192.22 86.93,191.79 CPU1.AN24 ; 86.49,192.22 86.49,192.22 CPU1.AM24 ; CPU1.J20 v5(63.61,186.34) CPU1.H21 ; CPU1.AK6 82.84,172.65 82.83,172.65 82.36,172.18 CPU1.AJ5 82.59,171.93 82.62,171.93 v5(82.86,171.69) ; CPU1.K19 v5(65.44,184.51) ; CPU1.AA33 v2(75.95,199.31) ; v5(90.16,201.33) 90.58,200.91 CPU1.AU34 ; CPU1.G31 v2(63.61,197.68) ; CPU1.AR33 88.87,199.97 v5(89.22,199.62) ; v5(62.7,180.85) CPU1.G15 ; CPU1.AM30 86,197.24 86,197.25 v5(85.56,197.69) 85.12,197.25 85.12,197.25 CPU1.AL30 ; v5(63.61,170.8) CPU1.H4 ; v5(89.01,100.62) 88.93,100.62 GPU1.B5 ; CPU1.C33 v2(59.95,199.51) ; CPU1.M15 v5(67.27,180.85) ; GPU1.E5 88.53,103.62 88.28,103.87 88.26,103.87 v5(88.18,103.95) ; CPU1.W33 v2(74.13,199.31) ; CPU1.D30 v2(59.95,194.57) ; CPU1.T39 v2(71.84,205) ; v5(92.16,103.57) 91.08,103.57 GPU1.E2 ; CPU1.E31 v2(61.78,197.68) ; CPU1.F26 v2(61.78,190.91) ; CPU1.AM33 v5(86.47,199.51) CPU1.AM32 ; CPU1.AC35 v2(77.33,201.34) ; CPU1.K35 v2(66.35,201.34) ; CPU1.M23 v2(67.27,188.17) ; v5(65.44,175.37) CPU1.L9 ; CPU1.V35 v2(73.67,201.34) ; GPU1.B1 v2(92.4,101.02) ; CPU1.B30 v2(58.12,194.57) ; v5(61.78,185.43) CPU1.G19 ; CPU1.N8 v5(67.27,174.45) CPU1.M7 v5(67.27,173.54) CPU1.N6 ; CPU1.M19 v2(67.27,184.51) ; v5(88.23,203.18) 88.22,203.17 88.22,203.09 CPU1.AP36 ; CPU1.M25 v2(67.27,190) ; v5(61.78,170.8) CPU1.F4 ; CPU1.F30 v2(61.78,194.57) ; CPU1.M39 v2(68.18,205) ; v5(65.44,173.54) CPU1.K7 ; CPU1.M29 v2(67.27,193.66) ; CPU1.AC33 77.78,199.72 v2(78.11,199.39) ; CPU1.C37 v2(59.04,204.08) CPU1.B38 ; CPU1.M21 v2(67.27,186.34) ; CPU1.D24 v5(59.04,190) ; v5(89.26,172.62) 89.63,172.25 89.63,172.21 CPU1.AU5 ; CPU1.AL1 CPU1.AL2 84.07,169.54 84.07,170.22 CPU1.AL3 CPU1.AL4 CPU1.AL5 83.74,172.61 v5(83.74,172.65) 83.27,172.18 CPU1.AK5 ; CPU1.K26 v2(65.44,190.91) ; v5(61.78,179.05) 61.81,179.09 61.85,179.09 CPU1.G13 ; CPU1.H28 v2(63.61,192.74) ; CPU1.M17 v2(67.27,182.68) ; CPU1.H24 v2(63.61,189.08) ; GPU1.K17 GPU1.L18 77.08,108.05 76.35,108.79 v5(76.24,108.79) ; CPU1.AD33 78.7,199.96 v2(79.19,199.46) 79.61,199.88 CPU1.AE33 ; v5(63.59,184.52) 64.06,184.05 CPU1.J18 ; CPU1.J34 v2(64.52,201.34) CPU1.H35 ; CPU1.K17 v5(65.44,182.68) ; CPU1.AG4 80.52,171.25 v5(80.08,171.69) ; v5(86.42,173.49) CPU1.AN6 ; CPU1.H26 v2(63.61,190.91) ; v5(89.22,199.62) 89.27,199.56 89.27,199.45 CPU1.AT32 ; v2(80.11,175.43) 80.53,175.01 CPU1.AG8 ; CPU1.AT6 88.68,173.08 v5(88.25,172.65) 88.73,172.17 CPU1.AT5 ; v2(79.17,171.7) 79.61,172.14 79.61,172.16 ; CPU1.H37 v2(64.52,203.17) ; v5(59.95,183.6) CPU1.E17 ; CPU1.B6 57.22,172.64 v5(57.22,172.64) ; 79.61,172.16 v5(80.08,171.69) ; 79.61,172.16 CPU1.AF5 ; v5(80.08,171.69) 80.53,172.14 CPU1.AG5 ; v5(59.96,169.9) 60.4,170.34 CPU1.E3 ; CPU1.V39 v2(73.67,205) ; CPU1.J10 v5(63.61,177.2) ; v5(63.61,173.54) CPU1.H7 ; CPU1.Y37 v2(75.5,203.17) ; CPU1.AJ36 83.27,202.7 v5(83.73,202.24) 84.18,202.7 CPU1.AK36 ; CPU1.P37 v2(70.01,203.17) ; CPU1.K22 v2(65.44,187.25) ; CPU1.AD6 77.78,173.12 v2(77.36,173.54) ; CPU1.E15 v5(60.87,180.85) ; CPU1.J32 v2(65.44,198.6) ; CPU1.D28 v2(59.95,192.74) ; CPU1.D37 v2(59.95,204.08) ; CPU1.K39 v2(66.35,205) ; CPU1.AT25 CPU1.AT26 ; 58.45,172.05 CPU1.C5 ; CPU1.E37 v2(60.87,204.08) ; CPU1.C16 v5(59.04,182.68) ; CPU1.F28 v2(61.78,192.74) ; v5(84.66,106.51) 84.61,106.51 84.2,106.92 GPU1.K11 ; CPU1.T37 v2(71.84,203.17) ; v5(91.04,196.74) 91.04,196.77 CPU1.AU30 89.74,197.23 89.71,197.19 ; CPU1.AM36 86.01,202.78 v5(85.6,203.2) 85.58,203.2 CPU1.AL36 ; CPU1.L11 v5(66.35,177.2) CPU1.M10 ; CPU1.K28 v2(65.44,192.74) ; CPU1.P35 v2(70.01,201.34) ; CPU1.B26 v5(58.12,190.91) ; v5(90.99,195.87) 91.07,195.79 91.11,195.79 CPU1.AV28 ; CPU1.AG33 v2(80.98,199.51) ; CPU1.AW3 91.07,169.91 v5(91.03,169.91) ; CPU1.Y35 v2(75.5,201.34) ; CPU1.D7 v5(59.04,173.54) ; CPU1.J16 v5(64.52,181.77) ; GPU1.AB7 86.88,117.49 86.99,117.38 86.99,116.93 86.88,116.82 GPU1.AA7 ; GPU1.E17 78.64,103.42 79.03,103.82 v5(79.03,103.88) ; CPU1.E11 v5(59.95,177.2) ; CPU1.E33 v2(61.78,199.51) ; CPU1.AF8 v2(79.15,175.37) ; v5(81.9,199.51) CPU1.AH33 ; CPU1.K37 v2(66.35,203.17) ; CPU1.B28 v2(58.12,192.74) ; CPU1.V37 v2(73.67,203.17) ; CPU1.G33 v2(63.61,199.51) ; GPU1.B8 86.04,101.01 86.4,100.64 v5(86.44,100.64) ; CPU1.H30 v2(63.61,194.57) ; CPU1.H39 v2(64.52,205) ; CPU1.P39 v2(70.01,205) ; CPU1.M37 v2(68.18,203.17) ; 59.06,170.82 CPU1.D4 ; CPU1.T35 v2(71.84,201.34) ; CPU1.AA8 v5(75.5,175.37) ; CPU1.D26 v2(59.95,190.91)
  TOP w0.4: GPU1.A26 70.77,99.81 70.27,99.81 v5(70.17,99.91) 70.03,100.05 70.03,100.67 GPU1.B27 ; VRAM6.B3 64.04,119.44 63.1,118.5 63.05,118.5 v5(62.98,118.43) ; v5(75.73,103.03) 75.97,103.27 75.97,103.27 GPU1.E20 ; VRAM2.A9 74.09,94.68 v5(74.09,94.68) 74.09,94.48 VRAM2.B9 ; GPU1.L25 72,108.42 72.01,108.42 v5(72.39,108.04) ; v5(71.57,103.06) GPU1.E25 ; v5(68.29,87.87) 68.26,87.9 68.26,87.9 VRAM2.J2 ; v5(79.02,101.45) 79.02,101.44 78.96,101.38 GPU1.B17 ; GPU1.P23 73.59,110.92 73.98,110.53 v5(73.98,110.48) ; GPU1.B23 73.51,100.9 73.51,100.28 v5(73.68,100.11) ; v5(52.78,100.02) 52.78,100.03 52.84,100.09 VRAM5.T9 ; v5(54.55,100.04) 54.44,100.14 VRAM5.P9 ; v5(74,113.85) 74,113.81 73.59,113.4 GPU1.U23 ; GPU1.E22 74.03,103.87 v5(74.03,103.95) ; GPU1.E14 81.07,103.42 80.71,103.78 v5(80.67,103.78) ; GPU1.B14 81.14,101.02 81.39,100.77 81.39,100.52 v5(81.37,100.5) ; GPU1.H23 v5(73.19,105.57)
  TOP w0.406: v5(88.28,187.59) 88.76,188.06 CPU1.AR20 ; GPU1.K15 80.06,106.92 v2(79.61,107.37) 79.08,107.9 GPU1.L16 ; U2.BC1 151.02,66.74 151.33,66.43 v2(151.33,66.34) ; v2(23.21,107.68) 24.63,107.68 25.83,108.89 Q6701.1 ; v2(92.7,129.85) 92.6,129.85 92.41,129.66 Q9632.1 ; GPU1.N16 79.07,109.92 v2(78.6,110.39) 78.08,110.91 GPU1.P17 ; U15.3 188.82,115.56 v2(188.84,115.58) ; v2(89.85,132.19) 89.81,132.19 89.27,131.66 Q9632.4 ; CPU1.AV30 91.5,197.2 v5(91.04,196.74) ; CPU1.AR27 88.76,194.49 v5(89.19,194.92) ; Q9633.4 95.4,132.4 v2(95.45,132.45) ; CPU1.AH37 82.36,203.65 v5(82.79,204.09) ; Q23.4 50.56,41.43 v2(50.56,41.39) ; Q23.1 53.09,43.93 53.43,43.93 53.49,43.88 v2(53.53,43.88) ; CPU1.AT25 89.64,192.65 v5(89.18,192.2) ; v2(88.28,194.04) CPU1.AP27 ; CPU1.AT29 89.67,196.12 89.73,196.05 89.73,195.59 89.67,195.53 CPU1.AT28 89.66,195.4 v5(89.19,194.92) ; CPU1.AM27 v5(85.56,194.03) CPU1.AL27 ; GPU1.V17 GPU1.U16 79.22,113.92 v2(79.69,113.45) 80.08,113.06 GPU1.T15 ; U16.8 v2(187.9,94.73) ; CPU1.AT27 89.62,194.48 v5(89.19,194.92) ; Q10.1 95.59,60.58 95.32,60.31 94.7,60.31 94.29,59.9 Q10.4 93.43,59.37 v2(93.27,59.21) ; CPU1.G11 v5(61.78,177.2) CPU1.F10 ; Q1233.4 v2(36.4,153.22) ; v2(98.49,129.78) 98.38,129.89 Q9633.1 ; GPU1.R16 79.23,111.92 v2(79.73,111.42) 80.07,111.07 80.07,110.93 GPU1.P15 ; v2(30.9,109.07) 30.61,109.07 28.39,111.29 Q6701.4 ; v2(87.37,194.04) CPU1.AN27 ; GPU1.M17 78.08,108.92 v2(78.6,108.41) ; v2(39.17,155.1) Q1233.1 ; GPU1.M15 80.08,108.91 v2(80.55,108.44) 81.07,107.92 GPU1.L14 ; CPU1.AT30 89.71,197.19 ; CPU1.M12 67.25,179.01 v5(67.25,179.03) ; v2(77.33,201.34) CPU1.AC34 ; CPU1.R8 v5(69.1,174.45) ; v2(80.98,199.51) CPU1.AF33
  TOP w0.432: CPU1.AJ8 82.29,174.91 v2(81.55,175.65) 81.44,175.54 CPU1.AH8 ; CPU1.AK9 83.25,175.82 v2(82.62,176.46) 82.89,176.74 CPU1.AK10 ; CPU1.H8 v5(63.61,175.37)
  TOP w0.457: GPU1.U14 81.08,113.89 v5(81.56,113.4) 82.05,112.92 GPU1.T13 82.59,112.41 v5(82.59,112.34) 83.01,111.92 GPU1.R12 ; GPU1.U12 83.19,113.92 v5(83.64,114.37) 84.08,114.81 GPU1.V11 ; v5(81.65,115.37) 81.65,115.35 GPU1.V13 ; GPU1.V17 78.07,114.92 77.63,114.48 v5(77.61,114.48) 77.08,113.95 GPU1.U18 ; GPU1.T17 77.71,112.55 v5(77.58,112.55) 77.58,112.42 GPU1.R18 ; v5(76.56,110.4) 76.72,110.4 77.08,110.05 GPU1.N18 ; GPU1.L10 85.08,108.05 v5(84.65,108.48) 84.21,108.92 GPU1.M11 ; v5(79.62,115.37) 79.7,115.28 79.71,115.28 80.07,114.92 GPU1.V15 ; GPU1.R14 81.13,111.92 v5(81.59,111.47) 82.08,110.97 GPU1.P13 82.08,110.91 v5(82.56,110.43) 83.07,109.92 GPU1.N12 ; GPU1.N14 81.12,109.92 v5(81.62,109.42) 82.08,108.96 GPU1.M13 82.1,108.92 v5(82.65,108.37) 83.08,107.94 GPU1.L12 ; v5(91.55,100.22) GPU1.A2
  TOP w0.508: v2(2.61,15.48) 2.84,15.25 C12101.2 ; v2(178.25,72.5) 178.69,72.95 Q18.E ; v2(106.26,98.41) 106.7,98.84 PR8312.2 ; v2(20.82,18.71) 20.82,18.93 20.26,19.49 R9505.2 ; v2(151.2,119.37) 151.2,120.19 R147.2 C12150.2 ; v2(158.97,83.53) 158.93,83.49 158.98,83.44 159.86,83.44 R79861.2 ; v4(69.92,194.42) 70.02,194.52 C83.2 ; v2(47.69,98.92) 47.76,98.98 C12417.2 ; v2(60,23.47) 60.09,23.38 U9614.2 ; v2(21.79,165.34) 21.34,164.9 R79948.2 ; v2(171.07,26.65) 171.07,27.64 C252.2 ; C6712.2 53.99,97.65 v5(54.37,97.27) ; v2(78.86,61.56) 78.94,61.48 R512.2 ; R1780.2 32.39,119.37 31.69,119.37 v2(31.57,119.49) ; v2(150.24,96.99) 150.16,96.99 150.12,97.03 C146.2 ; v2(136.34,22.49) 136.37,22.49 136.85,22.97 U5201.4 ; v2(97.73,26.02) 96.91,25.2 RJ1.13 ; PR5523.2 v5(78.3,77.08) 78.87,77.08 PR246.2 ; C11837.2 127.34,94.11 128.14,94.91 C11888.2 128.14,96.2 128.95,97.01 v2(128.95,97.24) ; R728.2 v2(132.15,253.22) ; R79748.2 v2(56.58,23.23) 56.58,23.1 56.2,22.72 C279.2 ; C12243.2 42.04,126.73 R52.2 42.19,126.88 v2(44.37,126.88) ; CN3.4 v2(174.27,91.62) 174.69,91.2 CN3.6 ; v2(123.77,72.2) 123.75,72.19 C157.2 ; C204.2 13.66,166.23 14.04,165.85 v2(14.67,165.85) ; C11839.2 135.45,64.39 v2(135.86,64.8) ; PC95.2 v2(126.43,225.41) ; C148.2 v2(86.62,80.25) ; R79764.2 19.37,22.66 v2(19.37,23.2) ; v2(150.31,50.02) 150.25,49.96 C12205.2 ; v2(149.05,102.41) 149.11,102.48 150.35,102.48 Q2.E ; R9508.2 53.41,6.78 v2(53.41,6.21) ; C837.2 102.48,120.71 v2(102.43,120.76) ; C522.2 16.9,132 15.98,131.09 v2(15.98,131.08) ; C3367.2 142.39,44.11 142.44,44.06 v2(142.52,44.06) ; v5(83.13,119.59) 83.56,120.03 GPU1.AF11 ; C12383.2 91.2,93.13 v2(90.98,92.9) ; v2(28.9,50.15) 29.53,50.79 29.79,50.79 29.85,50.85 R79950.1 ; GPU1.AG26 71.18,121.77 71.7,122.29 v2(72.08,122.29) ; R79875.2 158.95,82.64 158.95,81.93 158.92,81.9 v2(158.92,81.85) ; v5(149.72,183.73) 149.72,183.29 148.88,182.45 ; PC155.2 107.18,125.84 v2(105.48,125.84) ; v2(178.38,24.88) 177.5,24 SPK1.8 ; v2(112.87,129.55) 112.72,129.55 112.36,129.91 PC152.2 ; v2(36.9,103.69) 36.9,103.57 36.25,102.92 PC56.2 ; D9.2 v2(189.05,109.21) ; C12334.2 81.06,19.94 80.16,20.84 v2(80.16,21.83) ; C371.2 79.03,71.04 79.19,70.88 v2(79.39,70.88) ; DIMM1.206 v2(140.18,134.2) ; PC3.2 27.94,138.1 v2(27.76,137.91) ; PC158.2 98.62,124.45 v2(99,124.07) ; v2(180.03,74.98) 180.41,74.98 181.11,75.68 Q16.3 ; v2(166.82,62.43) 166.82,63.35 X2.2 ; v2(166.82,62.43) 167.72,62.43 167.96,62.67 X2.3 ; v2(166.82,62.43) 166.82,62.37 166.59,62.37 166.06,61.84 R228.2 ; R379.1 168.93,46.77 v2(168.5,46.34) 167.77,46.34 C12200.2 ; R7917.2 113.99,44.72 114.45,44.26 v2(114.45,44.08) ; v2(51.05,45.47) 50.93,45.58 R440.2 C282.2 ; C372.2 81.13,57.43 v2(80.84,57.14) 80.12,56.42 Q30.S 81.58,55.12 R510.2 ; v2(27.12,141.74) 27.25,141.62 PC1.2 ; R79717.2 4.16,17.41 v2(4.13,17.39) ; v2(171.42,59.17) 171.49,59.24 172,59.24 172.05,59.3 C224.2 ; R49.2 52.52,131.81 53.08,131.25 v2(53.16,131.25) ; v2(49.73,35.67) 50.97,35.67 X3.4 ; R79824.1 182.25,40.37 182.5,40.12 v2(182.52,40.12) ; C12052.2 R79773.2 155.6,58.93 v2(155.6,59.36) ; v2(43.12,107.68) PC8613.2 ; C7521.2 v2(47.57,115.94) 47.82,116.19 C12437.2 ; C9520.2 46.35,22.61 46.37,22.61 46.37,22.24 v2(46.35,22.21) ; v2(90.37,27.93) 90.56,28.12 C3453.2 ; NGFF1.76 125.78,226.07 v2(125.8,226.05) ; C281.2 57.35,23.93 v2(57.35,22.85) ; C12123.2 54.6,15.98 R9563.2 53.64,15.98 v2(53.5,16.12) ; C12438.2 67.22,77.46 v5(67.29,77.52) ; v2(140.81,34.05) 140.66,33.9 D11.2 ; C6711.2 51.63,95.72 v2(51.12,95.21) ; v2(115.51,32.6) 115.51,33.32 C341.2 ; v2(74.9,35.7) 74.9,33.65 PC5237.1 ; PU5302.1 103.18,132.43 v2(103.19,132.45) ; Q12.S 182.76,33.32 v2(182.12,33.96) R388.2 ; v2(78.02,94.22) 78.02,94.03 C6714.2 C163.2 ; v2(148.28,243.32) 148.34,243.25 C519.2 ; v2(14.8,166.86) 13.48,168.18 C12326.2 ; C12217.2 154.31,20.5 v2(154.12,20.69) ; C12242.2 30.23,122.1 v2(31.69,120.64) R1789.2 ; v2(121.26,73.64) 121.42,73.48 X1.2 ; PR4474.2 42.17,238.05 v2(42.49,237.73) ; v2(22.29,172.33) 22.23,172.33 21.79,172.77 PC63.2 ; v2(20.26,132.07) 20.83,132.07 PC6.1 ; R54.2 41.15,137.97 v2(40.58,138.54) 40.58,138.99 R58.2 ; WEBCM1.6 171.41,210.09 v2(171.41,208.77) ; PC81.2 29.15,74.38 29.28,74.51 v2(29.28,75.12) ; C12388.2 70.17,78.15 v5(70.17,77.33) ; PR14.2 v2(20.29,133.84) ; C524.2 22.56,18.46 v2(22.55,18.45) ; v2(71.7,130.67) 71.95,130.42 C420.2 ; R722.2 119.12,228.6 v2(119.08,228.56) ; C12190.2 43.78,52.64 v2(43,52.64) ; Q63.E 48.01,10.74 47.99,10.74 v2(47.99,10.72) ; C12341.2 28.01,133.02 PC11.2 27.76,132.07 v2(27.12,131.43) 26.17,132.38 PR18.2 ; v2(68.19,48.93) 68.19,48.98 68.04,49.14 LED2.K ; C7503.2 v2(48.08,97.01) ; C12189.2 48.08,41.32 47.45,40.69 C12188.2 46.31,40.69 v2(45.92,40.3) ; v2(74.92,180.12) 74.92,179.92 75.38,179.46 C91.2 ; R372.2 173.49,65.56 174.01,65.04 v2(174.11,65.04) ; v2(20.9,159.5) 20.9,160.45 C12055.2 ; v2(142.06,95.87) C12164.2 ; PC12187.2 153.56,224.08 153.55,224.09 v2(152.72,224.09) ; v2(53.79,254.49) 53.66,254.37 PR4414.1 PC4414.2 ; R47.2 R48.2 40.9,131.18 v2(39.44,131.18) ; v5(61.92,109.59) 62.05,109.71 C6704.2 ; v2(46.3,138.92) 46.3,136.19 R1782.1 ; PR8320.2 96.52,108.43 96.27,108.69 v2(96.27,109.33) 96.5,109.56 97.3,109.56 PC8301.2 ; R79756.2 41.15,16.18 41.55,15.79 v2(41.55,15.76) ; C356.2 v2(127.2,40.12) ; C528.2 C12238.2 v2(22.55,21.51) ; v2(106.91,67.42) 106.89,67.45 106.89,67.77 106.88,67.78 106.88,67.99 R321.2 ; C64.2 v4(60.39,229.22) ; X5.4 92.78,92.17 v2(92.04,91.43) ; v2(47.89,29.58) 47.85,29.61 48.51,30.28 R9519.1 ; PC8612.2 43.71,110.5 v2(44.54,111.34) 44.57,111.34 44.6,111.37 PR235.2 ; C12187.2 46.45,26.82 v2(46.45,26.12) 46.55,26.02 C12185.2 ; v2(13.71,12.89) 13.71,14.21 13.02,14.9 R79697.1 ; R79989.2 R243.2 v2(100.4,94.98) ; v2(164.74,212.73) 165.01,213 WEBCM1.10 ; R79811.2 C12223.2 26.18,54.72 v2(26.74,54.17) 26.74,53.59 27.12,53.21 Q103.S ; PR4417.2 39.5,236.76 38.93,236.19 v2(38.93,236.16) ; C333.2 124.4,23.05 v2(124.4,22.34) ; v2(56.84,33.13) 56.65,33.13 56.33,33.45 C284.2 ; R79978.2 73.6,125.08 73.6,125.21 v2(72.84,125.97) ; v2(50.49,26.28) 50.49,27.07 50.74,27.32 Q26.E ; v2(138.5,224.78) 138.12,225.16 C516.2 ; v2(140.66,225.67) 140.53,225.79 C515.2 ; v2(42.61,120.33) 42.61,120.39 42.04,120.95 R32.2 ; v2(156.66,11.42) 156.72,11.35 R5205.1 ; C332.2 122.88,21.83 v2(123.39,22.34) 122.88,22.85 C340.2 ; PC159.2 100.65,124.19 v2(100.53,124.07) ; X5.2 94.3,96.63 v2(94.3,96.63) ; v2(77.01,62.44) 76.69,62.13 Q31.S ; v2(165.3,89.27) 165.68,89.27 166.06,89.65 C202.2 ; R464.2 v2(127.2,27.29) ; v2(148.28,124.27) 148.44,124.12 PC105.2 ; C223.2 172.28,56.25 173.14,56.25 v2(173.17,56.22) C222.2 ; CN3.5 173.7,96.31 173.7,96.93 R472.2 173.42,97.14 v2(172.15,95.87) ; v2(97,28.36) 96.69,28.36 96.39,28.05 U9624.2 ; PC4428.2 37.85,255.83 v2(37.66,256.02) 37.6,255.95 PC4402.2 ; Q9626.S v2(182.57,31.42) ; v2(102.01,107.3) 102.05,107.3 102.18,107.17 PC8501.2 102.22,106.44 101.5,106.44 PC8311.2 ; C216.2 170.69,52.61 v2(170.88,52.79) 170.9,52.82 C217.2 ; PR229.2 101.25,133.39 101.42,133.38 102.3,132.49 v2(102.3,132.41) ; PR5522.2 94.87,101.9 94.43,102.35 v2(94.3,102.35) ; D13.1 51.89,30.94 v2(51.89,30.21) ; v2(45.87,42.74) 46.14,42.47 R79797.2 ; R79998.2 v2(47.69,113.65) ; C12201.2 153.71,52.57 153.79,52.65 v2(153.79,52.97) ; R80060.1 v2(102.27,115.9) 102.38,116.01 PC8306.2 ; v2(180.56,90.76) 180.54,90.76 R466.2 R471.2 ; NGFF1.77 125.78,249.18 v2(125.16,249.8) ; v5(92.27,168.26) 91.91,167.9 90.28,167.9 CPU1.AU1 ; D10.2 127.32,35.11 v2(127.27,35.17) ; v2(31.51,114.44) 30.71,114.44 C12239.2 ; U11.2 64.2,22.75 63.98,22.97 v2(63.98,23.23) ; v2(159.57,8.88) 159.12,8.43 R5202.1 R5203.1 ; C6702.2 36.39,114.05 v2(36.39,114.04) ; Q64.S 37.83,5.66 v2(38.3,5.19) ; v2(137.99,228.97) 136.82,228.97 C514.2 ; C278.2 54.43,22.69 v2(54.48,22.64) ; C12419.2 51.16,92.78 v5(50.54,92.16) ; R100.2 134.88,94.94 134.77,95.06 134.77,95.82 v2(134.71,95.87) R1663.2 ; PC43.2 v2(11.25,234.53) ; Q1228.1 111.78,241.84 v2(111.83,241.79) ; C413.2 66.46,125.31 v2(66.36,125.21) ; C160.2 163.29,67.99 v2(163.01,68.27) ; v2(57.73,7.1) 57.09,6.46 56.46,6.46 ; v2(73.75,76.76) 73.65,76.86 C7504.2 ; PWRCN1.12 33.75,15.69 33.22,16.22 31.21,16.22 v2(30.3,17.13) ; CPU1.A4 57.2,170.8 v5(57.22,170.8) ; U5201.1 v2(136.59,26.78) R469.2 ; v1(16.2,137.78) 14.55,137.78 v4(13.15,136.38) ; R2086.2 166.19,44.31 165.96,44.54 v2(165.93,44.54) ; Q1266.E 55.44,20.87 v2(55.44,21.58) ; D5.A 178.01,71.11 v2(178.33,71.42) R79822.1 ; v2(79.22,40.19) 79.19,40.22 79.19,39.56 79.06,39.43 C357.2 ; v2(13.4,235.32) v2(12.22,235.32) ; 150.69,191.55 149.88,191.55 149.14,192.3 v5(149.14,192.47) ; v5(62.89,111.58) 62.89,111.09 C12393.2 ; v2(172.34,101.42) 172.34,101.42 PC107.2 ; v2(42.87,145.2) 42.2,144.54 40.81,144.54 39.96,145.39 39.76,145.39 R59.2 R152.2 ; C334.2 v2(127.2,26.15) ; R229.2 160.06,58.62 160.06,58.78 159.78,59.07 159.56,59.07 v2(159.33,59.3) ; R79823.1 v2(187.9,67.8) ; v2(9.9,164.73) 9.85,164.73 9.56,164.44 Q1227.S ; PC8317.2 98.57,106.15 98.57,106.69 v2(98.62,106.74) ; v2(60.9,34.1) 60.78,33.97 C299.2 C298.2 ; v2(108.65,72.22) 109.31,72.22 C12126.2 ; PR8621.2 40.2,104.35 v2(40.23,104.38) 40.11,104.38 39.87,104.62 PR8338.2 ; v5(80.71,120.42) 81.08,120.8 GPU1.AF14 ; PR232.2 44.57,112.38 v2(44.54,112.36) 44.37,112.53 PC8609.2 ; C186.1 100.97,47.8 v2(100.5,47.33) 100.27,47.1 99.73,47.1 99.41,46.79 R80215.2 99.37,46.77 98.24,46.77 C187.2 ; v2(96.46,124.15) 96.46,124.19 96.59,124.32 PC156.2 ; PC4431.2 17.15,165.66 v2(17.21,165.59) 16.58,164.96 PR136.1 ; PQ4408.S v2(75.02,44.21) ; v2(41.98,13.32) 42.14,13.16 Q65.S ; v2(90.43,33.18) R423.1 ; v2(66.92,25.41) 67,25.49 C12121.2 ; v2(101.82,91.86) 102.04,91.86 102.79,91.11 104.46,91.11 104.75,91.39 Q9630.S ; PC73.2 34.25,74.34 v2(34.28,74.32) ; v2(45.92,44.82) 46.36,45.26 R79801.2 R79802.2 ; CONVT1.10A v2(32.58,8.75) ; PC39.2 v2(6.74,206.23) ; R764.1 v2(135.39,50.35) ; C159.2 165.36,71.36 164.92,71.36 164.55,71.73 164.55,72.25 v2(164.51,72.28) ; v2(142.94,17.51) 142.31,16.88 C12216.2 ; v2(153.51,60.88) 152.68,61.71 C156.2 ; v2(57.92,126.03) R80000.2 C12394.2 ; C54.2 v4(64.84,227.19) ; v2(35.68,152.39) 36.06,152.01 C12059.2 ; v2(167.2,40.37) 167.84,41.01 C12443.2 ; R35.1 62.4,138.67 62.4,138.67 62.5,138.67 v2(62.5,138.67) ; v2(135.71,23.1) 136.85,24.24 U5201.3 ; R61.2 R60.2 39.57,128.64 39.58,128.65 v2(39.71,128.65) 39.71,128.67 39.93,128.89 R50.2 ; R1991.2 44.73,148.77 v2(45.2,148.3) ; R725.2 v2(137.61,249.67) ; R79945.1 101.48,57.07 102.02,56.53 102.27,56.53 v2(102.29,56.55) ; R219.2 R238.2 100.27,97.01 v2(100.4,96.89) ; WEBCM1.8 168.9,210.09 v2(168.9,208.7) 168.81,208.7 167.84,207.73 v1(167.84,207.5) ; C12441.2 83.25,77.84 v2(83.51,77.58) C173.2 ; C12060.2 39.87,154.16 39.87,154.23 39.17,154.93 v2(39.17,155.1) ; R9554.2 46.73,50.53 46.83,50.43 v2(46.91,50.43) 46.91,50.05 47.31,49.64 48.9,49.64 R79949.1 ; v2(149.04,23.29) 149.04,23.29 C12218.2 ; C12149.2 146.31,123.87 v2(146.25,123.81) ; R587.2 56.27,98.3 v2(56.56,98.59) ; v2(39.92,116.85) 39.85,116.85 39.19,116.19 C12240.2 ; v2(39.31,232.83) 39.24,232.75 39.24,232.7 38.8,232.27 C12125.2 ; v2(153.99,25.5) 153.98,25.48 153.98,25.13 U5203.3 155.61,23.5 D5202.1 ; C12057.2 39.76,148.56 C12056.2 40.15,147.94 40.79,147.94 40.99,147.74 v2(41.09,147.74) 41.03,147.68 R51.2 R53.2 ; v2(178.41,213) WEBCM1.9 180.21,213 ; v2(137.32,224.56) 136.85,225.03 C517.2 ; SPK1.5 173.53,20.45 173.55,20.43 v2(173.55,19.71) ; R1833.2 159.2,89.33 v2(159.2,89.78) ; SPK1.7 164.98,24.5 163.01,24.5 162.25,25.26 v4(162.25,26.15) ; R79172.2 44.07,15.67 v2(44.01,15.61) ; v2(103.19,87.36) 103,87.55 R79982.2 ; Q61.E 47,7.35 47.38,6.97 v2(47.95,6.97) 48.46,6.97 48.74,7.26 Q62.E ; v2(143.56,57.79) 144.14,57.79 144.28,57.94 R79768.2 ; v2(64.08,8.77) 63.25,8.77 63.06,8.97 C12170.2 ; v2(42.7,24.2) C9522.2 ; R1592.2 v2(139.9,50.38) ; v2(75.89,180.06) 75.93,180.1 C84.2 76.85,180.07 C85.2 ; PC12186.2 163.9,222.74 v2(164.28,222.36) ; C7522.2 v2(47.57,114.92) ; X3.2 v2(53.71,37.86) ; PC34.2 v2(6.74,187.44) ; C518.2 141.86,236.27 v2(141.8,236.33) ; C12226.2 10.67,17.94 11.45,18.72 v2(11.58,18.72) ; R303.2 C190.2 v2(98.34,67.04) ; R79821.1 C231.1 173.68,50.81 173.71,50.85 v2(173.71,50.96) ; v2(102.61,28.36) 102.61,28.46 102.56,28.51 R424.1 ; v2(115.49,71.65) 115.47,71.65 115.8,71.32 C12151.2 C191.2 115.91,68.97 C12152.2 ; v2(23.82,76.44) 23.95,76.31 PR164.2 ; R894.2 128.02,98.28 v2(128.95,98.28) 129.36,97.88 129.36,97.78 R79931.2 ; R57.2 R56.2 37.98,134.3 39.61,134.3 39.64,134.28 v2(39.66,134.28) 39.72,134.23 39.82,134.23 39.87,134.18 39.93,134.18 40.32,133.79 40.32,133.73 40.71,133.34 R46.2 ; Q1267.E 58.34,15.28 58.34,14.79 58.82,14.31 v2(58.87,14.31) 59.09,14.53 C12122.2 ; U9617.S 34.07,130.07 v2(34.61,129.53) ; R5204.1 159.54,11.33 v2(159.58,11.29) ; C523.2 16.91,135.1 TOUCH2.2 13.52,135.1 v4(13.15,134.73) ; v2(17.47,170.22) C12324.2 ; v2(128.95,100.06) 129.87,100.06 129.96,99.97 R1923.1 ; R79742.1 54.74,30.09 v2(54.96,30.09) 55.5,30.09 C283.2 ; v2(28.25,255.03) 28.25,254.93 R79753.2 ; R1990.2 43.76,151.88 v2(44.49,151.14) ; v2(146.37,124.83) 146.56,125.02 R141.2 ; C12386.2 91.74,88.9 R258.2 90.8,89.57 v2(91,89.78) ; v2(171.52,206.62) 171.39,206.49 PC2.2 ; U5202.3 140.4,9.66 v2(140.61,9.46) ; R2089.2 156.38,47.74 v2(156.38,47.74) ; C426.2 73.98,130.29 v2(73.6,130.67) ; v2(35.97,136.45) 35.97,136.19 35.5,135.72 U9616.S 34.8,137.04 PR9.2 ; CPU1.C2 58.74,169.26 v2(58.74,168.64) ; v2(93.54,62.6) 93.54,62.09 93.16,61.71 C201.2 R339.2 ; R79933.2 v2(134.69,98.16) ; v2(153.99,27.16) R80225.2 ; R231.2 v2(100.37,96) ; PC4701.1 19.93,137.65 19.75,137.83 19.75,137.86 19.73,137.86 19.73,137.81 19.73,137.81 v2(19.73,137.86) ; R79914.2 C12327.2 17.26,168.9 17.59,168.57 v2(17.7,168.57) ; v2(46.27,250.05) PR4458.2 ; R45.2 69.09,178.99 v2(68.9,178.8) ; PC66.2 v2(44.71,182.56) ; Q53.S 97.47,113.92 v2(96.46,114.92) 97.29,115.75 C414.1 ; v2(92.45,256.55) 92.66,256.34 PC51.2 ; C353.1 v2(178.25,206.11) ; U5201.2 v2(136.49,25.51) 136.24,25.77 C338.2 ; C362.2 80.71,65.33 v2(80.71,65.52) ; v2(175.68,71.33) 175.68,71.36 175.71,71.39 C269.2 ; C7506.2 v2(48.18,96) ; C505.2 48.24,101.14 48.1,101 v5(47.74,101) ; v2(160.98,210.55) 160.98,210.04 161.61,209.41 PC92.2 ; R79668.2 31.18,109.31 30.94,109.07 v2(30.9,109.07) ; v2(40.07,109.54) 40.07,108.84 PC8617.2 PC12174.2 ; C368.2 v2(75.13,65.77) ; R2090.2 156.18,46.6 v2(156.41,46.37) 156.89,46.37 157.38,45.88 ; C513.2 v2(148.91,233.41) ; R62.2 44.33,152.45 v2(45.06,151.71) ; PC64.2 20.33,163.14 20.52,162.95 v2(20.59,162.95) ; C367.2 v2(75.13,66.79) ; C12241.2 49.7,127.26 v2(50.53,128.09) ; C158.2 122.3,67.99 v2(121.57,68.72) ; C245.2 177.91,29.65 177.86,29.6 v2(177.86,29.26) ; C512.2 v2(148.28,234.56) ; v2(123.34,27.8) 123.34,26.91 C331.2 ; C11892.2 R79772.2 141.78,60.1 141.67,59.96 v2(141.67,59.88) ; PR60.2 106.72,95.27 v2(106.72,96.06) ; C526.1 22.48,16.43 v2(22.52,16.39) ; R439.2 51.95,40.37 51.4,40.37 50.72,41.05 50.72,41.24 v2(50.56,41.39) ; Q17.3 106.05,37.64 v2(105.86,37.83) ; PWRCN1.11 35.14,22.12 v2(35.81,21.45) ; PC47.2 v2(62.93,262.11) ; C67.2 v4(69.8,229.22) ; 164.15,197.17 v5(164.94,197.96) ; v2(162.76,31.74) 163.26,32.24 C251.2 ; 152.55,129.55 v2(156.03,129.55) ; C151.2 156.28,55.93 C149.2 155.96,56.95 155.06,56.04 v2(154.6,56.04) ; C12390.2 v2(84.65,77.58) ; X1.4 119.77,68.92 v2(119.89,68.8) ; v2(92.04,96.57) C511.2 ; PC154.2 111.11,131.79 111.09,131.77 v2(111.09,131.28) ; C7508.2 v2(48.18,94.86) ; v2(103.01,93.53) 103.01,93.54 102.43,94.12 PC8307.2 ; C12384.1 v2(99.26,116.95) ; C52.2 v4(69.54,227.19) ; v2(10.61,208.14) v2(10.61,206.87) ; PC8610.2 v2(38.3,92.77) ; R715.2 v2(117.17,241.17) ; CPU1.Y5 74.13,172.19 v5(74.56,172.62) ; v2(112.59,79.87) 112.08,79.36 PC12184.2 ; C270.1 v2(103.07,40.59) ; X9502.2 v2(45.06,19.25) ; C351.2 v2(178.29,202.55) ; v2(173.86,77.74) 173.84,77.74 173.45,78.13 U9622.4 ; PR161.2 27.29,78.28 v2(27.42,78.14) ; R79719.2 v2(6.75,20.05) ; R79986.2 v2(99.51,91.66) 99.41,91.66 99.13,91.93 R79993.2 ; v2(41.6,21.07) 42.42,21.89 X9502.4 ; v5(59.95,175.37) CPU1.E9 ; v5(60.14,107.67) 60.09,107.67 60.04,107.62 ; CPU1.AH5 81.46,172.17 v5(81.92,171.71) 82.36,171.28 CPU1.AJ4 ; R1688.2 v2(134.69,99.55) ; PR143.2 v2(22.52,168.57) ; C53.2 v4(60.27,227.19) ; C147.2 v2(146.86,101.21) ; CONVT1.10B v2(32.58,3.42) ; v2(46.81,251.19) PR4418.2 ; v2(167.2,59.37) 167.18,59.35 167.18,58.24 C11838.2 ; PC12182.2 v2(124.81,256.46) ; PC12180.2 v2(37.41,57.39) ; C60.2 v4(64.97,229.22) ; C352.2 v2(178.29,204.58) ; R79916.2 8.58,169.28 v2(7.82,170.04) ; v2(148.99,26.21) C12219.2 ; C144.1 146.26,96.63 145.78,97.11 v2(145.78,97.18) ; v2(168.47,39.61) R79825.1 ; v2(156.38,45.45) R2085.2 ; v5(63.61,175.37) CPU1.H9 ; R420.1 v2(180.79,78.73)
  TOP w0.635: 145.25,10.41 HDMI2.20 ; HDMI2.20 145.25,16.05 ; HDMI2.20 146.37,13.23 ; HDMI2.20 144.13,13.23 ; HDMI2.22 150.47,5.98 ; HDMI2.22 145.09,5.98 ; HDMI2.22 147.78,7.1 ; HDMI2.22 147.78,4.86 ; 119.97,9.73 USB2.4 ; USB2.4 122.03,9.73 ; USB2.4 121,8.7 ; USB2.4 121,10.76 ; 198,68.87 UHS1.MS1 ; UHS1.MS1 199.42,69.89 ; UHS1.MS1 196.58,69.89 ; HDMI1.21 147.78,44.6 ; HDMI1.21 150.47,43.48 ; HDMI1.21 145.09,43.48 ; HDMI1.21 147.78,42.36 ; 191.73,91.04 SSUSB2.4 192.62,90.15 ; HDMI1.20 146.37,36.23 ; HDMI1.20 144.13,36.23 ; HDMI1.20 145.25,33.41 ; HDMI1.20 145.25,39.05 ; 194.25,88.14 SSUSB2.10 ; SSUSB2.10 197.99,88.14 ; SSUSB2.10 196.12,89.21 ; SSUSB2.10 196.12,87.07 ; 68.79,23.38 DCIN1.6 ; DCIN1.6 69.88,21.82 ; DCIN1.6 69.88,24.94 ; DCIN1.6 70.97,23.38 ; 196.12,108.57 SSUSB1.10 ; SSUSB1.10 194.25,109.64 ; SSUSB1.10 196.12,110.71 ; SSUSB1.10 197.99,109.64 ; USB4.4 135.53,9.73 ; USB4.4 133.47,9.73 ; USB4.4 134.5,8.7 ; 131.79,4.95 USB4.6 ; USB4.6 131.79,8.38 ; USB4.6 133.51,6.66 ; USB4.6 130.08,6.66 ; 74.82,22.23 DCIN1.2 71.69,22.23 ; 118.29,4.95 USB2.6 ; USB2.6 120.01,6.66 ; USB2.6 116.58,6.66 ; USB2.6 118.29,8.38 ; 72.39,29.1 DCIN1.7 72.39,28.56 ; HDMI1.22 147.78,30.1 ; HDMI1.22 145.09,28.98 ; HDMI1.22 150.47,28.98 ; 72.39,20.36 DCIN1.5 75.52,20.36 ; 196.12,99.87 SSUSB2.11 ; SSUSB2.11 196.12,102.01 ; SSUSB2.11 197.99,100.94 ; SSUSB2.11 194.25,100.94 ; UHS1.MS2 199,80.11 ; UHS1.MS2 200.42,79.09 ; UHS1.MS2 197.58,79.09 ; SSUSB1.11 196.12,123.51 ; SSUSB1.11 194.25,122.44 ; SSUSB1.11 197.99,122.44 ; SSUSB1.11 196.12,121.37 ; 76.08,21.82 DCIN1.4 76.63,21.82
  L3 w0.089: v5(74.03,103.95) 74.39,104.31 75.86,104.31 76.11,104.07 ; 76.11,104.07 76.11,103.63 75.73,103.26 v5(75.73,103.03) ; 76.11,104.07 76.34,104.3 76.86,104.3 77.33,103.83 v5(77.33,103.82) ; v5(73.19,105.57) 73.04,105.57 72.58,105.12 72.05,105.12 v5(71.59,105.58)
  L3 w0.635: 196.58,69.89 UHS1.MS1 ; UHS1.MS1 198,68.87 ; UHS1.MS1 199.42,69.89 ; 74.82,22.23 DCIN1.2 71.69,22.23 ; HS6.1 160.47,238 ; HS6.1 156.59,238 ; HS6.1 158.53,239.94 ; HS6.1 158.53,236.06 ; SSUSB1.10 196.12,110.71 ; SSUSB1.10 197.99,109.64 ; SSUSB1.10 194.25,109.64 ; SSUSB1.10 196.12,108.57 ; SSUSB2.11 196.12,102.01 ; SSUSB2.11 194.25,100.94 ; SSUSB2.11 196.12,99.87 ; SSUSB2.11 197.99,100.94 ; 72.39,28.01 DCIN1.7 72.39,29.1 ; 75.52,20.36 DCIN1.5 72.39,20.36 ; 76.63,21.82 DCIN1.4 76.08,21.82 ; 196.12,121.37 SSUSB1.11 ; SSUSB1.11 196.12,123.51 ; SSUSB1.11 194.25,122.44 ; SSUSB1.11 197.99,122.44 ; 197.58,79.09 UHS1.MS2 ; UHS1.MS2 200.42,79.09 ; UHS1.MS2 199,80.11 ; 68.79,23.38 DCIN1.6 ; DCIN1.6 70.97,23.38 ; DCIN1.6 69.88,21.82 ; DCIN1.6 69.88,24.94 ; 196.12,87.07 SSUSB2.10 ; SSUSB2.10 197.99,88.14 ; SSUSB2.10 194.25,88.14 ; SSUSB2.10 196.12,89.21
  L4 w0.089: v5(73.19,105.57) 73.6,105.17 73.6,104.38 74.03,103.95 v5(74.03,103.95) 74.08,103.95 74.59,103.44 75.32,103.44 v5(75.73,103.03) 75.95,103.03 76.37,102.61 76.7,102.61 76.93,102.85 76.93,103.38 77.33,103.78 v5(77.33,103.82)
  L4 w0.635: 9.91,95 ODD2.4 8.15,95 ; 194.25,88.14 SSUSB2.10 ; SSUSB2.10 196.12,89.21 ; SSUSB2.10 197.99,88.14 ; SSUSB2.10 196.12,87.07 ; 7.96,69.63 HDD1.8 ; HDD1.8 9.28,68.31 ; HDD1.8 9.28,70.95 ; HDD1.8 10.6,69.63 ; 9.03,71.31 HDD1.1 ; HDD1.1 8.15,72.19 ; HDD1.1 9.91,72.19 ; 156.59,238 HS6.1 ; HS6.1 158.53,239.94 ; HS6.1 160.47,238 ; HS6.1 158.53,236.06 ; ODD2.1 9.91,91.19 ; ODD2.1 8.15,91.19 ; ODD2.1 9.03,90.31 ; HDD1.9 9.28,83.69 ; HDD1.9 10.6,82.37 ; HDD1.9 7.96,82.37 ; HDD1.9 9.28,81.05 ; HDD1.7 9.03,80.69 ; HDD1.7 9.91,79.81 ; HDD1.7 8.15,79.81 ; 198,68.87 UHS1.MS1 ; UHS1.MS1 196.58,69.89 ; UHS1.MS1 199.42,69.89 ; UHS1.MS2 199,80.11 ; UHS1.MS2 197.58,79.09 ; UHS1.MS2 200.42,79.09 ; 194.25,122.44 SSUSB1.11 ; SSUSB1.11 196.12,123.51 ; SSUSB1.11 197.99,122.44 ; SSUSB1.11 196.12,121.37 ; SSUSB2.11 197.99,100.94 ; SSUSB2.11 196.12,99.87 ; SSUSB2.11 194.25,100.94 ; SSUSB2.11 196.12,102.01 ; 9.91,76 HDD1.4 8.15,76 ; 196.12,108.57 SSUSB1.10 ; SSUSB1.10 194.25,109.64 ; SSUSB1.10 197.99,109.64 ; SSUSB1.10 196.12,110.71 ; 7.96,88.63 ODD2.8 ; ODD2.8 10.6,88.63 ; ODD2.8 9.28,89.95 ; ODD2.8 9.28,87.31
  BOTTOM w0.102: v5(73.19,105.57) 73.45,105.57 73.85,105.96 74.4,105.96 v5(74.8,106.36)
  BOTTOM w0.2: VRAM7.F9 60.78,107.11 60.09,107.11 VRAM5.G1
  BOTTOM w0.203: PU40.14 165.83,216.02 v2(165.65,215.84) ; XDPC1.25 44.01,129.51 44.32,129.82 v2(44.41,129.82) 44.41,128.28 44.14,128.01 XDPC1.31 ; v2(39.44,131.18) 39.26,131.01 XDPC1.20 ; XDPC1.32 38.93,128.01 39.58,128.65 39.68,128.65 ; XDPC1.59 42.42,120.51 v2(42.61,120.33) ; v2(171.39,216.9) 170.91,216.42 PU40.1 ; U21.11 v2(83,66.41) ; XDPC1.37 43.77,126.51 44.12,126.86 44.34,126.86 v2(44.37,126.88) ; XDPC1.14 39.15,132.51 39.4,132.75 v2(39.65,132.75) ; XDPC1.7 39.88,134.01 39.66,134.22 v2(39.66,134.28) 39.61,134.28 39.59,134.3 39.05,134.3 38.76,134.01 XDPC1.8 ; v2(44.39,132.47) 44.36,132.51 XDPC1.13 ; v2(171.44,215.17) 171,215.62 PU40.3 ; U22.11 v2(73.6,51.17) ; v2(44.89,123.3) 44.69,123.51 XDPC1.49 ; XDPC1.2 36.13,135.51 35.97,135.66 v2(35.97,136.45) ; XDPC1.38 34.93,126.51 v2(34.61,126.82) ; v2(44.39,131.18) 44.21,131.18 44.04,131.01 XDPC1.19 ; 39.68,128.65 39.06,129.27 38.3,129.27 38.06,129.51 XDPC1.26 ; 39.68,128.65 v2(39.71,128.65)
  BOTTOM w0.254: RN7510.4 55.81,95 56.34,95 56.41,95.06 v5(56.5,95.06) ; v5(63.62,87.82) 63.51,87.71 62.2,87.71 61.94,87.97 RN7516.4 ; 51.25,95.08 51.75,94.58 RN7506.6 ; 51.25,95.08 RN7506.7 ; 51.25,95.08 v2(51.12,95.21) ; RN7507.4 52.08,89.57 v5(52.04,89.52) ; RN7509.3 53.41,91.53 v5(53.4,91.53) ; v5(50.54,92.16) 50.88,91.82 51.01,91.82 RN7508.4 ; R80028.2 61.58,86.31 61.58,85.76 v5(61.61,85.74) 61.59,85.74 61.58,85.74 61.53,85.74 61.14,85.34 RN7517.3
  BOTTOM w0.279: XDPC1.50 35.3,123.51 35.17,123.38 v2(34.77,123.38)
  BOTTOM w0.305: VRAM6.T9 52.84,114.66 v5(52.44,114.26) ; v2(13.71,12.89) 13.84,12.89 13.93,12.79 U120.20 ; v5(72.97,82.03) 73.01,82.03 73.49,82.5 VRAM2.T9 ; RN7505.7 53.41,85.33 53.63,85.11 54.23,85.11 v5(54.48,85.36) 54.25,85.36 53.91,85.69 RN7505.6 ; RN7513.3 56.62,86.59 v5(57.17,86.04) 57.71,86.59 RN7514.4 ; VRAM8.G8 60.04,120.3 v5(59.65,120.69) ; RN7511.4 56.63,94.93 v5(56.5,95.06) ; v2(182.68,104.27) 182.64,104.27 182.62,104.25 U9625.14 ; v5(59.99,87.54) 60.29,87.54 60.54,87.79 RN7515.3 ; RN7512.3 v5(60.75,95.75)
  BOTTOM w0.356: 60.04,107.62 VRAM5.G1 ; VRAM5.B9 64.04,100.55 63.73,100.24 v5(63.73,100.17) ; VRAM1.E2 81.92,91.48 v5(82.32,91.88) 82.03,92.17 82.03,92.17 VRAM3.D8 ; VRAM2.B1 66.78,93.88 v5(66.49,93.58) 66.49,94.15 67.01,94.68 VRAM4.A9 ; VRAM1.J2 82.31,87.89 v5(82.32,87.89) ; v5(62.02,105.85) 62.04,105.85 ; 62.04,105.85 VRAM5.E2 VRAM7.F9 ; 62.04,105.85 62.04,105.88 62.41,106.25 62.44,106.25 v5(62.03,106.65) ; VRAM4.E1 v5(73.09,91.88) ; v5(73.09,91.88) VRAM2.E8 ; v5(73.09,91.88) VRAM4.D1 ; VRAM3.E1 v5(87.12,91.88) VRAM1.E8 ; 64,107.91 64.04,107.87 VRAM5.B1 ; 64,107.91 64,107.89 VRAM7.A9 ; 64,107.91 v5(64,107.99) ; VRAM2.P9 73.77,84.28 v5(74.04,84.01) ; VRAM1.G9 v5(87.12,90.28) ; VRAM6.P9 54.44,114.27 v5(54.62,114.09) ; v5(60.45,105.84) 60.04,106.24 VRAM7.G8 ; VRAM1.G1 80.52,89.88 v5(80.51,89.89) ; v5(58.04,115.88) 58.06,115.86 VRAM6.J8 ; v5(54.25,108.39) 54.25,108.32 54.44,108.13 VRAM5.P1 ; v5(52.61,108.09) 52.61,107.27 VRAM5.T1 ; v5(64.45,121.58) 64.45,121.5 ; 64.45,121.5 64.84,121.11 VRAM8.A9 ; 64.45,121.5 64.45,121.48 64.11,121.13 64.09,121.13 VRAM6.B1 ; v5(59.65,120.69) 60.04,121.07 VRAM6.G1 ; VRAM2.M1 67.03,85.94 66.46,85.94 v5(66.26,85.74) ; v5(56.17,107.83) 56.04,107.7 VRAM5.M1 ; VRAM3.B3 85.37,94.42 v5(84.57,94.42) ; v5(80.43,84.16) 80.55,84.28 VRAM1.P1 ; VRAM2.P1 66.53,84.28 v5(66.31,84.06) ; v5(80.39,85.92) 80.46,85.92 80.5,85.88 VRAM1.M1 ; VRAM8.E1 v5(62.04,115.08) ; v5(62.04,115.08) VRAM6.E8 ; v5(62.04,115.08) VRAM8.D1 ; VRAM5.E8 VRAM7.D1 62.44,100.26 v5(62.29,100.11) 61.8,100.6 61.68,100.6 VRAM7.E1 ; v5(68.29,87.87) 68.26,87.9 68.26,87.9 VRAM2.J2 ; VRAM2.G1 66.93,89.72 v5(66.47,89.72) 66.47,90.06 67.09,90.68 ; VRAM3.A9 81.05,94.68 80.44,94.07 v5(80.44,93.89) 80.45,93.88 ; VRAM2.B9 74.09,94.48 v5(74.09,94.68) ; VRAM5.J2 58.43,106.25 v5(58.03,106.65) ; VRAM2.M9 73.83,85.88 73.84,85.89 74.32,85.89 v5(74.39,85.96) ; VRAM2.T1 67.06,82.68 66.57,82.18 v5(66.57,82.05) ; VRAM1.J8 v5(86.32,87.88) ; VRAM1.B9 88.09,93.88 v5(88.15,93.81) ; VRAM2.E2 67.5,91.87 v5(67.49,91.87) 67.49,91.88 VRAM4.D8 ; VRAM3.G8 81.92,89.88 v5(81.52,90.28) VRAM3.F9 ; v5(58.84,120.68) 58.44,120.28 VRAM6.J2 ; VRAM5.G9 60.04,100.27 v5(59.88,100.11) ; v5(56.01,121.82) 56.04,121.79 VRAM6.M1 ; VRAM6.E2 61.64,120.28 v5(61.24,120.68) VRAM8.F9 ; VRAM5.J8 58.43,101.45 v5(58.04,101.84) ; VRAM8.D8 62.43,120.28 v5(62.04,120.68) ; VRAM1.P9 v5(88.12,84.28) ; VRAM1.T9 v5(88.08,82.68) ; VRAM1.M9 87.81,85.88 87.95,86.02 v5(88.23,86.02) ; 67.09,90.68 VRAM4.F9 ; 67.09,90.68 VRAM4.G8 ; VRAM6.G9 60.39,115.04 v5(60.44,115.04) ; v5(54.44,121.81) 54.44,121.8 VRAM6.P1 ; v5(62.66,117.64) 62.66,117.43 63.25,116.83 63.48,116.83 64.04,116.28 ; v5(63.64,115.08) 63.64,115.08 VRAM6.B9 ; VRAM3.D1 v5(88.15,92.28) ; v5(80.46,82.59) 81.03,82.59 VRAM1.T1 ; v5(52.72,121.65) 52.84,121.53 VRAM6.T1 ; VRAM7.B3 64.48,102.69 v5(64.48,102.75) ; v5(72.29,87.88) 72.29,87.88 VRAM2.J8 ; VRAM2.G9 73.85,89.88 74,90.02 v5(74.03,90.02) ; VRAM4.B3 71.3,94.46
  BOTTOM w0.381: v2(33.72,257.92) 33.72,257.23 U175.1 ; v5(74,113.85) 74,113.89 74.81,114.7 C455.2 ; U3.3 v2(20.39,250.24) ; C12415.2 71.64,108.79 v5(72.39,108.04)
  BOTTOM w0.4: VRAM5.P9 54.44,100.14 v5(54.55,100.04) ; VRAM5.T9 52.84,100.09 52.78,100.03 v5(52.78,100.02) ; VRAM5.M9 56.04,100.07 55.35,99.38 v5(55.25,99.38) ; VRAM7.D8 62.44,106.25 ; v5(56.18,114.08) 56.18,114.08 56.04,114.22 VRAM6.M9 ; VRAM8.B3 64.04,116.28 ; VRAM1.B1 80.45,93.88
  BOTTOM w0.406: Q9628.1 19.77,43.66 20.52,44.41 v2(20.52,44.54) ; v2(30.93,255.13) 30.93,255.64 31.17,255.88 U175.4 ; PQ5007.4 49.41,45.26 49.85,45.7 50.81,45.7 v2(51.05,45.47) ; v2(45.87,42.74) 45.87,42.95 46.89,43.96 PQ5007.1 ; Q9629.4 24.39,47.98 v2(24.25,47.83) ; Q6.1 123.98,58.7 v2(124.26,58.42) ; U171.1 161.44,206.22 C12168.2 160.91,206.3 160.52,206.69 v2(160.52,207.21) ; Q6.4 122.2,61.63 122.19,61.64 122.19,61.71 ; Q9629.1 27.37,49.48 27.37,49.9 27.28,49.99 v2(27.28,50.12) ; v2(56.15,15.25) 56.18,15.23 56.51,15.23 56.59,15.15 Q9503.4 ; v2(58.87,14.31) 58.29,13.72 58.29,13.31 Q9503.1 ; v2(163.77,208.52) 164.71,207.58 U171.4 ; C476.1 72.26,112.28 73.12,111.42 C465.2 ; v2(17.72,45.2) 17.8,45.12 Q9628.4 ; U176.1 v2(27.07,255.14)
  BOTTOM w0.508: C12422.2 50.51,92.19 v5(50.54,92.16) 51.16,92.78 C12419.2 ; v2(152.65,73.28) 152.5,73.28 152.23,73.01 C143.2 152.15,72.76 C12061.2 ; C1935.2 152.34,80.82 152.95,80.21 v2(152.95,80.15) 153.24,80.44 C11835.2 ; v2(173.55,203.31) 174.38,204.14 R1952.2 C12167.2 ; C7508.2 v2(48.18,94.86) ; R239.1 158.77,83.55 158.79,83.53 v2(158.97,83.53) ; R79760.2 v2(29.3,253.29) ; v2(52.82,252.51) 52.81,252.53 R79762.2 ; v2(136.34,80.2) 136.47,80.33 R99.2 ; v2(162.81,213.47) 163.58,213.47 PC86.2 ; R190.2 143.54,71.85 v2(142.31,71.85) ; C12196.2 30.18,43.61 v2(30.24,43.67) ; v2(38.04,28.51) 37.6,28.07 C12183.1 ; C444.2 78.14,120.37 v5(78.19,120.42) ; Q9650.S 30.57,54.16 v2(28.47,54.16) ; D5213.1 28.33,21 v2(28.14,21.2) ; D5210.1 29.34,17.13 v2(30.3,17.13) ; v5(148.37,137.55) 148.37,137.3 148.79,136.89 R75.2 ; v5(60.14,107.67) 60.09,107.67 60.04,107.62 ; PC100.2 172.66,220.2 v2(173.93,221.47) ; v2(157.58,164.08) 157.92,164.41 158.7,164.41 158.74,164.45 C99.2 C122.2 159.33,161.32 C121.2 159.36,160.49 159.01,160.13 C96.2 ; v4(84.83,25.16) 85.31,25.16 86.05,25.89 C355.2 ; v2(47.12,236.84) PR4473.2 PR4461.2 ; v2(68.9,178.8) 69.09,178.99 R1996.2 ; C369.2 85.45,65.87 C370.2 86.14,65.19 v2(86.33,65.19) ; R247.2 142.45,73.12 v2(142.29,73.28) ; C6725.2 76.21,108.83 v5(76.24,108.79) 76.24,108.8 76.82,109.37 C482.1 ; R622.2 89.01,100.7 v5(89.01,100.62) 89.19,100.44 R619.2 ; C193.2 120.24,51.29 v2(120.89,51.95) 120.15,52.69 C195.2 ; C6709.1 86.48,118.01 v5(86.46,118.03) ; PC77.1 34.23,74.27 v2(34.28,74.32) ; v5(163.39,198.09) 163.39,198.1 163.39,198.42 R91.2 ; v5(77.61,114.48) 76.75,113.62 C471.2 76.75,113.38 v5(77.58,112.55) 76.78,111.74 76.78,110.62 v5(76.56,110.4) 76.56,109.73 C482.1 ; U176.4 28.95,257.24 28.26,257.92 v2(28.14,257.92) ; v2(139.13,76.7) 139.2,76.63 C11834.2 ; C21.2 46.63,182.41 v4(45.79,183.25) ; C138.2 C139.2 R95.2 167.75,156.39 v5(167.12,155.75) ; R127.2 160.41,77.52 160.52,77.63 v2(160.9,77.63) ; D5214.1 22.85,18.15 v2(22.55,18.45) ; PR210.2 149.1,125.08 v2(148.28,125.08) ; v2(105.12,62.47) 105.1,62.5 105.1,64.31 C185.2 ; v2(158.44,166.48) 158.57,166.61 158.57,166.99 159.2,167.63 C97.2 C98.2 ; C363.2 86,62.61 C364.2 86.71,62.34 v2(86.81,62.44) ; C194.2 121.67,63.11 121.71,63.11 122.27,62.55 122.27,61.78 122.19,61.71 v2(122.19,61.74) ; v5(167.14,189.35) 167.9,190.11 C136.2 ; v2(152.22,94.09) 152.66,94.53 152.66,94.54 Q3.S ; 63.98,22.37 v2(63.98,23.23) ; 63.98,22.37 63.95,22.34 C296.2 C297.2 ; 63.98,22.37 C12128.2 ; v4(21.51,177.41) 21.57,177.47 PC65.2 ; PC8615.2 45.04,108.71 v2(45.04,107.28) ; PC5311.2 v2(6.42,118.73) ; v2(94.3,102.35) 94.3,102.08 95.88,100.51 PR8333.2 ; v2(11.5,19.93) 11.47,19.95 C12230.2 C12229.2 ; v2(23.67,253.35) C12165.2 ; C465.2 73.41,111.17 73.98,110.61 v5(73.98,110.48) ; v2(46.27,250.05) 47.5,250.05 PC4413.2 ; v2(150.24,96.99) 150.12,97.11 C145.2 ; R79840.2 184.92,145.85 v2(185.11,146.04) ; v2(186.71,103.95) 186.66,104 R80049.2 ; C441.2 83.32,117.18 v5(84.02,117.18) 84.5,116.7 C479.1 ; v2(70.81,130.67) 70.94,130.54 C429.2 ; PC4415.2 40.35,239.67 40.35,240.27 v2(40.12,240.5) ; v2(47.19,243.32) 47.21,243.29 47.5,243.29 47.73,243.06 PC4417.2 ; PR4464.1 v2(62.25,251.2) ; C12394.2 R80000.2 ; v2(111.75,60.14) 111.78,60.11 111.78,60.06 111.85,59.99 Q8.S ; v2(136.67,89.65) 137.17,90.14 R1660.2 ; C142.1 v2(153.89,91.68) 154.02,91.81 C141.1 ; Q58.S 148.04,235.46 148.02,235.44 v2(147.8,235.44) ; R80.2 143.39,200.33 v2(142.82,200.9) ; C11836.2 142.93,88.96 143.89,88.96 v2(143.95,89.02) ; C286.2 55.85,30.29 C12336.2 55.29,30.31 55.06,30.09 v2(54.96,30.09) ; C7522.2 v2(47.57,114.92) ; R79728.2 15.44,35.23 v2(15.44,35.8) 16.86,35.8 Q1262.S ; 71.3,94.46 71.04,94.73 v5(70.77,94.73) ; PR193.2 v2(170.38,208.77) ; R86.2 162.63,138.61 v5(163.36,137.88) ; v2(186.68,102.93) 186.28,102.93 186.26,102.92 C314.2 ; 75.69,119.62 75.28,120.03 C433.1 ; 75.69,119.62 75.69,119.03 75.92,118.81 C428.2 75.72,118.49 C434.2 76.27,117.77 76.5,117.99 v5(76.57,117.99) 76.59,118.01 C445.2 ; 75.69,119.62 v5(75.7,119.61) ; v2(171.44,213.6) PC98.2 ; R503.2 v2(50.49,26.28) ; U9502.3 42.84,44.82 v2(42.46,44.44) 42.58,44.44 42.9,44.12 42.91,44.12 43.48,43.55 U9502.4 ; v2(189.01,149.88) C12161.1 189.01,149.02 C12160.1 ; v5(47.74,101) 47.88,101.14 C505.2 ; C12184.1 32.24,29.86 v2(32.73,29.86) 32.73,29.07 Q9619.S ; C12222.2 25.66,53.07 C12220.2 C12221.2 26.15,54.72 26.71,54.17 v2(26.74,54.17) ; v5(151.9,158.81) 152.61,159.51 C114.2 153.17,159.5 C115.2 ; C199.2 104.34,60.73 104.74,61.14 105.16,61.14 v2(105.23,61.07) ; v2(23.84,78.38) 23.83,78.37 PR169.2 ; R1829.1 158.87,81.9 v2(158.92,81.85) 158.97,81.85 159,81.82 159.82,81.82 R1798.1 ; C12158.1 191.55,150.51 v2(191.46,150.61) ; v2(23.61,252.46) 24.58,252.46 C12166.1 ; v5(88.1,118.77) 88.08,118.75 C440.2 ; v2(110.74,66.35) 110.74,66.34 110.37,65.96 C180.2 ; PC5303.2 v2(16.05,109.59) ; R80020.2 78.29,89.9 78.68,89.9 v5(78.94,90.16) ; R79981.2 91.05,94.84 91.5,95.29 91.5,96.02 v2(92.04,96.57) ; v2(105.38,98.56) 105.96,99.15 PC8302.2 ; Q76.E 170.95,206.04 v2(171.52,206.62) ; 28.77,49.14 28.77,50.02 v2(28.9,50.15) ; C7506.2 v2(48.18,96) ; v2(178.5,58.28) 177.3,58.28 C228.2 C219.2 176.54,55.68 C220.2 C227.2 ; R327.2 117.51,64.03 118.05,63.49 v2(118.05,63.23) ; PC94.2 172.79,221.47 v2(173.42,222.11) ; v2(103.7,194.04) R2.2 R1.2 ; PC8308.2 103.32,93.84 103.02,93.53 v2(103.01,93.53) ; v5(161.91,198.05) 161.46,197.6 C133.2 C134.2 160.85,196.65 R89.2 ; v2(56.56,98.59) 56.8,98.35 C12429.2 56.85,97.57 R7514.2 57.77,97.5 R7541.2 ; C110.2 166.63,136.19 C109.2 165.68,136.89 164.98,136.19 C104.2 C105.2 163.9,136.51 164.83,137.44 v5(164.83,137.86) ; v5(147.92,153.91) 147.92,154 147.4,154.52 146.35,154.52 146.17,154.34 C41.2 ; v2(93.27,59.21) 92.56,58.5 Q9635.E ; v2(174.44,220.84) 174.69,220.59 PC99.2 ; v5(80.67,103.78) 80.83,103.78 81.18,103.43 C12380.2 ; C503.2 78.64,105.92 78.2,106.36 C458.1 78.02,107.33 77.74,107.61 C486.2 77.69,107.77 77.55,107.77 77.13,108.19 77.13,109.07 77.04,109.16 77.04,109.24 C482.1 ; PR4456.2 v2(47.95,247.32) ; v2(169.87,81.67) 170.08,81.89 R1830.2 ; PU5301.6 11.25,117.59 v2(11.88,116.95) ; v2(42.46,45.83) 42.72,46.09 43.88,46.09 ; C131.2 143.77,138.42 C130.2 145.94,138.42 v5(146.8,137.55) 146.4,137.55 145.74,136.89 R74.2 C128.2 146.79,136.41 C129.2 ; v2(106.62,88.25) 106.3,88.57 PC12183.2 ; C12131.2 184.78,148.58 184.6,148.76 v2(184.6,149.81) ; v5(151.98,189.75) 152.08,189.85 C112.2 ; R188.2 143.99,66.44 143.99,65.29 143.62,64.93 143.62,64.93 143.38,64.69 R189.2 142.68,64.69 v2(142.39,64.4) ; v2(160.62,125.18) 160.47,125.34 PC104.2 ; C12172.2 29.03,39.17 C12197.2 29.09,38.34 v2(30.07,38.34) ; C221.2 v2(176.98,59.04) ; v2(34.62,247.64) 34.62,248.2 PR4453.1 ; PR165.2 23.83,75.41 v2(23.82,75.42) ; v2(148.79,240.02) 148.79,239.38 148.91,239.26 Q60.E ; R79376.1 18.61,28.05 v4(19.25,27.42) ; v2(148.28,124.27) 148.9,124.27 PR214.2 ; v2(101.67,101.59) 101.67,100.95 101.22,100.51 PR8334.2 ; v2(47.69,98.92) 47.76,98.98 C12417.2 ; PR208.2 148.98,123.18 v2(148.28,123.18) ; R78.2 144.33,197.01 C108.2 C107.2 145.55,196.96 147.13,196.96 147.64,197.47 147.64,197.61 v5(147.72,197.69) ; Q6704.E 111.29,82.44 v2(113.35,80.38) ; v5(86.44,100.64) 86.48,100.64 86.78,100.95 R629.2 ; v4(162.25,26.15) 162.12,26.02 C255.2 ; C67.2 v4(69.8,229.22) ; v2(73.75,76.76) 73.65,76.86 C7504.2 ; v2(149.76,89.8) 149.68,89.72 149.26,89.22 C140.1 ; C43.2 155.29,165.39 v2(155.47,165.21) ; Q1263.E v2(17.02,30.52) ; PC12185.2 109.5,20.96 v2(109.49,20.97) ; v2(121.23,56.31) 121.23,55.99 120.55,55.32 R293.2 119.49,55.32 118.86,55.94 C189.2 ; v5(63.32,85.46) 63,85.77 C12400.2 ; R5.2 104.65,226.01 v2(105.45,226.81) C1.2 ; v2(35.1,42.66) 34.97,42.53 C9516.2 33.72,42.15 R9609.2 ; R457.2 v2(186.73,105.02) ; C2.2 115.58,224.59 v2(115.77,224.78) ; PC8315.2 PR8335.2 99.32,106.29 PC8314.2 98.81,105.84 98.62,106.03 v2(98.62,106.74) ; v2(92.02,121.65) 91.7,121.33 C12382.2 ; v2(60,23.47) 60.14,23.33 60.14,23.15 60.27,23.02 C3454.2 ; C12437.2 47.82,116.19 v2(47.57,115.94) C7521.2 ; PC12172.2 30.23,32.43 31.01,31.66 C12246.2 ; R80040.2 C12392.2 61.16,109.33 v5(61.38,109.1) ; v2(16.71,53.33) 16.71,52.25 C12114.2 ; v2(38.42,49.77) 38.42,49.58 38.11,49.26 C12191.2 ; UHS1.MS1 198,68.45 ; R533.2 v2(19.12,48.35) 19.22,48.25 20.01,48.25 C12113.2 ; C173.2 v2(83.51,77.58) 83.25,77.84 C12441.2 ; v2(94.64,69.23) 94.64,68.61 U6.4 ; PQ5301.S 19.15,106.03 v2(17.09,106.03) ; R615.2 85.59,103.06 v5(85.62,103.03) ; PC12176.2 7.16,162.58 v2(7.16,163.59) ; R9604.2 42.36,39.48 v2(42.41,39.53) 43.38,38.57 C12186.2 43.31,38.34 C12171.2 ; C502.2 75.05,106.62 v5(74.8,106.36) ; v5(151.69,155.35) 151.96,155.62 R84.2 ; Q1261.S v2(18.97,39.83) 21.12,39.83 R19.2 ; C12393.2 63.02,110.73 62.89,110.86 v5(62.89,111.58) ; v2(7.44,176.01) 6.93,175.5 R362.1 ; C436.2 106.18,83.74 v2(106.11,83.81) ; Q1265.E 56.52,20.37 55.44,21.45 v2(55.44,21.58) ; C37.2 154.2,173.34 v2(155.64,173.34) ; R79237.1 25.79,27.61 26.36,28.18 v2(26.36,28.56) ; v5(88.71,122.31) 88.71,122.03 88.27,121.59 R192.2 88.37,121.27 89.03,121.27 89.16,121.4 R79988.1 ; v5(73.68,100.11) 73.16,100.63 R79979.2 ; C435.2 78,123.13 77.74,123.38 v2(77.74,123.81) ; C442.2 74.75,115.01 C455.2 ; v2(38.52,255.99) 38.99,255.51 41.19,255.51 PC4430.2 ; R1685.2 138.25,89.86 v2(138.8,89.3) ; PR4462.2 v2(44.27,236.84) ; C12390.2 v2(84.65,77.58) ; v2(72.59,130.67) 72.97,130.29 C417.2 ; C12120.2 53.73,21.89 v2(54.48,22.64) ; v4(177.62,26.53) 177.36,26.28 C261.2 ; C413.2 66.46,125.31 v2(66.36,125.21) ; v5(71.59,105.58) 71.38,105.79 C12409.2 C12416.2 ; R223.2 148.02,95.36 148.53,94.86 149.14,94.86 v2(149.15,94.84) ; v2(31.82,49.85) 32.07,49.59 C12195.2 ; C438.1 C443.1 v5(91.8,118.35) ; R137.2 173.7,77.58 v2(173.86,77.74) ; C9518.2 30.04,49.26 30.55,49.77 v2(30.97,49.77) 31.06,49.68 C12194.2 ; v2(23.82,73.34) PC84.2 ; U9502.1 43.88,47.48 v2(44.65,48.25) ; C64.2 v4(60.39,229.22) ; C376.2 76.93,51.89 76.93,51.17 v2(76.9,51.14) 76.93,51.12 76.93,49.81 C381.2 ; C60.2 v4(64.97,229.22) ; C447.2 96.32,87.81 95.75,88.38 v2(95.32,88.38) ; PR4420.2 v2(51.63,255.51) ; v2(147.91,82.37) 147.97,82.31 147.97,82.02 148.23,81.76 C11833.2 ; v2(148.33,89.09) 148.28,89.14 148.19,89.14 147.74,89.59 147.74,90.45 R224.2 ; Q9634.E 80.36,49.23 79.51,50.09 R80218.2 79.32,50.41 78.61,51.12 v2(78.5,51.12) ; v2(22.55,21.51) 22.96,21.51 23.41,21.07 D5212.1 25.01,21.06 25.01,20.06 D5211.1 ; PC4416.2 v2(46.68,253.88) ; C12408.2 v2(86.62,80.25) ; C12413.2 C6713.2 77.79,93.95 78.02,94.18 v2(78.02,94.22) ; v2(44.19,27.16) C12174.2 ; v5(88.18,103.95) 88.65,103.95 R610.1 89.79,104.16 R616.2 ; v2(139.93,69.18) 139.93,69.2 139.95,69.21 R246.2 ; C182.2 112.32,50.54 v2(112.48,50.7) ; R620.2 C12414.2 78.12,92.06 v2(78.4,91.78) ; C9504.2 36.2,47.29 36.39,47.1 v2(36.39,46.6) ; v2(23.84,72.33) PR168.2 ; v2(143.47,82.66) 143.38,82.66 143.25,82.79 R79770.1 ; v2(35.02,253.61) 35.15,253.48 PR4409.1 35.82,252.72 PC4407.2 ; PR5309.2 v2(6.67,113.4) ; C437.1 v2(72.08,122.29) ; PC85.2 v2(23.82,76.44) ; PC90.2 165.3,212.18 v2(164.74,212.73) ; C6724.2 90.47,107.17 89.65,106.36 v5(88.99,106.36) ; v5(61.92,109.59) 62.05,109.71 C12433.2 ; v2(145.78,97.18) 145.78,97.1 146.25,96.63 C144.1 ; v2(31.44,78.73) 31.49,78.78 31.49,79.2 30.8,79.89 PC70.1 ; PC4408.2 v2(34.97,254.49) ; R1799.2 160.91,83.43 v2(161.6,84.11) ; Q1249.S 170.85,53.1 170.88,53.07 v2(170.88,52.79) ; v2(103.43,65.65) 103.32,65.65 102.81,66.15 C197.2 ; U9601.1 v2(35.53,31.74) ; R79994.2 83.75,99.81 v5(83.96,99.6) 84.47,100.11 R621.2 ; R79944.2 151.96,70.66 R1994.2 152.51,70.98 v2(152.68,70.81) ; v2(151.07,93.71) R227.2 ; R523.2 24.64,46.79 24.25,47.18 v2(24.25,47.83) ; U33.4 104.06,87.76 104.26,87.76 v2(104.34,87.69) ; v2(56.84,33.13) 57.22,32.75 C12154.2 ; PC4401.2 v2(42.11,254.39) ; v5(70.17,99.91) 70.17,99.91 70.71,99.36 C12387.2 71.7,99.11 71.7,97.84 R79782.2 ; PC4423.2 v2(34.46,244.33) ; R79985.1 v2(89.1,125.56) ; PR166.2 36.38,74.61 v2(35.45,74.61) ; v5(158.94,171.08) 159.6,170.42 C103.2 C102.2 C101.2 159.2,172.96 v5(158.82,173.34) 158.44,173.72 C48.2 159.78,174.53 C127.2 C126.2 ; v2(133.29,101.97) 133.29,102.28 PC12181.2 ; 165.16,37.28 164.79,36.91 C233.2 164.99,34.91 166.31,34.91 C232.2 ; C12162.1 189.93,135.09 189.63,134.78 v2(189.63,134.58) 189.63,134.3 189.86,134.07 C12163.2 ; PC12177.2 v2(17.85,146.8) ; v5(67.29,77.52) 67.22,77.46 C12438.2 ; C295.2 C294.2 v2(57.35,22.85) ; PR5303.2 v2(6.42,119.75) ; PC4429.2 v2(44.65,253.88) ; C6707.1 72.29,117.84 v5(72.4,117.95) ; C12157.2 v2(190.44,151.12) ; C6710.2 92.08,110.96 91.64,110.51 C6708.2 91,110.96 v5(90.62,111.34) 90.11,110.83 C484.2 ; C357.2 79.06,39.43 79.19,39.56 79.19,40.22 v2(79.22,40.19) ; C12155.1 v2(185.87,146.04)
  BOTTOM w0.635: USB4.4 134.5,10.76 ; USB4.4 134.5,8.7 ; USB4.4 135.53,9.73 ; USB4.4 133.47,9.73 ; USB2.5 118.29,21.52 ; USB2.5 116.58,19.8 ; USB2.5 118.29,18.09 ; USB2.5 120.01,19.8 ; TC4.2 181.08,94.22 ; TC4.2 178.97,94.22 ; TC4.2 180.03,93.17 ; 145.09,20.48 HDMI2.21 ; HDMI2.21 150.47,20.48 ; HDMI2.21 147.78,19.36 ; HDMI2.21 147.78,21.6 ; 71.69,22.23 DCIN1.2 74.82,22.23 ; 116.58,42.8 USB1.5 ; USB1.5 120.01,42.8 ; USB1.5 118.29,41.09 ; USB3.6 133.51,29.66 ; USB3.6 130.08,29.66 ; USB3.6 131.79,31.38 ; USB3.6 131.79,27.95 ; HDD1.7 9.03,80.69 ; HDD1.7 8.15,79.81 ; HDD1.7 9.91,79.81 ; USB1.4 122.03,32.73 ; USB1.4 119.97,32.73 ; USB1.4 121,33.76 ; USB1.4 121,31.7 ; 9.28,87.31 ODD2.8 ; ODD2.8 10.6,88.63 ; ODD2.8 7.96,88.63 ; ODD2.8 9.28,89.95 ; HDMI1.22 147.78,30.1 ; HDMI1.22 145.09,28.98 ; HDMI1.22 147.78,27.86 ; HDMI1.22 150.47,28.98 ; ODD2.1 9.91,91.19 ; ODD2.1 8.15,91.19 ; ODD2.1 9.03,90.31 ; USB1.6 118.29,31.38 ; USB1.6 116.58,29.66 ; USB1.6 118.29,27.95 ; USB1.6 120.01,29.66 ; 197.58,79.09 UHS1.MS2 ; UHS1.MS2 199,80.11 ; UHS1.MS2 200.42,79.09 ; SSUSB2.4 192.62,91.93 ; SSUSB2.4 191.73,91.04 ; SSUSB2.4 192.62,90.15 ; DCIN1.6 69.88,24.94 ; DCIN1.6 70.97,23.38 ; DCIN1.6 69.88,21.82 ; DCIN1.6 68.79,23.38 ; SSUSB1.10 196.12,110.71 ; SSUSB1.10 197.99,109.64 ; SSUSB1.10 196.12,108.57 ; 9.28,100.05 ODD2.9 ; ODD2.9 7.96,101.37 ; ODD2.9 10.6,101.37 ; USB3.5 133.51,42.8 ; USB3.5 131.79,41.09 ; USB3.5 130.08,42.8 ; 193.23,94.54 SSUSB2.7 ; SSUSB2.7 194.12,93.65 ; SSUSB2.7 194.12,95.43 ; SSUSB2.7 195.01,94.54 ; 194.25,88.14 SSUSB2.10 ; SSUSB2.10 196.12,87.07 ; SSUSB2.10 197.99,88.14 ; SSUSB2.10 196.12,89.21 ; HDMI1.21 147.78,44.6 ; HDMI1.21 145.09,43.48 ; HDMI1.21 147.78,42.36 ; HDMI1.21 150.47,43.48 ; HDMI2.22 147.78,7.1 ; HDMI2.22 145.09,5.98 ; HDMI2.22 147.78,4.86 ; HDMI2.22 150.47,5.98 ; HDD1.9 9.28,83.69 ; HDD1.9 9.28,81.05 ; HDD1.9 10.6,82.37 ; HDD1.9 7.96,82.37 ; SSUSB2.11 196.12,102.01 ; SSUSB2.11 197.99,100.94 ; SSUSB2.11 196.12,99.87 ; 130.08,6.66 USB4.6 ; USB4.6 131.79,8.38 ; USB4.6 131.79,4.95 ; USB4.6 133.51,6.66 ; 9.03,71.31 HDD1.1 ; HDD1.1 8.15,72.19 ; HDD1.1 9.91,72.19 ; 145.25,33.41 HDMI1.20 ; HDMI1.20 144.13,36.23 ; HDMI1.20 145.25,39.05 ; HDMI1.20 146.37,36.23 ; 158.53,234.39 HS6.1 ; HS6.1 162.14,238 ; HS6.1 158.53,241.61 ; HS6.1 154.92,238 ; 72.39,29.1 DCIN1.7 72.39,28.01 ; HDMI2.20 146.37,13.23 ; HDMI2.20 144.13,13.23 ; HDMI2.20 145.25,16.05 ; HDMI2.20 145.25,10.41 ; 134.5,31.7 USB3.4 ; USB3.4 135.53,32.73 ; USB3.4 134.5,33.76 ; USB3.4 133.47,32.73 ; 199.42,69.89 UHS1.MS1 196.58,69.89 ; 72.39,20.36 DCIN1.5 75.52,20.36 ; 116.58,6.66 USB2.6 ; USB2.6 118.29,4.95 ; USB2.6 120.01,6.66 ; USB2.6 118.29,8.38 ; 130.08,19.8 USB4.5 ; USB4.5 133.51,19.8 ; USB4.5 131.79,21.52 ; 194.25,122.44 SSUSB1.11 ; SSUSB1.11 196.12,123.51 ; SSUSB1.11 197.99,122.44 ; SSUSB1.11 196.12,121.37 ; HDD1.8 9.28,70.95 ; HDD1.8 7.96,69.63 ; HDD1.8 9.28,68.31 ; HDD1.8 10.6,69.63 ; USB2.4 121,10.76 ; USB2.4 122.03,9.73 ; USB2.4 119.97,9.73 ; USB2.4 121,8.7 ; 76.63,21.82 DCIN1.4 75.54,21.82 ; 9.91,95 ODD2.4 8.15,95 ; 8.15,98.81 ODD2.7 ; ODD2.7 9.91,98.81 ; ODD2.7 9.03,99.69
  vias: v1(5.02,110.6) v1(9.34,264.65) v1(15.69,188.84) v1(17.21,210.43) v1(34.44,9.36) v1(37.66,86.85) v1(68.4,238.24) v1(99.51,264.65) v1(138.88,262.62) v1(157.55,253.1) v1(160.85,5.32) v1(163.01,19.16) v1(172.66,236.46) v1(172.92,224.65) v1(178.76,169.53) v1(184.73,122.41) v1(185.49,87.49) v1(188.28,104.89) v2(1.32,266.58) v2(1.32,264.04) v2(1.32,261.5) v2(1.32,258.96) v2(1.32,256.42) v2(1.32,253.88) v2(1.32,251.34) v2(1.32,248.8) v2(1.32,246.26) v2(1.32,243.72) v2(1.32,241.18) v2(1.32,238.64) v2(1.32,236.1) v2(1.32,233.56) v2(1.32,231.02) v2(1.32,228.48) v2(1.32,225.94) v2(1.32,223.4) v2(1.32,218.32) v2(1.32,215.78) v2(1.32,213.24) v2(1.32,210.7) v2(1.32,208.16) v2(1.32,205.62) v2(1.32,203.08) v2(1.32,200.54) v2(1.32,198) v2(1.32,195.46) v2(1.32,192.92) v2(1.32,190.38) v2(1.32,187.84) v2(1.32,185.3) v2(1.32,182.76) v2(1.32,180.22) v2(1.32,177.68) v2(1.32,175.14) v2(1.32,172.6) v2(1.32,170.06) v2(1.32,167.52) v2(1.32,164.98) v2(1.32,162.44) v2(1.32,159.9) v2(1.32,157.36) v2(1.32,154.82) v2(1.32,152.28) v2(1.32,149.74) v2(1.32,142.12) v2(1.32,139.58) v2(1.32,137.04) v2(1.32,134.5) v2(1.32,131.96) v2(1.32,129.42) v2(1.32,126.88) v2(1.32,124.34) v2(1.32,121.8) v2(1.32,119.26) v2(1.32,116.72) v2(1.32,114.18) v2(1.32,111.64) v2(1.32,109.1) v2(1.32,106.56) v2(1.32,104.02) v2(1.32,101.48) v2(1.32,98.94) v2(1.32,96.4) v2(1.32,93.86) v2(1.32,91.32) v2(1.32,88.78) v2(1.32,86.24) v2(1.32,83.7) v2(1.32,78.62) v2(1.32,76.08) v2(1.32,73.54) v2(1.32,71) v2(1.32,68.46) v2(1.32,65.92) v2(1.32,19.67) v2(1.32,17.13) v2(1.32,14.59) v2(1.32,12.05) v2(1.32,9.51) v2(1.32,6.97) v2(1.32,4.43) v2(1.57,268.41) v2(1.72,21.45) v2(1.72,1.76) v2(2.25,64.3) v2(2.48,135.95) v2(3.14,110.98) v2(3.24,261.73) v2(3.63,8.75) v2(3.63,7.61) v2(3.63,6.59) v2(3.63,5.7) v2(4.01,1.38) v2(4.3,268.68) v2(4.41,8.8) v2(4.41,7.66) v2(4.41,6.77) v2(4.41,5.75) v2(4.54,21.65) v2(4.79,64.3) v2(5.78,261.73) v2(6.55,1.38) v2(6.84,268.68) v2(7.33,64.3) v2(7.28,21.68) v2(7.94,263.89) v2(7.94,4.69) v2(8.4,105.68) v2(8.53,266.43) v2(8.83,4.69) v2(9.09,1.38) v2(9.38,268.68) v2(9.59,4.74) v2(9.87,64.3) v2(10.23,21.68) v2(10.36,4.69) v2(10.61,209.41) v2(10.61,190.52) v2(10.61,189.34) v2(10.61,188.16) v2(11.92,268.68) v2(12.39,1.51) v2(12.57,22.26) v2(13.28,62.6) v2(13.32,60.57) v2(13.32,58.03) v2(13.32,55.49) v2(13.32,52.95) v2(13.32,50.41) v2(13.32,47.87) v2(13.32,40.25) v2(13.33,30.11) v2(13.32,27.55) v2(13.32,25.01) v2(13.35,35.37) v2(13.66,12.13) v2(14.46,268.68) v2(14.8,247.64) v2(14.93,3.16) v2(14.93,1.51) v2(17,268.68) v2(17.09,243.19) v2(17.04,84.26) v2(17.06,79.18) v2(17.24,81.39) v2(17.26,76.74) v2(17.47,3.16) v2(17.47,1.51) v2(18.92,126.45) v2(19.09,128.87) v2(19.22,236.41) v2(19.54,268.68) v2(19.75,168.01) v2(20.01,3.16) v2(20.01,1.51) v2(20.64,168.01) v2(21.07,267.09) v2(21.53,168.01) v2(22.08,268.68) v2(22.17,98.16) v2(22.17,95.62) v2(22.55,94.6) v2(22.55,92.06) v2(22.55,3.16) v2(22.55,1.51) v2(23.95,261.61) v2(24.62,268.68) v2(25.09,1.51) v2(25.16,136.64) v2(25.34,127.62) v2(25.72,137.2) v2(25.72,136.08) v2(26.1,128.18) v2(26.1,127.42) v2(26.28,136.64) v2(26.51,267.07) v2(26.87,247) v2(26.87,242.43) v2(27.16,268.68) v2(27.34,250.3) v2(27.63,1.51) v2(28.72,75.68) v2(28.77,261.61) v2(29.28,76.24) v2(29.7,268.68) v2(29.84,75.68) v2(30.06,35.7) v2(30.07,34.91) v2(30.17,1.51) v2(30.98,267.22) v2(32.24,268.68) v2(32.71,32.84) v2(32.71,1.51) v2(34.78,268.68) v2(34.74,261.61) v2(35.25,1.51) v2(35.5,3.42) v2(37.32,268.68) v2(37.24,158.86) v2(37.79,90.66) v2(37.79,89.14) v2(37.79,3.16) v2(37.79,1.51) v2(38.55,90.66) v2(38.68,89.14) v2(39.86,268.68) v2(40.33,245.48) v2(40.33,3.16) v2(40.33,1.51) v2(41.07,159.05) v2(41.22,245.48) v2(41.22,31.74) v2(41.24,32.75) v2(42.11,247.38) v2(42.11,246.49) v2(42.11,245.48) v2(42.11,244.59) v2(42.11,243.7) v2(43,245.48) v2(43.76,3.03) v2(43.76,1.38) v2(43.88,245.48) v2(44.13,158.8) v2(44.39,155.9) v2(46.04,102.19) v2(46.04,101.33) v2(46.3,3.03) v2(46.3,1.38) v2(46.42,155.9) v2(46.53,158.69) v2(47.06,104.51) v2(47.08,103.75) v2(47.11,102.98) v2(47.67,186.78) v2(47.69,31.36) v2(48.84,3.03) v2(48.84,1.38) v2(49.61,36.57) v2(49.72,38.43) v2(49.64,34.89) v2(50.18,186.73) v2(50.56,188.43) v2(51.38,3.03) v2(51.38,1.38) v2(51.5,34.02) v2(51.89,126.1) v2(52.56,268.68) v2(52.65,186.8) v2(52.65,126.22) v2(52.74,189.14) v2(53.92,126.22) v2(53.92,3.03) v2(53.92,1.38) v2(55.1,268.68) v2(55.03,189.04) v2(56.46,3.03) v2(56.46,1.38) v2(57.64,268.68) v2(59,126.1) v2(59,3.03) v2(59,1.38) v2(60.18,268.68) v2(60.39,126.1) v2(60.65,27.55) v2(61.54,3.03) v2(61.54,1.38) v2(61.66,28.43) v2(61.66,27.55) v2(61.66,26.66) v2(62.55,27.55) v2(62.72,268.68) v2(62.88,34.37) v2(64.08,3.03) v2(64.08,1.38) v2(65.13,37.15) v2(65.26,268.68) v2(65.26,34.36) v2(66.01,261.1) v2(66.62,1.31) v2(67.25,261.1) v2(67.47,37.03) v2(67.8,268.68) v2(68.5,261.15) v2(68.62,51.24) v2(69.16,1.31) v2(70.07,37.04) v2(70.34,268.68) v2(70.88,131.81) v2(71.7,1.31) v2(72.71,38.59) v2(72.88,268.68) v2(73.01,132.2) v2(73.07,48.93) v2(73.48,39.36) v2(73.48,38.59) v2(73.48,37.83) v2(73.83,48.93) v2(74.24,38.59) v2(74.24,1.31) v2(75.42,268.68) v2(76.78,1.38) v2(77.96,268.68) v2(78.56,1.31) v2(80.5,268.68) v2(80.71,67.3) v2(80.74,66.41) v2(81.1,1.31) v2(83.04,268.68) v2(83.51,19.67) v2(83.51,18.66) v2(84.91,143.88) v2(85.19,141.51) v2(85.58,268.68) v2(86.43,143.88) v2(86.43,141.34) v2(86.94,19.67) v2(86.94,18.66) v2(87.83,144) v2(87.83,141.46) v2(88.12,268.68) v2(88.61,58.93) v2(89,142.1) v2(89.48,1.38) v2(90.06,53.83) v2(90.21,142.1) v2(90.62,137.29) v2(90.57,135.95) v2(90.66,268.68) v2(90.87,147.31) v2(90.87,144.89) v2(91,143.12) v2(92.02,1.38) v2(92.27,142.99) v2(92.45,97.55) v2(92.59,86.92) v2(92.6,85.69) v2(92.6,82.66) v2(92.73,83.55) v2(92.91,260.34) v2(92.99,147.46) v2(93.03,96.63) v2(93.2,268.68) v2(93.29,114.79) v2(93.29,91.43) v2(93.41,144.89) v2(93.41,142.35) v2(93.44,97.6) v2(94.09,260.34) v2(94.3,147.43) v2(94.33,97.65) v2(94.56,91.43) v2(94.56,1.38) v2(94.85,260.31) v2(95.74,268.68) v2(96.37,55.05) v2(96.97,263.77) v2(97.1,1.38) v2(97.35,263) v2(97.86,263.77) v2(98.28,268.68) v2(98.24,263) v2(98.75,263.77) v2(99.13,263) v2(99.64,263.77) v2(99.64,1.38) v2(100.02,263) v2(100.53,263.77) v2(100.82,268.68) v2(100.91,263) v2(101.42,263.77) v2(101.8,263) v2(102.18,1.38) v2(102.56,102.48) v2(102.56,100.7) v2(102.91,262.79) v2(103.36,268.68) v2(103.45,101.59) v2(104.72,1.38) v2(105.9,268.68) v2(105.99,3.57) v2(107.26,1.38) v2(108.44,268.68) v2(109.54,6.59) v2(109.8,1.38) v2(110.98,268.68) v2(112.08,40.12) v2(112.34,1.38) v2(113.52,268.68) v2(114.88,1.38) v2(116.06,268.68) v2(116.4,39.48) v2(117.42,1.38) v2(118.6,268.68) v2(118.56,82.91) v2(118.76,79.84) v2(119.96,1.38) v2(120.47,83.74) v2(120.47,76.31) v2(121.14,268.68) v2(121.35,80.5) v2(122.5,1.38) v2(123.68,268.68) v2(124.76,74.38) v2(125.04,1.38) v2(125.8,12.05) v2(126.1,135.98) v2(126.22,268.68) v2(126.39,82.15) v2(126.5,70.88) v2(126.82,73.39) v2(126.92,129.25) v2(127.16,79.36) v2(127.25,38.8) v2(127.58,1.38) v2(127.79,82.38) v2(127.96,134.3) v2(128.21,73.77) v2(128.26,130.19) v2(128.34,12.05) v2(128.47,67.21) v2(128.64,71.33) v2(128.76,268.68) v2(129.51,128.59) v2(129.48,81.52) v2(129.61,72.25) v2(130.12,1.38) v2(130.88,129.22) v2(130.88,126.73) v2(131.3,268.68) v2(131.98,65.22) v2(132.58,71.13) v2(132.66,1.38) v2(133.29,127.37) v2(133.55,70.34) v2(133.84,268.68) v2(133.97,64.6) v2(134.05,66.33) v2(134.44,69.3) v2(134.56,127.37) v2(135.2,1.38) v2(135.38,70.96) v2(135.43,68.04) v2(135.53,61.43) v2(136.38,268.68) v2(137.82,61.43) v2(137.74,1.38) v2(138.63,38.75) v2(138.92,268.68) v2(139.35,26.74) v2(140.1,64.38) v2(140.18,133.18) v2(140.15,21.58) v2(140.28,23.74) v2(140.28,1.38) v2(140.79,38.7) v2(141.17,266.81) v2(141.17,264.4) v2(141.17,134.23) v2(141.17,133.21) v2(141.34,200.62) v2(141.46,268.68) v2(141.8,172.45) v2(142.31,200.11) v2(142.44,263) v2(142.56,172.45) v2(142.69,38.64) v2(142.82,1.38) v2(143.07,169.15) v2(143.45,172.45) v2(143.71,266.81) v2(143.71,264.4) v2(144,268.68) v2(144.21,262.37) v2(145.16,267.3) v2(145.16,264.76) v2(145.16,262.22) v2(145.36,1.38) v2(145.48,118.07) v2(147.9,1.38) v2(148.8,258.68) v2(149.19,10.63) v2(150.51,110.73) v2(150.51,109.97) v2(150.44,1.38) v2(151.34,258.68) v2(151.47,254.74) v2(152.32,243.67) v2(152.98,1.38) v2(153.26,88.51) v2(153.46,43.55) v2(153.61,226.55) v2(153.71,42.53) v2(153.88,258.68) v2(154.01,254.74) v2(154.22,240.7) v2(154.63,125.46) v2(154.63,124.45) v2(154.63,123.43) v2(154.88,226.68) v2(155.26,5.7) v2(155.47,38.37) v2(155.52,1.38) v2(155.64,205.09) v2(155.72,204.2) v2(156.15,226.68) v2(156.28,165.21) v2(156.42,258.68) v2(156.55,254.74) v2(156.53,204.96) v2(156.66,130.03) v2(156.74,204.2) v2(158.06,1.38) v2(158.57,18.02) v2(158.96,258.68) v2(159.09,254.74) v2(159.91,45.68) v2(160.22,52.95) v2(160.92,46.57) v2(160.92,45.68) v2(160.92,44.66) v2(161.23,20.43) v2(161.5,258.68) v2(161.63,254.74) v2(161.87,16.75) v2(161.94,45.68) v2(162.06,15.53) v2(162.27,6.59) v2(162.98,235.6) v2(163.14,1.38) v2(163.66,7.23) v2(163.8,14.69) v2(163.79,8.24) v2(164.04,258.68) v2(164.04,9.38) v2(164.17,254.74) v2(164.82,48.28) v2(165.17,53.07) v2(165.48,9.45) v2(165.7,36.26) v2(165.68,1.38) v2(166.58,258.68) v2(166.71,254.74) v2(168.07,215.62) v2(168.22,1.38) v2(168.63,216.18) v2(168.63,215.06) v2(169.12,258.68) v2(169.18,215.62) v2(169.25,254.74) v2(170.12,250.56) v2(170.76,34.15) v2(170.76,1.38) v2(171.27,166.48) v2(171.27,165.72) v2(171.27,164.96) v2(171.27,164.2) v2(171.27,163.44) v2(171.66,258.68) v2(171.9,35.17) v2(171.9,34.15) v2(171.9,33.13) v2(172.66,250.56) v2(172.87,133.44) v2(173.04,34.15) v2(173.3,130.59) v2(173.3,1.38) v2(173.65,76.67) v2(174.2,258.68) v2(174.14,13.58) v2(175.2,248.78) v2(175.2,246.24) v2(175.2,243.7) v2(175.2,241.16) v2(175.2,238.62) v2(175.2,236.08) v2(175.2,233.54) v2(175.84,1.38) v2(176.73,108.95) v2(176.74,258.68) v2(176.83,111.46) v2(176.88,254.95) v2(176.9,152.16) v2(176.9,142.99) v2(176.93,138.19) v2(176.98,147.56) v2(177.74,59.04) v2(177.74,10.27) v2(178.22,188.73) v2(178.22,174.92) v2(178.38,1.38) v2(178.5,60.57) v2(178.5,59.8) v2(178.5,59.04) v2(178.5,57.52) v2(179.04,141.91) v2(179.28,258.68) v2(179.27,59.04) v2(179.39,107.42) v2(179.34,100.6) v2(179.77,118.22) v2(179.9,115.05) v2(180.03,104) v2(180.03,59.04) v2(180.16,142.86) v2(180.28,252.72) v2(180.66,100.49) v2(180.89,107.38) v2(180.92,1.38) v2(181.04,201.66) v2(181.04,199.12) v2(181.22,164.07) v2(181.45,188.94) v2(181.48,172.45) v2(181.55,179.95) v2(181.82,258.68) v2(181.93,249.29) v2(181.93,246.75) v2(181.93,244.21) v2(181.93,241.67) v2(181.93,239.13) v2(181.93,236.59) v2(181.93,234.05) v2(182.01,153.43) v2(182.06,154.19) v2(182.19,157.72) v2(182.19,144.26) v2(182.22,88.31) v2(182.26,142.91) v2(182.52,115.68) v2(182.55,112.95) v2(182.7,253.35) v2(182.7,138.87) v2(183.41,133.31) v2(183.46,256.27) v2(183.48,88.28) v2(183.46,1.38) v2(184.09,94.29) v2(184.17,91.93) v2(184.36,258.68) v2(184.4,125.77) v2(184.57,162.65) v2(184.94,12.87) v2(184.94,10.33) v2(184.94,7.79) v2(184.94,5.25) v2(184.94,2.71) v2(185.06,154.75) v2(185.16,256.94) v2(185.16,254.4) v2(185.16,251.86) v2(185.16,249.32) v2(185.16,246.78) v2(185.16,244.24) v2(185.16,241.7) v2(185.16,239.16) v2(185.16,236.62) v2(185.16,234.08) v2(185.16,231.54) v2(185.69,138.72) v2(185.82,133.54) v2(185.87,121.91) v2(185.87,82.41) v2(186.25,139.94) v2(186.38,141.34) v2(188,91.12) v2(188,88.58) v2(188.16,82.28) v2(188.68,219.57) v2(188.68,217.03) v2(188.68,214.49) v2(188.68,211.95) v2(188.68,209.41) v2(188.68,206.87) v2(188.68,204.33) v2(188.68,201.79) v2(188.68,199.25) v2(188.68,196.71) v2(188.68,194.17) v2(188.68,191.63) v2(188.68,189.09) v2(188.68,186.55) v2(188.68,184.01) v2(188.68,181.47) v2(188.68,178.93) v2(188.68,176.39) v2(188.68,173.85) v2(188.68,171.31) v2(188.68,168.77) v2(188.68,166.23) v2(188.68,163.69) v2(188.68,49.66) v2(188.68,47.12) v2(188.68,44.58) v2(188.68,42.04) v2(188.68,39.5) v2(188.68,36.96) v2(188.68,34.42) v2(188.68,31.88) v2(188.68,29.34) v2(188.68,26.8) v2(188.68,24.26) v2(189.05,124.9) v2(189.43,82.54) v2(189.55,105.4) v2(189.55,104.63) v2(189.93,141.72) v2(190.57,82.54) v2(190.95,142.61) v2(190.99,141.74) v2(190.95,140.83) v2(191.97,141.72) v2(192.3,124.01) v2(192.45,160.28) v2(192.45,87.93) v2(192.45,85.39) v2(192.45,82.85) v2(192.63,137.5) v2(193.74,138.92) v2(194.99,160.28) v2(195.4,136.51) v2(195.34,125.74) v2(195.65,105.78) v2(195.78,103.11) v2(196.16,128.38) v2(196.67,154.93) v2(196.74,84.95) v2(196.74,82.41) v2(197.05,138.16) v2(197.15,98.03) v2(197.15,95.49) v2(197.15,92.95) v2(197.15,90.41) v2(197.27,119.59) v2(197.27,117.05) v2(197.27,114.51) v2(197.27,111.97) v2(197.53,160.28) v2(197.76,144.31) v2(197.81,140.45) v2(197.94,126.22) v2(198.19,105.78) v2(198.32,103.11) v2(198.3,67.42) v2(198.82,128.13) v2(198.87,148.93) v2(200.07,160.28) v2(200.3,83.86) v2(200.3,81.32) v2(200.35,107.91) v2(200.45,127.24) v2(200.5,99.1) v2(200.5,96.56) v2(200.5,94.02) v2(200.5,91.48) v2(200.5,88.94) v2(200.5,86.4) v2(200.75,120.43) v2(200.75,117.89) v2(200.75,115.35) v2(200.75,112.81) v2(200.75,110.27) v2(200.84,67.42) v2(201.49,125.34) v2(202.13,150.74) v2(202.13,148.2) v2(202.13,145.66) v2(202.13,143.12) v2(202.13,140.58) v2(202.13,138.04) v2(202.13,135.5) v2(202.05,128.18) v2(202.74,102.22) v2(203.68,151.19) v2(203.68,148.65) v2(203.68,146.11) v2(203.68,143.57) v2(203.68,141.03) v2(203.68,138.49) v2(203.68,135.95) v2(203.65,128) v2(203.68,125.34) v2(203.68,123.25) v2(203.68,120.71) v2(203.68,118.17) v2(203.68,115.63) v2(203.68,113.09) v2(203.68,110.55) v2(203.68,100.15) v2(203.68,97.61) v2(203.68,95.07) v2(203.68,92.53) v2(203.68,89.99) v2(203.68,87.45) v2(203.68,84.01) v2(203.68,82.37) v3(6.8,257.54) v3(12.52,225.54) v3(12.52,203.06) v3(15.31,102.73) v3(15.56,188.84) v3(19.37,177.15) v3(23.18,242.94) v3(32.07,262.24) v3(32.96,150.23) v3(34.61,150.61) v3(35.91,78.5) v3(37.64,72.43) v3(54.81,126.35) v3(63.44,263.26) v3(63.7,28.18) v3(65.04,32.8) v3(67.76,71.61) v3(68.52,238.01) v3(70.17,258.18) v3(79.7,183.12) v3(85.67,20.56) v3(91.64,114.92) v3(102.81,263.77) v3(109.8,243.83) v3(118.56,87.24) v3(120.34,232.4) v3(122.12,23.86) v3(130.5,263.89) v3(141.17,31.36) v3(141.8,47.74) v3(141.93,174.36) v3(142.31,161.78) v3(146.5,244.97) v3(153.36,116.06) v3(153.74,12.43) v3(155.39,212.33) v3(155.64,163.94) v3(161.11,12.89) v3(164.15,50.53) v3(167.68,11.58) v3(170.63,124.32) v3(171.39,162.42) v3(174.54,145.68) v3(177.36,230.87) v3(178.63,181.72) v3(188.79,92.32) v3(195.85,130.24) v4(3.12,106.92) v4(3.24,108.95) v4(9.09,222.11) v4(9.09,221.09) v4(9.09,220.08) v4(9.09,219.06) v4(9.09,204.08) v4(9.09,203.06) v4(9.09,202.04) v4(9.09,201.03) v4(9.21,226.4) v4(9.21,225.49) v4(9.21,224.52) v4(9.21,223.51) v4(10.1,222.11) v4(10.1,221.09) v4(10.1,220.08) v4(10.1,219.06) v4(10.1,204.08) v4(10.1,203.06) v4(10.1,202.04) v4(10.1,201.03) v4(10.23,226.4) v4(10.23,225.49) v4(10.23,224.52) v4(10.23,223.51) v4(11.12,222.11) v4(11.12,221.09) v4(11.12,220.08) v4(11.12,219.06) v4(11.12,204.08) v4(11.12,203.06) v4(11.12,202.04) v4(11.12,201.03) v4(11.22,226.4) v4(11.22,225.49) v4(11.22,224.52) v4(11.22,223.51) v4(12.39,186.81) v4(12.97,185.91) v4(13.15,133.21) v4(13.15,131.81) v4(13.3,186.78) v4(13.71,185.3) v4(13.91,226.68) v4(13.91,225.67) v4(14.01,187.36) v4(14.04,186.17) v4(14.29,224.65) v4(14.29,223.63) v4(14.29,222.62) v4(14.29,220.59) v4(14.29,219.57) v4(14.29,208.01) v4(14.29,207) v4(14.29,204.84) v4(14.29,203.82) v4(14.29,202.81) v4(14.29,201.79) v4(14.29,189.85) v4(14.55,209.03) v4(14.8,187.84) v4(14.8,186.68) v4(14.88,185.76) v4(15.31,224.65) v4(15.31,223.63) v4(15.31,222.62) v4(15.31,220.59) v4(15.31,219.57) v4(15.31,208.01) v4(15.31,207) v4(15.31,204.84) v4(15.31,203.82) v4(15.31,202.81) v4(15.31,190.87) v4(15.31,189.85) v4(15.56,209.03) v4(15.59,187.26) v4(15.69,186.3) v4(15.92,185.41) v4(16.33,224.65) v4(16.33,223.63) v4(16.33,222.62) v4(16.33,220.59) v4(16.33,219.57) v4(16.33,208.01) v4(16.33,207) v4(16.33,204.84) v4(16.33,203.82) v4(16.33,190.87) v4(16.33,189.85) v4(16.33,187.82) v4(16.45,186.8) v4(16.58,209.03) v4(16.71,226.68) v4(16.71,225.67) v4(16.83,192.52) v4(16.83,185.74) v4(17.49,226.15) v4(17.47,174.97) v4(17.57,175.88) v4(18.51,174.98) v4(18.57,175.89) v4(19.25,26.28) v4(19.42,174.97) v4(19.6,175.88) v4(20.62,175.88) v4(29.15,147.05) v4(29.15,146.04) v4(30.3,147.05) v4(30.3,146.04) v4(31.31,152.01) v4(31.31,150.99) v4(31.82,149.97) v4(32.45,152.01) v4(32.45,150.99) v4(33.6,152.01) v4(33.6,150.99) v4(34.51,77) v4(34.49,70.6) v4(34.74,152.01) v4(34.87,71.49) v4(35.25,69.84) v4(35.49,77.58) v4(35.76,70.85) v4(36.15,76.64) v4(36.26,70.09) v4(36.26,69.07) v4(36.41,77.58) v4(36.49,73.67) v4(36.59,71.46) v4(37.15,70.55) v4(37.51,73.67) v4(37.51,71.44) v4(38.42,71.33) v4(38.52,73.67) v4(38.85,70.5) v4(39.49,73.62) v4(47.69,212.97) v4(47.69,204.96) v4(47.69,197.09) v4(47.69,189.22) v4(48.71,212.97) v4(48.71,204.96) v4(48.71,197.09) v4(48.71,189.22) v4(52.42,82.59) v4(53.13,81.85) v4(56.97,82.92) v4(57.69,82.16) v4(61.41,237.98) v4(63.32,237.98) v4(63.7,70.6) v4(63.7,69.46) v4(63.82,68.44) v4(65.09,257.42) v4(65.09,256.4) v4(65.35,237.98) v4(66.11,257.42) v4(66.11,256.4) v4(67,69.84) v4(67,68.69) v4(67.13,257.42) v4(67.13,256.4) v4(67.25,237.86) v4(68.14,257.42) v4(68.14,256.4) v4(68.27,69.84) v4(68.4,68.69) v4(69.16,257.42) v4(69.16,256.4) v4(69.67,237.86) v4(69.89,184.77) v4(70.02,193.33) v4(70.17,257.16) v4(70.17,256.15) v4(70.88,184.72) v4(71.32,237.86) v4(71.77,193.08) v4(71.8,184.72) v4(72.79,184.69) v4(72.87,193.08) v4(73.6,262.11) v4(73.7,184.75) v4(73.93,193.09) v4(74.62,262.11) v4(74.72,184.72) v4(74.87,193.08) v4(75.76,184.75) v4(75.89,193.09) v4(76.85,193.1) v4(77.54,183.63) v4(77.77,193.09) v4(78.58,183.58) v4(78.68,193.05) v4(79.67,193.09) v4(83.91,25.13) v4(83.91,23.86) v4(84.84,23.86) v4(85.54,258.18) v4(85.54,255.38) v4(85.54,254.24) v4(86.56,259.19) v4(86.56,258.18) v4(86.68,255.38) v4(86.68,254.24) v4(87.57,259.19) v4(87.57,258.18) v4(87.83,255.38) v4(87.83,254.24) v4(87.83,70.47) v4(91.89,249.41) v4(91.89,248.4) v4(91.89,247.38) v4(95.7,249.29) v4(95.7,248.27) v4(95.67,247.26) v4(113.1,255.38) v4(113.1,254.24) v4(113.1,253.1) v4(113.71,82.87) v4(114.24,255.38) v4(114.24,254.24) v4(114.24,253.1) v4(114.61,92.73) v4(114.75,82.87) v4(115.72,82.84) v4(115.89,93.31) v4(116.35,92.52) v4(116.4,90.82) v4(116.5,94.09) v4(116.86,91.71) v4(116.96,93.23) v4(117.04,255.38) v4(117.04,254.24) v4(117.04,253.1) v4(117.49,92.42) v4(117.54,94.02) v4(118.03,93.23) v4(118.03,91.6) v4(118.18,255.38) v4(118.18,254.24) v4(118.18,253.1) v4(118.61,94.02) v4(118.61,92.47) v4(119.02,91.5) v4(119.14,93.23) v4(119.73,94.02) v4(119.65,92.39) v4(120.26,93.23) v4(120.85,94.02) v4(121.89,93.76) v4(125.06,128.84) v4(152.34,118.86) v4(152.34,117.84) v4(153.87,118.86) v4(153.87,117.84) v4(155.01,118.96) v4(155.01,117.84) v4(155.42,214.39) v4(155.48,210.84) v4(155.54,209.66) v4(155.9,213.6) v4(156.41,214.42) v4(156.74,210.84) v4(156.74,209.7) v4(156.91,213.6) v4(157.42,214.39) v4(157.8,210.81) v4(157.8,209.66) v4(157.93,213.6) v4(158.46,214.39) v4(167.84,126.33) v4(168.47,26.12) v4(169.03,126.27) v4(169.03,125.31) v4(169.74,26.15) v4(170.02,126.3) v4(170.02,125.34) v4(170.93,126.27) v4(170.93,125.31) v4(171.85,126.22) v4(171.85,125.27) v4(172.79,126.22) v4(172.79,125.27) v4(188.78,121.85) v5(58.33,83.17) v5(67,111.93) v5(67.18,117.84) v5(80.07,208.88) v5(81.93,96.96) v5(87.32,108.86) v5(147.83,178.24) v5(148.27,183.76) v5(148.37,189.67) v5(148.91,185.97) v5(149.06,151.78) v5(149.65,157.69) v5(149.68,141.92) v5(149.8,189.72) v5(149.75,147.87) v5(150.02,187.84) v5(150.18,144.82) v5(150.38,158.82) v5(150.46,185.51) v5(150.51,146.29) v5(150.94,186.65) v5(151.17,141.85) v5(161.99,181.93) v5(162.87,141.13) v5(163.41,195.06) v5(163.37,189.6) v5(163.36,147.97) v5(163.47,193.28) v5(163.52,188.07) v5(163.44,181.98) v5(163.7,157.9) v5(164.15,191.37) v5(164.14,156.55) v5(164.17,144.61) v5(164.15,142.35) v5(164.45,146.42) v5(164.78,147.97) v5(164.86,139.64) v5(164.99,188.12) v5(164.96,150.28) v5(165.14,157.92) v5(165.68,195.06) v5(165.68,191.57) v5(165.69,189.32) v5(165.68,143.12) v5(165.77,192.9) v5(165.77,182.55) v5(165.77,151.91) v5(165.74,141.13) v5(166.13,186.3) v5(166.38,197.95) v5(166.43,154.19) v5(167.9,199.27)
