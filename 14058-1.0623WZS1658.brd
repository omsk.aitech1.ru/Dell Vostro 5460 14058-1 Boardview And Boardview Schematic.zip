# Allegro board 14058-1.0623WZS1658.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R2089  4K7R2F-GP  [R402H16]  155.01 47.74 90 top
R2090  4K7R2F-GP  [R402H16]  155.01 46.6 90 top
R2091  10KR2J-3-GP  [R402H16]  164.79 54.72 180 bottom
R2281  -  [0R0402-PAD]  60.39 35.67 270 top
R5201  10KR2J-3-GP  [R402H16]  158.69 5.96 180 top
R5202  10KR2J-3-GP  [R402H16]  158.69 7.99 0 top
R5203  10KR2J-3-GP  [R402H16]  157.55 8.88 180 top
R5204  10KR2J-3-GP  [R402H16]  158.59 11.77 180 top
R5205  10KR2J-3-GP  [R402H16]  157.55 10.91 0 top
R5206  10KR2J-3-GP  [R402H16]  158.59 13.68 0 top
R5207  10KR2J-3-GP  [R402H16]  157.57 16.6 0 top
R5208  10KR2J-3-GP  [R402H16]  157.57 14.69 180 top
R5209  10KR2J-3-GP  [R402H16]  142.06 21.45 270 top
R5210  47R2J-2-GP  [R402H16]  150.56 25.13 270 top
R5211  47R2J-2-GP  [R402H16]  150.56 24.12 270 top
R5212  100R2J-2-GP  [R402H14]  140.15 19.04 0 top
R5213  4K7R2J-2-GP  [R402H16]  145.36 25.77 0 top
R5214  4K7R2J-2-GP  [R402H16]  145.36 23.74 180 top
R5215  1KR2J-1-GP  [R402H16]  140.15 15.99 0 top
R5216  10KR2J-3-GP  [R402H16]  139.64 14.46 90 top
R5217  -  [0R0402-PAD]  158.82 29.7 0 top
R5218  1KR2J-1-GP  [R402H16]  141.67 14.46 270 top
R5219  100R2J-2-GP  [R402H14]  141.29 15.99 180 top
R6701  0R3J-0-U-GP  [R603H22]  33.72 107.3 90 top
R6702  10KR2J-3-GP  [R402H16]  33.72 108.44 90 top
R6703  100KR2J-1-GP  [R402H16]  28.9 108.44 180 top
R6704  100KR2J-1-GP  [R402H16]  23.06 109.59 180 top
R6705  100KR2J-1-GP  [R402H16]  24.2 111.49 0 top
R6706  0R2J-2-GP  [R402H16]  24.2 109.59 180 top
R7513  100R2J-2-GP  [R402H14]  59.61 97.55 90 top
R7514  100R2J-2-GP  [R402H14]  58.29 97.57 90 bottom
R7539  100R2J-2-GP  [R402H14]  55.42 96.53 90 bottom
R7541  100R2J-2-GP  [R402H14]  57.32 96.51 270 bottom
R7916  100KR2J-1-GP  [R402H16]  109.16 44.94 180 top
R7917  100KR2J-1-GP  [R402H16]  113.99 45.26 0 top
R7918  10KR2J-3-GP  [R402H16]  108.72 43.29 270 top
R9501  56R2J-4-GP  [R402H16]  64.38 7.81 90 top
R9502  22R2J-2-GP  [R402H16]  65.02 5.65 90 top
R9503  4K7R2J-2-GP  [R402H16]  19.12 20.05 0 top
R9504  22R2J-2-GP  [R402H16]  54.17 11.8 90 top
R9505  10KR2J-3-GP  [R402H16]  20.26 20.05 0 top
R9506  22R2J-2-GP  [R402H16]  54.17 10.53 90 top
R9507  10KR2J-3-GP  [R402H16]  54.17 8.24 90 top
R9508  10KR2J-3-GP  [R402H16]  54.17 7.1 270 top
R9509  -  [0R0402-PAD]  54.17 9.38 90 top
R9519  6K2R2J-1-GP  [R402H16]  48.71 29.83 0 top
R9521  4K7R2J-2-GP  [R402H16]  25.47 26.4 270 top
R9525  4K7R2J-2-GP  [R402H16]  25.47 23.99 270 top
R9527  -  [0R0402-PAD]  38.42 22.34 180 top
R9528  4K7R2J-2-GP  [R402H16]  40.07 28.69 90 bottom
R9530  -  [0R0402-PAD]  39.44 22.34 180 top
R9531  6K2R2F-GP  [R402H16]  48.71 27.93 180 top
R9532  10KR2J-3-GP  [R402H16]  46.68 16.5 90 top
R9533  10KR2J-3-GP  [R402H16]  46.3 18.02 180 top
R9534  47R2J-2-GP  [R402H16]  47.8 18.63 270 top
R9535  47R2J-2-GP  [R402H16]  47.82 17.56 270 top
R9536  -  [0R0402-PAD]  40.58 22.34 180 top
R9540  4K7R2J-2-GP  [R402H16]  47.44 20.81 0 top
R9541  4K7R2J-2-GP  [R402H16]  53.28 21.2 180 top
R9542  10KR2J-3-GP  [R402H16]  55.7 11.67 270 bottom
R9543  10KR2J-3-GP  [R402H16]  57.47 16.5 270 bottom
R9544  10KR2J-3-GP  [R402H16]  38.73 17 180 top
R9545  10KR2J-3-GP  [R402H16]  33.98 48.12 0 bottom
R9546  -  [0R0402-PAD]  41.6 23.81 180 top
R9547  1MR2J-1-GP  [R402H16]  44.14 24.29 90 top
R9548  4K7R2J-2-GP  [R402H16]  39.57 27.16 0 bottom
R9553  0R0402-PAD-2-GP  [0R0402-PAD-1]  31.21 52.31 180 top
R9554  10KR2J-3-GP  [R402H16]  45.66 50.53 90 top
R9555  0R0402-PAD-2-GP  [0R0402-PAD-1]  32.23 52.31 180 top
R9556  -  [0R0402-PAD]  54.68 13.96 270 bottom
R9557  10KR2J-3-GP  [R402H16]  53.28 19.29 0 top
R9563  10KR2J-3-GP  [R402H16]  54.35 16.42 0 top
R9601  47KR2J-2-GP  [R402H16]  47.95 40.25 90 bottom
R9602  330KR2J-L1-GP  [R402H16]  47.95 41.39 90 bottom
R9603  100KR2J-1-GP  [R402H16]  47.19 42.53 270 bottom
R9604  47KR2J-2-GP  [R402H16]  40.84 39.48 270 bottom
R9605  1KR2J-1-GP  [R402H16]  41.22 41.01 0 bottom
R9606  10KR2F-2-GP  [R402H16]  51.12 46.72 180 bottom
R9609  47KR2J-2-GP  [R402H16]  33.72 39.86 0 bottom
R79171  1MR2J-1-GP  [R402H16]  41.6 17.64 90 top
R79172  1MR2J-1-GP  [R402H16]  43.63 16.62 90 top
R79174  4K7R2J-2-GP  [R402H16]  25.47 25.39 270 top
R79205  10KR2J-3-GP  [R402H16]  35.12 48.12 0 bottom
R79236  10KR2J-3-GP  [R402H16]  25.47 27.42 270 top
R79237  10KR2J-3-GP  [R402H16]  25.34 28.05 0 bottom
R79376  10KR2J-3-GP  [R402H16]  18.61 29.2 0 bottom
R79618  0R0402-PAD-2-GP  [0R0402-PAD-1]  99.88 27.29 0 top
R79619  0R0402-PAD-2-GP  [0R0402-PAD-1]  98.24 55.36 90 top
R79620  0R0402-PAD-2-GP  [0R0402-PAD-1]  100.4 56.5 90 bottom
R79621  0R0402-PAD-2-GP  [0R0402-PAD-1]  103.7 55.36 180 bottom
R79622  10KR2F-2-GP  [R402H16]  103.32 53.83 90 bottom
R79623  10KR2F-2-GP  [R402H16]  98.44 53.66 0 top
R79624  10KR2F-2-GP  [R402H16]  100.15 54.85 180 bottom
R79637  10KR2J-3-GP  [R402H16]  107.26 38.34 90 top
R79638  10KR2J-3-GP  [R402H16]  107.26 39.48 90 top
R79656  0R2J-2-GP  [R402H16]  32.2 110.48 180 top
R79657  0R2J-2-GP  [R402H16]  21.91 109.59 0 top
R79658  0R2J-2-GP  [R402H16]  33.72 109.59 90 top
R79668  100KR2J-1-GP  [R402H16]  31.18 110.48 0 top
R79687  10KR2J-3-GP  [R402H16]  114.24 71.74 90 top
R79690  -  [0R0402-PAD]  13.66 19.67 0 top
R79691  -  [0R0402-PAD]  16.58 19.67 0 top
R79693  -  [0R0402-PAD]  22.17 11.54 0 top
R79694  10KR2F-2-GP  [R402H16]  9.34 15.99 90 bottom
R79695  100R2F-L1-GP-U  [R402H14]  18.87 17.28 90 top
R79696  -  [0R0402-PAD]  23.31 11.54 0 top
R79697  0R1206-PAD-1-GP  [0R1206-PAD-1]  13.02 16.37 180 top
R79698  D33R6F-GP  [R1206H26]  10.03 7.33 180 bottom
R79699  -  [0R0402-PAD]  24.45 11.54 0 top
R79700  1KR2F-3-GP  [R402H16]  15.44 19.67 0 bottom
R79701  0R5J-5-GP  [R805H24]  8.58 11.42 0 bottom
R79702  300KR2F-GP  [R402H16]  11.25 16.88 270 bottom
R79703  D33R6F-GP  [R1206H26]  7.84 7.33 180 bottom
R79704  10KR2F-2-GP  [R402H16]  8.58 16.62 180 top
R79705  -  [0R0402-PAD]  25.6 11.54 0 top
R79706  10R2F-L-GP  [R402H14]  10.28 15.23 180 top
R79707  300KR2F-GP  [R402H16]  8.2 14.97 270 top
R79708  100KR2F-L1-GP  [R402H16]  16.33 16.5 0 top
R79709  10KR2F-2-GP  [R402H16]  17.6 14.59 270 top
R79710  200R5J-GP  [R805H24]  5.78 7.86 180 bottom
R79711  1KR2J-1-GP  [R402H16]  26.74 11.54 0 top
R79712  1KR2J-1-GP  [R402H16]  30.17 11.54 0 top
R79713  1KR2J-1-GP  [R402H16]  31.31 11.54 0 top
R79714  10KR2J-3-GP  [R402H16]  29.03 11.54 0 top
R79715  10KR2J-3-GP  [R402H16]  27.88 11.54 0 top
R79716  0R1206-PAD-1-GP  [0R1206-PAD-1]  7.1 12.05 90 top
R79717  100KR2J-1-GP  [R402H16]  5.63 17.41 270 top
R79719  100KR2J-1-GP  [R402H16]  8.32 20.05 270 top
R79720  10KR2J-3-GP  [R402H16]  5.63 18.43 90 top
R79721  4K7R2J-2-GP  [R402H16]  9.34 17 270 bottom
R79722  4K7R2J-2-GP  [R402H16]  8.58 18.53 0 top
R79723  -  [0R0402-PAD]  5.63 16.39 90 top
R79724  -  [0R0402-PAD]  10.1 18.91 270 top
R79727  470KR2F-GP  [R402H16]  17.21 51.17 270 bottom
R79728  100KR2J-1-GP  [R402H16]  15.94 34.28 0 bottom
R79729  10KR2J-3-GP  [R402H16]  22.17 34.15 180 bottom
R79730  10KR2J-3-GP  [R402H16]  26.1 45.33 90 bottom
R79731  100R2F-L1-GP-U  [R402H14]  25.06 51.65 270 top
R79732  10KR2J-3-GP  [R402H16]  31.11 54.44 180 top
R79734  22R2J-2-GP  [R402H16]  20.14 29.7 270 bottom
R79735  330R3J-L-GP  [R603H22]  16.96 58.53 270 bottom
R79737  10KR2J-3-GP  [R402H16]  20.01 30.85 90 bottom
R79738  100KR2J-1-GP  [R402H16]  14.8 33.39 180 bottom
R79739  43D2R2F-GP  [R402H16]  111.35 73.47 180 top
R79740  1KR2J-1-GP  [R402H16]  152.6 92.82 270 bottom
R79741  1KR2J-1-GP  [R402H16]  147.07 97.65 270 top
R79742  2K49R2F-GP  [R402H16]  54.17 29.07 0 top
R79743  8K2R2J-3-GP  [R402H16]  53.16 17.89 270 bottom
R79744  8K2R2J-3-GP  [R402H16]  53.66 14.34 0 top
R79745  39K2R2F-L-GP  [R402H16]  54.81 14.34 180 top
R79747  0R2J-2-GP  [R402H16]  53.41 19.42 180 bottom
R79748  10KR2J-3-GP  [R402H16]  56.58 24.62 0 top
R79750  10KR2J-3-GP  [R402H16]  52.65 21.45 180 bottom
R79753  10KR2J-3-GP  [R402H16]  27.63 253.86 180 top
R79754  -  [0R0402-PAD]  27.5 251.83 180 top
R79755  100KR2J-1-GP  [R402H16]  43.63 17.64 270 top
R79756  100KR2J-1-GP  [R402H16]  41.6 16.62 270 top
R79759  100R2F-L1-GP-U  [R402H14]  30.3 250.94 0 bottom
R79760  100R2F-L1-GP-U  [R402H14]  30.3 252.84 0 bottom
R79761  100R2F-L1-GP-U  [R402H14]  52.01 250.18 0 bottom
R79762  100R2F-L1-GP-U  [R402H14]  52.01 252.08 0 bottom
R79763  1KR2J-1-GP  [R402H16]  20.26 21.96 0 top
R79764  100KR2J-1-GP  [R402H16]  19.12 21.96 180 top
R79765  0R2J-2-GP  [R402H16]  24.96 254.37 90 bottom
R79766  8K2R2J-3-GP  [R402H16]  157.65 77.29 270 bottom
R79767  8K2R2J-3-GP  [R402H16]  144.28 90.74 90 bottom
R79768  51R2F-2-GP  [R402H16]  144.39 58.38 0 top
R79769  51R2F-2-GP  [R402H16]  32.96 121.78 270 top
R79770  10KR2J-3-GP  [R402H16]  142.31 82.79 90 bottom
R79771  10KR2J-3-GP  [R402H16]  50.62 10.4 270 top
R79772  1KR2J-1-GP  [R402H16]  141.78 61.28 0 top
R79773  100KR2F-L1-GP  [R402H16]  154.63 58.41 90 top
R79774  20R2J-3-GP  [R402H16]  138.83 61.31 0 top
R79775  30R2J-1-GP  [R402H16]  133.8 61.23 270 top
R79776  4K99R2F-L-GP  [R402H16]  57.47 125.21 270 bottom
R79777  -  [0R0402-PAD]  22.29 28.05 0 bottom
R79778  0R2J-2-GP  [R402H16]  24.2 30.21 0 bottom
R79779  1KR2J-1-GP  [R402H16]  147.77 58.41 0 top
R79780  1KR2J-1-GP  [R402H16]  162.12 73.19 90 top
R79782  51R2  [R402]  71.06 97.65 270 bottom
R79783  10KR2F-2-GP  [R402H16]  99.13 98.03 90 bottom
R79788  49D9R2F  [R402H16]  31.44 251.83 0 bottom
R79789  0R2J-2-GP  [R402H16]  50.49 49.64 0 top
R79790  -  [0R0402-PAD]  37.15 51.8 180 top
R79791  -  [0R0402-PAD]  35.88 51.68 180 top
R79792  -  [0R0402-PAD]  34.87 52.31 180 top
R79793  -  [0R0402-PAD]  145.78 94.77 0 top
R79794  -  [0R0402-PAD]  146.84 94.77 0 top
R79795  -  [0R0402-PAD]  147.91 94.74 0 top
R79796  0R2J-2-GP  [R402H16]  165.17 78.09 0 top
R79797  10KR2J-3-GP  [R402H16]  46.68 42.91 0 top
R79798  10KR2J-3-GP  [R402H16]  47.82 42.91 180 top
R79799  10KR2J-3-GP  [R402H16]  47.72 46.72 180 top
R79800  10KR2J-3-GP  [R402H16]  47.82 44.82 0 top
R79801  10KR2J-3-GP  [R402H16]  46.68 44.82 180 top
R79802  10KR2J-3-GP  [R402H16]  46.68 46.72 0 top
R79806  10KR2J-3-GP  [R402H16]  26.1 46.47 90 bottom
R79809  0R2J-2-GP  [R402H16]  47.19 46.85 270 bottom
R79810  -  [0R0805-PAD]  35.25 40.12 180 bottom
R79811  0R2J-2-GP  [R402H16]  25.49 53.71 90 top
R79812  -  [0R0603-PAD]  173.53 46.52 90 top
R79813  -  [0R0603-PAD]  183.2 47.23 270 top
R79814  -  [0R0402-PAD]  93.29 44.82 270 top
R79815  -  [0R0402-PAD]  104.72 45.2 0 top
R79816  -  [0R0402-PAD]  103.83 43.67 270 top
R79817  -  [0R0402-PAD]  49.35 47.59 270 top
R79818  -  [0R0402-PAD]  49.35 44.44 270 top
R79819  -  [0R0402-PAD]  49.35 43.29 270 top
R79820  10KR2J-3-GP  [R402H16]  123.54 56.37 90 top
R79821  0R0402-PAD-2-GP  [0R0402-PAD-1]  174.72 49.36 0 top
R79822  0R0402-PAD-2-GP  [0R0402-PAD-1]  179.14 70.98 0 top
R79823  0R0402-PAD-2-GP  [0R0402-PAD-1]  186.63 67.8 270 top
R79824  0R0402-PAD-2-GP  [0R0402-PAD-1]  181.81 40.93 270 top
R79825  0R0402-PAD-2-GP  [0R0402-PAD-1]  169.87 39.61 90 top
R79827  100KR2F-L1-GP  [R402H16]  186 50.79 270 top
R79829  510R2J-1-GP  [R402H16]  98.75 27.29 0 top
R79830  -  [0R0402-PAD]  184.09 50.79 90 top
R79831  10KR2J-3-GP  [R402H16]  66.11 27.67 90 top
R79832  0R2J-2-GP  [R402H16]  24.2 28.05 180 bottom
R79833  -  [0R0603-PAD]  152.34 89.52 0 bottom
R79834  -  [0R0603-PAD]  183.2 45.83 90 top
R79835  -  [0R0603-PAD]  173.53 45.2 270 top
R79836  1KR2J-1-GP  [R402H16]  124.02 50.91 90 top
R79837  0R2J-2-GP  [R402H16]  99.64 61.84 270 top
R79838  10KR2J-3-GP  [R402H16]  54.68 15.1 90 bottom
R79839  10KR2J-3-GP  [R402H16]  136.02 94.33 0 top
R79840  6K2R2F-GP  [R402H16]  185.36 145.02 90 bottom
R79842  -  [0R0603-PAD]  192.88 132.83 90 bottom
R79843  0R0402-PAD-2-GP  [0R0402-PAD-1]  187.27 147.05 90 bottom
R79844  0R2J-2-GP  [R402H16]  192.94 146.83 0 bottom
R79845  0R2J-2-GP  [R402H16]  194.03 146.83 0 bottom
R79846  0R2J-2-GP  [R402H16]  195.65 145.4 270 bottom
R79847  0R2J-2-GP  [R402H16]  196.54 143.37 270 bottom
R79848  0R2J-2-GP  [R402H16]  196.54 142.1 270 bottom
R79849  0R2J-2-GP  [R402H16]  196.54 140.96 270 bottom
R79850  10KR2J-3-GP  [R402H16]  191.46 136.08 270 bottom
R79851  0R2J-2-GP  [R402H16]  189.88 136.23 180 bottom
R79852  10KR2J-3-GP  [R402H16]  188.03 136.89 270 bottom
R79855  0R2J-2-GP  [R402H16]  103.19 45.83 90 top
R79858  10KR5F-2-GP  [R805H24]  46.42 13.83 270 top
R79859  -  [0R0402-PAD]  106.88 45.07 0 top
R79860  -  [0R0402-PAD]  108.02 45.07 0 top
R79861  20KR2J-L2-GP  [R402H16]  160.03 82.83 180 top
R79862  0R0402-PAD-2-GP  [0R0402-PAD-1]  143.93 97.38 180 top
R79867  10KR2J-3-GP  [R402H16]  30.55 27.67 270 bottom
R79868  10KR2J-3-GP  [R402H16]  36.14 27.04 0 bottom
R79871  0R2J-2-GP  [R402H16]  184.98 29.96 270 top
R79872  0R2J-2-GP  [R402H16]  115 45.26 180 top
R79873  -  [0R0402-PAD]  110.81 53.83 90 bottom
R79874  2K2R2J-2-GP  [R402H16]  48.33 128.38 270 top
R79875  1KR2J-1-GP  [R402H16]  158.53 82.66 90 top
R79876  0R0402-PAD-2-GP  [0R0402-PAD-1]  73.27 31.73 270 top
R79913  0R2J-2-GP  [R402H16]  10.84 158.81 270 top
R79914  4K7R2J-2-GP  [R402H16]  15.82 169.91 90 top
R79915  47KR2J-2-GP  [R402H16]  7.44 168.39 0 top
R79916  100KR2J-1-GP  [R402H16]  8.58 168.39 180 top
R79917  10KR2J-3-GP  [R402H16]  7.94 166.74 90 top
R79919  0R2J-2-GP  [R402H16]  178.89 28.31 0 top
R79920  0R2J-2-GP  [R402H16]  184.98 28.69 270 top
R79922  1KR2J-1-GP  [R402H16]  118.81 48.37 180 bottom
R79923  0R0402-PAD-2-GP  [0R0402-PAD-1]  30.55 50.66 90 bottom
R79924  0R0402-PAD-2-GP  [0R0402-PAD-1]  17.98 47.1 180 bottom
R79925  10KR2J-3-GP  [R402H16]  105.61 68.69 180 top
R79930  75R3F-GP  [R603H22]  86.61 12.36 270 top
R79931  10KR2J-3-GP  [R402H16]  130.5 97.78 270 top
R79932  10KR2J-3-GP  [R402H16]  135.96 99.43 90 top
R79933  10KR2J-3-GP  [R402H16]  135.96 98.16 270 top
R79934  20KR2J-L2-GP  [R402H16]  179.71 34.78 90 top
R79935  -  [0R0805-PAD]  13.4 163.94 270 top
R79936  10KR2F-2-GP  [R402H16]  184.45 62.11 270 top
R79938  10KR2J-3-GP  [R402H16]  139.39 98.67 270 top
R79939  10KR2J-3-GP  [R402H16]  144.19 96.28 90 bottom
R79940  1KR2J-1-GP  [R402H16]  144.18 94.14 90 bottom
R79941  1KR2J-1-GP  [R402H16]  144.18 95.16 90 bottom
R79942  10KR2J-3-GP  [R402H16]  142.78 98.86 90 top
R79943  0R2J-2-GP  [R402H16]  156.53 94.6 0 bottom
R79944  2K2R2J-2-GP  [R402H16]  151.96 69.46 0 bottom
R79945  0R0402-PAD-2-GP  [0R0402-PAD-1]  101.03 56.63 0 top
R79946  10KR2J-3-GP  [R402H16]  29.28 130.03 90 top
R79947  0R2J-2-GP  [R402H16]  29.28 131.18 90 top
R79948  100R2F-L1-GP-U  [R402H14]  21.79 164.58 270 top
R79949  10KR2J-3-GP  [R402H16]  49.07 49.36 0 top
R79950  10KR2J-3-GP  [R402H16]  30.04 51.29 180 top
R79951  10KR2J-3-GP  [R402H16]  144.16 100.24 0 bottom
R79975  10KR2J-3-GP  [R402H16]  114.24 72.88 90 top
R79976  10KR2F-2-GP  [R402H16]  112.34 55.1 180 bottom
R79977  10KR2F-2-GP  [R402H16]  112.77 53.5 90 bottom
R79978  2K49R2F-GP  [R402H16]  73.09 125.08 90 top
R79979  42D2R2F-GP  [R402H16]  73.09 101.08 180 bottom
R79980  0R0402-PAD-2-GP  [0R0402-PAD-1]  107.77 80.63 0 bottom
R79981  100KR2J-1-GP  [R402H16]  90.77 95.29 180 bottom
R79982  4K99R2F-L-GP  [R402H16]  103 88.97 0 top
R79983  100KR2J-1-GP  [R402H16]  91.26 103.36 0 bottom
R79984  100KR2J-1-GP  [R402H16]  93.67 85.58 180 bottom
R79985  10KR2J-3-GP  [R402H16]  89.1 124.17 180 bottom
R79986  10KR2F-2-GP  [R402H16]  99.51 90.41 180 top
R79987  100KR2J-1-GP  [R402H16]  92.14 107.05 270 bottom
R79988  10KR2J-3-GP  [R402H16]  89.73 121.4 270 bottom
R79989  10KR2F-2-GP  [R402H16]  99.13 93.97 90 top
R79990  2K2R2J-2-GP  [R402H16]  91.26 101.48 180 bottom
R79991  10KR2F-2-GP  [R402H16]  99.13 93.97 90 bottom
R79992  0R0402-PAD-2-GP  [0R0402-PAD-1]  94.23 105.56 0 bottom
R79993  4K99R2F-L-GP  [R402H16]  97.99 91.93 90 top
R79994  100KR2J-1-GP  [R402H16]  83.75 101.07 180 bottom
R79995  4K99R2F-L-GP  [R402H16]  91.33 86.78 90 top
R79997  4K99R2F-L-GP  [R402H16]  55.95 124.7 0 bottom
R79998  243R2F-2-GP  [R402H16]  49.22 113.65 270 top
R79999  4K99R2F-L-GP  [R402H16]  55.95 124.7 180 top
R80000  4K99R2F-L-GP  [R402H16]  57.47 125.21 90 top
R80001  80D6R2F-L-GP  [R402H16]  60.65 110.48 90 top
R80016  0R0402-PAD-2-GP  [0R0402-PAD-1]  98.42 107.71 90 bottom
R80018  10KR2J-3-GP  [R402H16]  117.57 48.4 180 bottom
R80020  243R2F-2-GP  [R402H16]  77.79 88.96 0 bottom
R80028  243R2F-2-GP  [R402H16]  62.59 86.87 90 bottom
R80034  243R2F-2-GP  [R402H16]  59 124.83 0 bottom
R80040  243R2F-2-GP  [R402H16]  60.14 110.86 180 bottom
R80045  0R2J-2-GP  [R402H16]  95.14 104.68 180 top
R80047  0R2J-2-GP  [R402H16]  86.81 98.03 90 bottom
R80048  0R2J-2-GP  [R402H16]  86.81 99.05 90 bottom
R80049  20KR2F-L-GP  [R402H16]  185.24 104 270 bottom
R80050  -  [0R0402-PAD]  180 102.55 180 top
R80051  -  [0R0402-PAD]  180 105.4 180 top
R80052  -  [0R0402-PAD]  178.86 102.55 180 top
R80053  -  [0R0402-PAD]  178.86 105.4 180 top
R80054  10KR2J-3-GP  [R402H16]  87.45 131.56 90 top
R80055  10KR2J-3-GP  [R402H16]  93.52 131.79 90 top
R80056  10KR2J-3-GP  [R402H16]  88.84 126.61 90 top
R80057  10KR2J-3-GP  [R402H16]  99.76 131.18 90 top
R80058  10KR2J-3-GP  [R402H16]  94.05 129.65 0 top
R80059  0R2J-2-GP  [R402H16]  100.68 110.55 90 top
R80060  100KR2F-L1-GP  [R402H16]  101.82 114.87 270 top
R80061  0R0402-PAD-2-GP  [0R0402-PAD-1]  147.14 23.74 180 top
R80062  0R0402-PAD-2-GP  [0R0402-PAD-1]  147.14 25.77 0 top
R80201  4K7R2J-2-GP  [R402H16]  40.4 5.47 180 top
R80202  4K7R2J-2-GP  [R402H16]  41.6 5.45 180 top
R80206  0R2J-2-GP  [R402H16]  101.16 45.45 90 top
R80215  15KR2F-GP  [R402H16]  99.38 46.34 180 top
R80216  10KR2F-2-GP  [R402H16]  93.29 46.21 90 top
R80217  1K5R2F-2-GP  [R402H16]  126.69 95.36 180 top
R80218  1K8R2-GP  [R402H16]  79.32 49.64 0 bottom
R80219  10KR2F-2-GP  [R402H16]  78.3 49.64 0 bottom
R80220  5K6R2F-2-GP  [R402H16]  79.32 47.61 270 bottom
R80221  10KR2F-2-GP  [R402H16]  80.33 52.06 90 bottom
R80222  0R0402-PAD-2-GP  [0R0402-PAD-1]  90.11 57.64 180 bottom
R80223  0R0402-PAD-2-GP  [0R0402-PAD-1]  92.27 99.66 0 bottom
R80224  0R0402-PAD-2-GP  [0R0402-PAD-1]  93.97 99.81 0 bottom
R80225  100KR2J-1-GP  [R402H16]  157.04 27.16 270 top
R80226  -  [0R0603-PAD]  187.39 74.79 90 top
R80227  -  [0R0603-PAD]  187.39 76.44 90 top
R80228  1KR2F-3-GP  [R402H16]  21.09 154.42 90 top
R80229  10KR2J-3-GP  [R402H16]  24.83 249.73 180 bottom
R80230  10KR2J-3-GP  [R402H16]  25.22 55.74 270 bottom
R80231  0R2J-2-GP  [R402H16]  117.73 46.34 90 top
R80232  0R0402-PAD-2-GP  [0R0402-PAD-1]  31.63 24.75 90 bottom
R80233  0R0402-PAD-2-GP  [0R0402-PAD-1]  30.61 52.06 270 bottom
R80234  0R5J-5-GP  [R805H24]  13.28 161.66 270 bottom
R80235  -  [0R0805-PAD]  13.4 161.78 90 top
R80236  10KR2J-3-GP  [R402H16]  108.4 50.28 180 bottom
R80238  10KR2F-2-GP  [R402H16]  94.58 50.15 270 bottom
R80239  17K8R2F-GP  [R402H16]  94.05 52.56 0 bottom
R80240  10KR2J-3-GP  [R402H16]  122.69 59.65 90 top
R80241  51R2F-2-GP  [R402H16]  36.71 115.68 270 bottom
R80242  51R2F-2-GP  [R402H16]  31.44 117.08 0 top
R80244  4K7R2J-2-GP  [R402H16]  124.15 49.9 270 bottom
R80245  0R2J-2-GP  [R402H16]  119.7 46.09 270 top
RJ1  RJ45-8P-199-GP  [23-01120-2A03-A]  96.91 20.26 180 top
RN1  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  115.41 60.16 0 bottom
RN2  SRN33J-7-GP-U  [ARES8-CN24-UH20]  115.26 55.36 180 bottom
RN3  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  108.02 58.38 90 bottom
RN5  SRN10KJ-5-GP  [ARES2H18]  103.07 68.06 180 top
RN6  SRN10KJ-5-GP  [ARES2H18]  108.15 68.06 180 top
RN7501  SRN100J-4-GP  [ARES8-CN24H20]  53.89 89.45 90 top
RN7502  SRN100J-3-GP  [SMD-ARES4H18]  61.28 94.07 90 top
RN7503  SRN100J-3-GP  [SMD-ARES4H18]  58.69 87.44 180 top
RN7504  SRN100J-3-GP  [SMD-ARES4H18]  60.95 87.51 180 top
RN7505  SRN100J-4-GP  [ARES8-CN24H20]  53.66 86.85 0 bottom
RN7506  SRN100J-4-GP  [ARES8-CN24H20]  53.26 94.83 270 bottom
RN7507  SRN100J-3-GP  [SMD-ARES4H18]  53.53 89.24 270 bottom
RN7508  SRN100J-3-GP  [SMD-ARES4H18]  51.86 91.25 270 bottom
RN7509  SRN100J-3-GP  [SMD-ARES4H18]  54.9 91.86 270 bottom
RN7510  SRN100J-3-GP  [SMD-ARES4H18]  55.49 94.4 180 bottom
RN7511  SRN100J-3-GP  [SMD-ARES4H18]  58.03 94.6 270 bottom
RN7512  SRN100J-3-GP  [SMD-ARES4H18]  62.25 96.07 270 bottom
RN7513  SRN100J-3-GP  [SMD-ARES4H18]  56.15 87.18 0 bottom
RN7514  SRN100J-3-GP  [SMD-ARES4H18]  58.15 87.18 0 bottom
RN7515  SRN100J-3-GP  [SMD-ARES4H18]  60.22 89.04 0 bottom
RN7516  SRN100J-3-GP  [SMD-ARES4H18]  62.27 89.04 0 bottom
RN7517  SRN100J-3-GP  [SMD-ARES4H18]  60.59 85.94 0 bottom
RN9503  SRN4K7J-10-GP  [ARES8-CN24H20]  33.34 45.07 270 bottom
RT1  NTC-10K-28-GP-U  [NTC-402H24-U]  129.08 146.14 270 top
RT2  NTC-10K-28-GP-U  [NTC-402H24-U]  88.33 98.41 0 bottom
RT3  NTC-10K-28-GP-U  [NTC-402H24-U]  46.04 154.55 0 top
RV5  P4500SCLHLRP-GP  [TVS5436-1121H105]  85.21 16.8 0 top
SATAP1  CLX-CON5-18-GP-U  [CI2505P1H00-LF-U]  21.28 119.5 270 top
SCA1  RTD2586HD-CG-GP  [TQFP128H63]  36.26 37.71 270 top
SPK1  JWT-CON6-20-GP  [A1501WV0-6PS-5E]  171.28 24 180 top
SPR1  SPRING-62-GP  [SPR10637H367]  184.28 188 90 top
SPR2  SPRING-62-GP  [SPR10637H367]  184.28 166 270 top
SRCON1  SKT-G6179-GP-U  [G6179-1000000-U]  170.82 81.62 180 top
SSUSB1  SKT-USB11-112-GP-U  [SKT-USB11-138165-1]  196.12 116.04 90 top
SSUSB2  SKT-USB11-112-GP-U  [SKT-USB11-138165-1]  196.12 94.54 90 top
TC2  E100U16VM-47-GP  [ECAP-100D6D3H237]  110.05 32.88 180 top
TC3  ST100U6D3VBM-7GP  [CT3528H79]  184.98 102.02 180 top
TC4  E100U16VM-47-GP  [ECAP-100D6D3H237]  180.03 95.49 180 top
TC5  E220U16VM-25-GP  [ECAP-100D6D3H473]  26.99 119.75 180 top
TC6  ST330U2D5VDM-9GP  [CT7343H75]  150.65 228.69 270 bottom
TOUCH2  ENT-CON5-GP  [3703K-Q05N-11L]  11.37 134.1 270 top
TP1  -  [TPAD28]  95.37 184.11 90 bottom
TP2  -  [TPAD28]  83.84 187.49 90 bottom
TP3  -  [TPAD28]  90.37 198.61 90 bottom
TP4  -  [TPAD28]  91.13 199.88 90 bottom
TP5  -  [TPAD28]  88.13 192.59 90 bottom
TP6  -  [TPAD28]  85.74 192.72 90 bottom
TP7  -  [TPAD28]  92.78 223.25 90 bottom
TP8  -  [TPAD28]  96.46 221.6 90 bottom
TP9  -  [TPAD28]  59.51 180.83 90 bottom
TP10  -  [TPAD28]  63.52 180.96 90 bottom
TP11  -  [TPAD28]  49.85 181.47 90 bottom
TP12  -  [TPAD28]  62.76 175.2 90 bottom
TP13  -  [TPAD28]  59.89 178.04 90 bottom
TP14  -  [TPAD28]  63.62 172.73 90 bottom
TP15  -  [TPAD28]  60.9 178.93 90 bottom
TP16  -  [TPAD28]  66.34 174.46 90 bottom
TP17  -  [TPAD28]  62.68 173.6 90 bottom
TP18  -  [TPAD28]  90.57 98.39 180 bottom
TP19  -  [TPAD28]  93.67 206.23 90 bottom
TP20  -  [TPAD28]  91.66 167.73 90 bottom
TP21  -  [TPAD28]  92.27 169.12 90 bottom
TP31  -  [TPAD28]  136.72 83.04 180 bottom
TP32  -  [TPAD28]  136.77 85.61 0 bottom
TP33  -  [TPAD28]  134.61 92.67 0 top
TP34  -  [TPAD28]  145.81 75.04 0 bottom
TP36  -  [TPAD28]  145.36 73.52 0 bottom
TP40  -  [TPAD28]  87.88 123.94 180 bottom
TP41  -  [TPAD28]  156.03 77.71 0 top
TP42  -  [TPAD28]  87.09 122.46 180 bottom
TP43  -  [TPAD24]  75.38 98.11 180 bottom
TP44  -  [TPAD28]  157.42 91.17 0 top
TP45  -  [TPAD28]  151.58 83.04 0 bottom
TP47  -  [TPAD28]  151.07 84.7 0 bottom
TP49  -  [TPAD28]  157.17 88.76 0 top
TP51  -  [TPAD28]  158.44 88.76 0 top
TP52  -  [TPAD28]  146.83 83.12 0 bottom
TP53  -  [TPAD28]  149.24 85.2 0 bottom
TP54  -  [TPAD28]  145.61 91.95 0 top
TP55  -  [TPAD28]  157.17 87.49 0 top
TP56  -  [TPAD28]  144.2 91.93 0 top
TP58  -  [TPAD28]  155.11 76.58 180 top
TP60  -  [TPAD28]  155.77 67.8 180 top
TP61  -  [TPAD28]  142.77 79.87 0 bottom
TP62  -  [TPAD28]  148.18 79.55 0 bottom
TP63  -  [TPAD28]  151.25 63.74 0 top
TP64  -  [TPAD28]  152.11 62.77 0 top
TP65  -  [TPAD28]  133.67 94.22 0 top
TP66  -  [TPAD28]  144.72 81.27 0 bottom
TP67  -  [TPAD28]  155.77 73.58 0 top
TP68  -  [TPAD28]  147.85 73.39 0 bottom
TP69  -  [TPAD28]  160.47 81.14 0 top
TP71  -  [TPAD28]  139.92 67.8 0 bottom
TP72  -  [TPAD24]  178.12 107.3 0 bottom
TP83  -  [TPAD28]  139.97 82.28 0 bottom
TP85  -  [TPAD28]  141.42 88.51 180 bottom
TP99  -  [TPAD28]  102.25 110.43 0 top
TP103  -  [TPAD28]  113.48 50.15 90 bottom
TP104  -  [TPAD28]  114.75 50.02 270 bottom
TP105  -  [TPAD28]  116.02 50.02 270 bottom
TP107  -  [TPAD28]  101.54 50.91 90 top
TP108  -  [TPAD28]  123.51 102.48 180 bottom
TP109  -  [TPAD28]  169.74 35.42 180 bottom
TP113  -  [TPAD28]  139.39 240.14 0 top
TP114  -  [TPAD28]  135.83 239.51 0 top
TP115  -  [TPAD28]  137.1 239.51 0 top
TP116  -  [TPAD28]  135.6 231.64 0 top
TP117  -  [TPAD28]  121.91 232.17 0 top
TP118  -  [TPAD28]  136.34 230.11 0 top
TP135  -  [TPAD28]  43.5 135.37 90 top
TP136  -  [TPAD28]  43.5 134.1 90 top
TP137  -  [TPAD28]  51.38 132.96 0 top
TP142  -  [TPAD28]  139.77 92.06 180 top
TP144  -  [TPAD28]  131.77 92.06 0 top
TP149  -  [TPAD28]  93.67 204.58 90 bottom
TP150  -  [TPAD28]  142.21 74.87 0 bottom
TP151  -  [TPAD28]  144.09 74.28 0 bottom
TP152  -  [TPAD28]  142.18 76.14 0 bottom
TP153  -  [TPAD28]  140.02 73.99 0 bottom
TP154  -  [TPAD28]  153.18 85.33 0 bottom
TP155  -  [TPAD28]  158.44 87.36 0 top
TP163  -  [TPAD28]  146.25 72.25 0 bottom
TP164  -  [TPAD28]  154.2 74.05 180 bottom
TP165  -  [TPAD28]  138.91 81.49 0 bottom
TP167  -  [TPAD28]  153.84 63.59 0 top
TP169  -  [TPAD28]  149.29 66.79 0 bottom
TP171  -  [TPAD28]  145.99 81.27 0 bottom
TP172  -  [TPAD28]  156.91 80.63 0 top
TP174  -  [TPAD28]  157.88 81.47 0 top
TP175  -  [TPAD28]  151.45 77.2 0 bottom
TP176  -  [TPAD28]  151.19 80.48 0 bottom
TP177  -  [TPAD28]  65.14 185.48 90 bottom
TP178  -  [TPAD28]  66.36 182.61 90 bottom
TP179  -  [TPAD28]  58.74 207.76 180 bottom
TP180  -  [TPAD28]  58.49 205.73 180 bottom
TP181  -  [TPAD28]  68.47 176.42 90 bottom
TP182  -  [TPAD28]  67.07 176.42 90 bottom
TP183  -  [TPAD28]  92.65 207.12 90 bottom
TP184  -  [TPAD28]  90.39 206.77 90 bottom
TP185  -  [TPAD28]  61.79 181.93 90 bottom
TP186  -  [TPAD28]  66.24 180.96 90 bottom
TP187  -  [TPAD28]  90.26 177.2 90 bottom
TP188  -  [TPAD28]  89.07 178.04 90 bottom
TP189  -  [TPAD28]  50.74 182.61 90 bottom
TP190  -  [TPAD28]  67.71 177.95 90 bottom
TP191  -  [TPAD28]  64.59 179.82 90 bottom
TP192  -  [TPAD28]  63.62 176.29 90 bottom
TP193  -  [TPAD28]  144.21 83.55 0 bottom
TP194  -  [TPAD28]  145 88.43 0 bottom
TP195  -  [TPAD28]  143.63 87.44 0 bottom
TP199  -  [TPAD28]  140.89 96.43 0 top
TP200  -  [TPAD28]  141.8 83.93 0 bottom
TP201  -  [TPAD28]  141.75 81.6 0 bottom
TP202  -  [TPAD28]  140.35 80.83 0 bottom
TP203  -  [TPAD28]  142.99 81.14 0 bottom
TP204  -  [TPAD28]  140.66 95.11 0 top
TP205  -  [TPAD28]  188.54 138.04 180 bottom
TP216  -  [TPAD28]  137.61 81.52 180 bottom
TP217  -  [TPAD28]  135.78 83.93 180 bottom
TP220  -  [TPAD28]  147.82 84.29 180 bottom
TP221  -  [TPAD28]  163.21 75.42 0 top
TP222  -  [TPAD28]  160.8 74.18 0 top
TP223  -  [TPAD28]  160.62 69.81 180 bottom
TP224  -  [TPAD28]  159.63 54.24 0 top
TP225  -  [TPAD28]  29.53 127.62 0 top
TP226  -  [TPAD28]  91.38 221.86 180 bottom
TP227  -  [TPAD28]  63.57 202.3 180 bottom
TP228  -  [TPAD28]  62.81 204.84 180 bottom
TP229  -  [TPAD28]  62.55 203.57 180 bottom
TP230  -  [TPAD28]  135.07 237.35 0 top
TP231  -  [TPAD28]  135.07 236.08 0 top
TP232  -  [TPAD28]  136.72 235.95 0 top
TP233  -  [TPAD28]  136.72 234.68 0 top
TP234  -  [TPAD28]  135.32 234.3 0 top
TP235  -  [TPAD28]  135.32 233.03 0 top
TP236  -  [TPAD28]  121.61 235.57 0 top
TP237  -  [TPAD28]  121.61 234.3 0 top
TP238  -  [TPAD28]  120.34 233.79 0 top
TP239  -  [TPAD28]  120.34 232.52 0 top
TP240  -  [TPAD28]  122.24 236.71 0 top
TP241  -  [TPAD28]  138.37 247.38 0 top
TP242  -  [TPAD28]  118.05 248.04 0 top
TP243  -  [TPAD28]  118.05 249.31 0 top
TP244  -  [TPAD28]  119.55 246.57 0 top
TP245  -  [TPAD28]  119.55 247.84 0 top
TP246  -  [TPAD28]  118.05 245.35 0 top
TP247  -  [TPAD28]  118.05 246.62 0 top
TP248  -  [TPAD28]  82.11 190.87 180 bottom
TP249  -  [TPAD28]  82.11 192.65 180 bottom
TP250  -  [TPAD28]  82.11 189.09 180 bottom
TP251  -  [TPAD28]  81.6 194.55 180 bottom
TP252  -  [TPAD28]  94.3 224.78 180 bottom
TP253  -  [TPAD28]  81.6 196.71 180 bottom
TP254  -  [TPAD28]  136.09 247.38 0 top
TP256  -  [TPAD28]  106.24 61.07 180 bottom
TP257  -  [TPAD28]  89.71 99.3 180 bottom
TP258  -  [TPAD28]  91.81 124.65 180 bottom
TP260  -  [TPAD28]  95.19 98.03 0 top
TP261  -  [TPAD28]  68.14 179.31 180 bottom
TP262  -  [TPAD28]  66.24 178.29 180 bottom
TP263  -  [TPAD28]  128.59 63.36 0 top
TP264  -  [TPAD28]  129.86 63.74 0 top
TP265  -  [TPAD28]  147 78.5 180 bottom
TP266  -  [TPAD28]  141.67 86.98 180 bottom
TR1  MCM1012B900FBP-GP-U  [L125100-4P-1H37]  182.44 110.22 180 top
TR2  MCM1012B900FBP-GP-U  [L125100-4P-1H37]  182.44 107.94 180 top
TR3  MCM1012B900FBP-GP-U  [L125100-4P-1H37]  126.18 36.82 90 top
TR4  MCM1012B900FBP-GP-U  [L125100-4P-1H37]  128.34 36.82 90 top
TR5  MCM1012B900FBP-GP-U  [L125100-4P-1H37]  139.64 36.82 90 top
TR6  MCM1012B900FBP-GP-U  [L125100-4P-1H37]  141.8 36.82 90 top
TR7  MCM1012B900FBP-GP-U  [L125100-4P-1H37]  180.16 203.31 270 top
TR12  MCM1012B900FBP-GP-U  [L125100-4P-1H37]  119.59 230.26 180 top
TR13  MCM1012B900FBP-GP-U  [L125100-4P-1H37]  18.61 130.42 270 top
TR16  FILTER-4P-120-GP  [L125100-4P-1H28]  164.41 38.34 90 top
TR17  FILTER-4P-120-GP  [L125100-4P-1H28]  162.25 38.34 90 top
TR18  FILTER-4P-120-GP  [L125100-4P-1H28]  159.84 38.34 90 top
TR19  FILTER-4P-120-GP  [L125100-4P-1H28]  157.68 39.61 90 top
TR5201  FILTER-4P-185-GP  [L125100-4P-1H28]  155.39 6.84 180 top
TR5202  FILTER-4P-185-GP  [L125100-4P-1H28]  155.39 12.81 180 top
TR5203  FILTER-4P-185-GP  [L125100-4P-1H28]  155.39 9.77 180 top
TR5204  FILTER-4P-185-GP  [L125100-4P-1H28]  155.39 15.73 180 top
U1  AO6402A-GP  [SOT-6-1H50]  20.26 53.2 180 bottom
U2  SUNRISE-1-GP  [BGA837M23-1H58]  141.06 77.85 270 top
U3  SNLVC1G08DCKRG4-GP  [SC70-5H44]  21.79 251.07 0 bottom
U6  MX25L1006EMI-10G-GP  [SOIC8H69]  97.48 66.41 90 bottom
U9  ALC3661-CG-GP  [QFN48J6-G465H40]  178.5 59.04 90 top
U10  TPA3131D2RHBR-GP-U  [QFN32-G3D55H40]  171.9 34.15 0 top
U11  AZ1215-04S-R7G-GP  [SOT-6H58]  64.2 20.81 180 top
U14  RTS5250S-GR-GP  [QFN32J4-G2D9-U1H36]  190.99 141.74 270 bottom
U15  AZ1045-04F-R7G-GP  [DFN10G2510H26]  187.39 115.56 270 top
U16  AZ1045-04F-R7G-GP  [DFN10G2510H26]  189.3 94.73 270 top
U17  AO4407AL-GP  [SOIC8H69]  82.37 32.63 180 bottom
U18  AO4407AL-GP  [SOIC8H69]  82.37 32.63 0 top
U21  TPS22966DPUR-GP  [SON14J3020-G2610H34]  80.71 66.41 270 bottom
U22  TPS22966DPUR-GP  [SON14J3020-G2610H34]  73.6 51.17 90 bottom
U26  AZ1045-04F-R7G-GP  [DFN10G2510H26]  154.34 36.61 90 top
U28  AZ1045-04F-R7G-GP  [DFN10G2510H26]  154.33 33.06 270 top
U29  AZ1045-04F-R7G-GP  [DFN10G2510H26]  154.37 40.12 270 top
U33  MX25L1006EMI-10G-GP  [SOIC8H69]  100.78 90.41 270 bottom
U55  BQ24727RGRR-1-GP  [QFN20G3D5-G2D15H40]  73.48 38.59 0 top
U109  IT8739E-GP  [LQFP128H63]  111.58 57.01 270 top
U118  PS8407ATQFN40GTR2-A1-GP  [QFN40J5-G3D65H32]  160.92 45.68 0 top
U119  AZ1117CR-ADJTRG1-GP  [SOT-89-4541H63]  143.71 48.5 270 top
U120  OZ554ALN-B-0-TR-GP  [QFN20-G2D1H32]  15.44 14.75 270 bottom
U171  2N7002KDW-1-GP  [SOT-363H44]  163.77 206.87 90 bottom
U173  2N7002KDW-1-GP  [SOT-363H44]  18.36 158.61 180 top
U175  2N7002KDW-1-GP  [SOT-363H44]  32.84 256.53 270 bottom
U176  2N7002KDW-1-GP  [SOT-363H44]  28.01 256.53 90 bottom
U5201  AT24C02C-SSHM-T-GP  [SOIC8H69]  140.53 24.88 270 top
U5202  AZ23C6V2-1-GP  [SOT-23-9H44]  140.84 11.72 180 top
U5203  AZ23C6V2-1-GP  [SOT-23-9H44]  153.61 24.5 270 top
U6701  KXCNL-1010-GP  [LGA16G3-1H40]  33.72 113.78 0 top
U9501  PM25LD020C-SCE-GP  [SOIC8H69]  59 8.37 270 top
U9502  AT24C16C-SSHM-T-GP  [SOIC8H69]  41.34 45.45 270 bottom
U9601  LD1117AG-12-AA3-A-R-GP  [SOT-223H71]  33.98 34.02 90 bottom
U9614  AZ1215-04S-R7G-GP  [SOT-6H58]  60.09 20.81 180 top
U9615  TS5A22364DGSR-1-GP  [MSOP10H44]  178.42 45.59 270 top
U9616  2N7002K-2-GP  [SOT23DGS2D4H44]  33.85 134.73 90 top
U9617  2N7002K-2-GP  [SOT23DGS2D4H44]  32.2 131.05 270 top
U9618  2N7002K-2-GP  [SOT23DGS2D4H44]  169.94 60.29 270 top
U9619  NCP81172MNTXG-GP-U  [LFQFN24G4-G2D9H40]  102.56 101.59 0 top
U9621  NL17SZ08DFT2G-GP  [SC70-5H44]  100.65 112.64 90 top
U9622  W25Q128FVSIQ-GP  [SOIC8-1H86]  170.82 81.62 0 top
U9623  RTL8111G-CGT-1-GP-U1  [QFN32J4-G2D9-U1H36]  61.66 27.55 180 top
U9624  AZ1215-04S-R7G-GP  [SOT-6H58]  94.18 28.05 90 top
U9625  TPS2546RTER-GP  [QFN16-G1D8-UH32]  180.03 104 0 bottom
UHS1  AUDIO-JK500-GP  [2SJ3082-038111F]  196.5 74.49 90 top
UR6  330R2F-GP  [R402H16]  89.6 24.37 0 top
UR7  330R2F-GP  [R402H16]  90.75 24.37 0 top
USB1  SKT-USB6-127-GP  [SKT-USB6-146072]  118.29 36.23 270 top
USB2  SKT-USB6-127-GP  [SKT-USB6-146072]  118.29 13.23 270 top
USB3  SKT-USB6-127-GP  [SKT-USB6-146072]  131.79 36.23 270 top
USB4  SKT-USB6-127-GP  [SKT-USB6-146072]  131.79 13.23 270 top
VRAM1  H5TQ1G63DFR-11C-GP  [BGA96D075130H48]  84.32 88.68 0 top
VRAM2  H5TQ1G63DFR-11C-GP  [BGA96D075130H48]  70.29 88.68 0 top
VRAM3  H5TQ1G63DFR-11C-GP  [BGA96D075130H48]  84.32 88.68 180 bottom
VRAM4  H5TQ1G63DFR-11C-GP  [BGA96D075130H48]  70.29 88.68 180 bottom
VRAM5  H5TQ1G63DFR-11C-GP  [BGA96D075130H48]  58.84 103.85 270 top
VRAM6  H5TQ1G63DFR-11C-GP  [BGA96D075130H48]  58.84 117.88 270 top
VRAM7  H5TQ1G63DFR-11C-GP  [BGA96D075130H48]  58.84 103.85 90 bottom
VRAM8  H5TQ1G63DFR-11C-GP  [BGA96D075130H48]  58.84 117.88 90 bottom
WEBCM1  JWT-CON8-4-GP  [A1251WR0-8PS-5E]  173.27 213 180 top
X1  XTAL-24MHZ-86-GP  [OSC-3225-4P-3H36]  120.59 71.23 90 top
X2  XTAL-32D768KHZ-67-GP  [SMD49-6914-0403H56]  167.53 67.02 270 top
X3  XTAL-25MHZ-181-GP  [OSC-3225-4P-4H36]  51.89 36.69 90 top
X5  XTAL-27MHZ-85-GP-U  [OSC-3225-4P-4H30]  93.54 94.09 90 top
X9502  XTAL-14D31818MHZ-37-GP  [OSC-3225-4P-3H36]  43.88 21.07 0 top
XDPC1  DM-SMC-CONN60A-GP-01  [DM-BSH-03001-FDA-01]  36.9 128.26 270 bottom
XF3  XFORM-24P-27-GP  [XFORM24Z151100H160]  74.67 9.69 180 top

## Library data of the parts
BT1 = AAA-BAT-034-K01: tolerance: 62.70010.031
BTRST1 DB1 DB2 = 210-41-02GB01: tolerance: 21.62874.102
C1 C2 C92-C96 C100 C104-C108 C110 C113-C120 C124 C128 C129 C131-C134 C138 C139 C143 C153 C156 C179 C181 C183-C185 C191 C193 C194 C199 C207 C211 C213 C219 C222 C228 C230 C270 C278 C281 C287-C292 C294 C295 C312 C314 C329 C332 C339-C341 C343 C353 C356 C364 C366 C375 C379 C380 C415 C418 C419 C440 C444 C455 C463 C465 C469 C475 C484 C502 C503 C506 C512 C514 C524 C526 C528 C836 C1935 C3366 C3453 C3454 C6702 C6705 C6708 C6712 C6714 C7505 C7507 C7508 C7512 C7516 C7522 C9504 C9518 C11359 C12055 C12057 C12061 C12063 C12064 C12128 C12148 C12154 C12155 C12158 C12160 C12162 C12166-C12168 C12170 C12172 C12175 C12176 C12183 C12184 C12186-C12188 C12191 C12194-C12197 C12199 C12200 C12202 C12204 C12206 C12220-C12223 C12226 C12230 C12238 C12239 C12241-C12243 C12327 C12337-C12341 C12378-C12380 C12386 C12388 C12389 C12394 C12395 C12397 C12409 C12413-C12415 C12418 C12422 C12425 C12433 C12446 PC6 PC11 PC56 PC66 PC107 PC154 PC4415 PC4416 PC4420-PC4422 PC4426 PC4427 PC8307 PC8314 PC12172 PC12174-PC12187 R423 R424 = C402H22: tolerance: 78.10421.2FLDL
C3 C111 C135 = C402H22: tolerance: 78.22321.2FLDL
C4-C9 C38-C40 C45 C84 C85 C467 C6710 = C603H40: tolerance: 78.22610.5BLDL
C10-C37 C41-C44 C47-C51 C55-C59 C61-C63 C70-C82 C86-C91 C187 C195 C417 C420 C426 C429 C449 C452 C471 C837 C11888 C12444 C12445 PC8306 PC8607 PC8611 PC8616 PC8618 = C805H54: tolerance: 78.22610.51LDL
C52-C54 C60 C64 C67-C69 C460 = C805H54: tolerance: 78.47610.51LDL
C83 C145 C146 C148 C149 C151 C152 C169 C171-C173 C186 C188 C190 C202 C209 C210 C269 C280 C282 C362 C371 C376 C384 C434 C441 C442 C445 C448 C459 C486 C504 C505 C518 C519 C6711 C6713 C11358 C11833-C11839 C12120 C12122 C12123 C12149 C12150 C12152 C12156 C12159 C12161 C12165 C12192 C12193 C12237 C12331 C12332 C12381 C12385 C12387 C12390-C12393 C12400 C12401 C12403 C12405-C12408 C12416 C12417 C12419 C12423 C12424 C12426 C12427 C12429 C12431 PC1 PC3 PC34 PC39 PC43 PC47 PC51 PC63 PC73 PC78 PC86 PC92 PC104 PC4428 PC5237 PC5303 PC5311 PC5312 PC8501 PC12173 = C402H22: tolerance: 78.10523.5FLDL
C97-C99 C101-C103 C109 C121-C123 C125-C127 C130 C263 C265 C286 C296 C297 C299 C311 C330 C433 C437 C438 C443 C446 C453 C454 C458 C461 C464 C466 C468 C472 C473 C476 C479 C481 C482 C487 C488 C492 C6706 C6707 C9516 C12157 C12163 C12169 C12189 C12377 PC77 PC8302 = C603H36: tolerance: 78.47520.5BLDL
C112 C136 PC4401 PC4402 = C402H22: tolerance: 78.10423.2FLDL
C140-C142 C144 C201 C217 C225 C243 C267 C268 C271 C272 C12235 C12384 PC8 PC4418 PC8309 = C402H22: tolerance: 78.10134.1FLDL
C147 C218 C12231-C12233 PC8617 = C402H22: tolerance: 78.10422.5FLDL
C157 C158 C12218 C12219 = C402H22: tolerance: 78.33034.1FLDL
C159 C160 = C402H22: tolerance: 78.3R074.1FL
C161 C162 C165-C168 C324 C325 C347-C350 C12118 C12119 C12179-C12182 = C402H22: tolerance: 78.10421.2FLDL; signal model: 2pins
C163 C6704 = C402H22: tolerance: 78.10322.2FLLL
C180 = C402H22: tolerance: 78.10413.5FLDL
C182 = C402H22: tolerance: (78.10421.2FLDL)
C189 C197 C12216 C12217 = C402H22: tolerance: 78.10491.4FLDL
C204 C233 C248 C477 C12224 C12225 PC24 PC5253 PC5254 PC5301 PC5302 PC5304-PC5306 PC5308 PC8609 PC8612 = C805H58: tolerance: 78.10622.51LDL
C206 C208 C212 C214 C215 C226 C331 C333 C342 C344 C345 C351 C352 C363 C365 C374 C377 C378 C489 C520 C3367 C12056 C12127 C12131 C12174 C12245 C12246 C12326 C12329 C12330 PC94 PC99 PC100 PC155 PC156 PC158 = C805H50: tolerance: 78.10623.51LDL
C216 PC5245 = C402H22: tolerance: 78.22124.2FLDL
C220 C221 C223 C227 C229 C412 C413 C421 C491 C516 C517 C12153 C12185 C12240 C12244 C12376 C12434-C12441 = C603H36: tolerance: 78.10610.5BLDL
C224 PC2 PC79 PC83 PC8303 = C402H22: tolerance: 78.22034.1FLDL
C231 C264 C266 C334 C338 C369 C370 C382 C383 C436 C447 C12164 C12228 PC9 PC36 PC40 PC44 PC48 PC52 PC64 PC65 PC87 PC105 PC106 PC4406 PC4412 PC4417 PC4423 PC4431 PC8311 = C402H22: tolerance: 78.10224.2FLDL
C232 C246 C247 C298 C12336 PC41 = C603H36: tolerance: 78.10422.2BLDL
C234 C236 C240 C241 = C603H36: tolerance: 78.27324.2BLDL
C235 C239 C242 C244 = C603H36: tolerance: 78.22421.2BLDL
C245 = C603H36: tolerance: 78.10521.5BLDL
C249 C250 C358 C428 C435 C456 C490 C6723-C6725 C12190 PC152 PC8308 PC8615 = C603H36: tolerance: 78.10522.5BLDL
C251 C252 C257 C258 = C603H36: tolerance: 78.68421.5BL
C253 C254 C259 C260 = C603H36: tolerance: 78.10234.1BLDL
C255 C256 C261 C262 = C603: tolerance: 78.10334.2BL
C279 C513 C515 C12121 PC4430 = C603H36: tolerance: 78.22523.5BLDL
C283 C284 = C402H22: tolerance: 78.12034.1FLDL
C355 C357 C373 C12058-C12060 C12171 C12314 C12324 C12325 PC5 PC19 PC33 PC37 PC45 PC49 PC62 PC70 PC74 PC75 PC88 PC93 PC103 PC5233-PC5236 PC5307 PC8608 PC8613 = C603H35: tolerance: 78.10424.2BLDL
C367 C368 C381 = C402H22: tolerance: 78.10520.5FLDL
C372 C414 C12114 C12334 = C402H22: tolerance: 78.10322.2FLDL
C427 C430 PC4 PC12 PC35 PC38 PC42 PC46 PC50 PC61 PC69 PC71 PC101 PC102 PC117 PC163 = C805H54: tolerance: 78.47522.51LDL
C494-C501 = C402H22: tolerance: 78.10322.2FLDL; signal model: 2pins
C511 C12383 = C402H22: tolerance: 78.15034.1FLDL
C522 C523 = C402H22: tolerance: 78.10034.1FLDL
C3457 C12201 C12203 C12205 C12207 C12227 C12382 PC68 PC72 PC4429 PC5232 = C402H22: tolerance: 78.10324.2FLDL
C6709 = C402H22: tolerance: 78.10421.2FLLL
C7503 C7504 C7506 C7511 C7521 PC4701 = C402H22: tolerance: 78.10423.5FLDL
C9520 C9522 PC67 PC84 PC85 PC96 PC108 = C402H22: tolerance: 78.18034.1FLDL
C11892 = C402H22: tolerance: 78.47034.1FL
C11895 C11898 C11900 C11902 C11904 C11905 C11907 C11908 C12138-C12145 C12264-C12279 = C402H22: tolerance: 078.22423.05FD; signal model: 2pins
C12052 C12443 = C402H22: tolerance: 78.10321.2FLDL
C12065 PC4404 PC4410 = C402H22: tolerance: 78.22224.2FLDL
C12098 C12100 C12103 C12107 C12108 = C1206H71: tolerance: 78.10525.22LLL
C12101 = C603H36: tolerance: 78.10492.4BLLL
C12113 C12236 = C603H36: tolerance: 78.47523.5BLDL
C12125 PC4405 PC4411 PC8312 = C402H22: tolerance: 78.47034.1FLDL
C12126 = C603H35: tolerance: 78.47034.1BLDL
C12151 = C402H22: tolerance: 78.22510.5FLDL
C12208-C12215 = C402H22: tolerance: 78.10423.5FLDL; signal model: 2pins
C12229 PC8614 = C402H22: tolerance: 78.27034.1FLDL
C12234 = C603H36: tolerance: 78.47422.5BLDL
C12328 = C402H22: tolerance: 78.10394.4FL
C12333 = C1808H56: tolerance: 78.1013N.1AL
C12442 PC4403 PC4408 PC4409 PC4414 = C402H22: tolerance: 78.47124.2FLDL
CN3 = 88459-047N: tolerance: 20.F1897.004
CONVT1 = CI1410M1VL0-NH: tolerance: 020.F0035.0010
CPU1 = SKTBGA1151Z753620H369: tolerance: 062.10015.0081
D2 = SOT-23-9H44: tolerance: 75.00040.07D
D3 = SOD323AKH38: tolerance: 83.R5003.H8H
D4 D23 = SOD323AKH38: tolerance: 83.00355.D1F
D5 = SOD523AKH28: tolerance: 83.02015.0AF
D9-D11 = SOT-6H44: tolerance: 75.04223.07C
D12 = DO214AAAK-1121H97: tolerance: 83.P6SMB.KAG
D13 = SOT23-2D4-312H48: tolerance: 75.00099.F7D
D32 = D4724AKH44: tolerance: 83.3R010.C8M
D5201 = SOT-23-9H44: tolerance: 75.00054.A7D
D5202 = SOT-23-9H44: tolerance: 83.6R803.E31
D5203 D5204 = SLP2510P8-1H22: tolerance: 83.03010.0A0
D5205 D5206 D5209 PD8301 = SOD323AKH40: tolerance: 83.00355.F1F
D5210-D5214 = SOD882-10D6-1H20: tolerance: 83.05725.0A0
DCIN1 = 2DC3115-000111F: tolerance: 022.10015.0311
DIMM1 = DAN06-K4406-0103-U: tolerance: 62.10017.I31
DIMM2 = DAN06-K4806-0103: tolerance: 062.10011.0071
F6 F7 F12 F20 = POLYSW-2114H30: tolerance: 069.50001.0031
F14 F17-F19 F21 = POLYSW-2114H30: tolerance: 069.50003.0001
F16 = FUSE-1608H22: tolerance: 69.43001.441
FANC3 = HF1804H: tolerance: 021.D0086.0104
G1 PG1-PG12 = CON2C-U: tolerance: ZZ.CON2C.XXX
GPU1 = BGA595M23H83: tolerance: 071.0N16S.0A0U
H13 H14 H24 = GEN8D5X8R5X4D5-8-F-A: tolerance: ZZ.00PAD.BV1
H15-H20 = HOLE315R158: tolerance: ZZ.00PAD.BT1
H22 = GEN315R178-8-F-A-1: tolerance: ZZ.00PAD.BR1
H23 = GEN315R138-8-F-A-2-S: tolerance: ZZ.00PAD.HK1
H25 = GEN315R138-8-F-A-1: tolerance: ZZ.00PAD.BU1
HDD1 ODD2 = 15-02070-5A61-A: tolerance: 020.80244.0007
HDMI1 HDMI2 = SKT-HDMI22-150077: tolerance: 062.10012.0121
HS6 = STF256R109H99: tolerance: 34.3NH01.001
L1 L28 L9502-L9505 L9523 = L603H38: tolerance: 68.00335.081
L3 L5 L12 L13 = L402H24: tolerance: 68.00213.031
L4 = L603H38: tolerance: 68.00230.231
L6 = L603H38: tolerance: 68.00335.141
L7 L8 L10 L11 = L20125H42: tolerance: 68.00216.111
L17-L20 = L125100-4P-1H36: tolerance: 68.12105.201; signal model: 4pins1
L21 = L402H22: tolerance: 68.00084.541
L25 PR3 PR5 PR6 PR75 PR76 PR78 PR96 PR97 PR99 PR100 PR133 PR134 PR137 PR138 PR140-PR142 PR144 PR148 PR149 PR155 PR156 PR167 PR170-PR180 PR182 PR188 PR189 PR191 PR194-PR206 PR213 PR215-PR220 PR228 PR230 PR5301 PR5304 PR5471-PR5482 PR5519-PR5521 R692 R693 R79810 R79935 R80235 = 0R0805-PAD: tolerance: ZZ.R0805.ZZZ
L27 L29 = L603H38: tolerance: 68.00335.051
L61 = L8080-6020H158: tolerance: 068.33010.1061
L62 = L20125H42: tolerance: 68.00216.121
L4102 L4103 = L125100-4P-1H36: tolerance: 68.12105.201
L9524 = L603H38: tolerance: 68.00909.121
LED2 = LED1608AKH30: tolerance: 83.01608.Q70
LOUT1 = JAC331-0140A8B-9H: tolerance: 22.10277.2M1
LPC1 = HL5507F: tolerance: 21.60964.207
LVDS1 = 50524-0300N-001: tolerance: 020.K0005.0030
MEJ1 PSWD1 = A2541WV0-1EX2PA-6T: tolerance: 21.60909.102
MEMCD1 = 156-2131302600: tolerance: 062.10002.0211
NGFF1 = 2199230-7: tolerance: 62.10043.K51
PC7 PC10 = C402H22: tolerance: 78.22322.2FLDL
PC80 PC82 PC97 PC5246 PC5309 PC8610 = C603H36: tolerance: 78.15224.2BLDL
PC81 PC95 = C603H36: tolerance: 78.10521.2BLDL
PC89-PC91 = C1206H71: tolerance: 78.10622.22LDL
PC98 = C603H36: tolerance: 78.47322.2BLDL
PC157 = C402H22: tolerance: 78.10134.1FL
PC159 = C805H56: tolerance: 78.10623.21L
PC4407 PC4413 = C402H22: tolerance: 78.12224.2FLDL
PC4419 PC4425 = C402H22: tolerance: 78.15224.2FLDL
PC4424 = C603H36: tolerance: 78.82034.1BLDL
PC4432 = C805H58: tolerance: 078.10522.021D
PC5310 = C402H22: tolerance: 78.68034.1FLDL
PC8301 = C603H36: tolerance: 78.56224.2BLDL
PC8315 = C402H22: tolerance: 78.10322.L0L
PC8317 = C402H22: tolerance: 78.27224.2FLDL
PD4401 = D1608-035030AKH28: tolerance: 83.1R003.N8F
PD5301 = D5226145AKH91: tolerance: 83.5R004.C8M
PG13-PG17 PG4905 PG4907 = GAP-CLOSE-PWR-3: tolerance: ZZ.CLOSE.001
PL1-PL6 PL12 = L115100-2H158: tolerance: 68.R3610.10M
PL7 = L686647H119: tolerance: 68.1R51A.10F
PL8 = L686647H119: tolerance: 68.3R31A.10V
PL9 = L115100-2030H158: tolerance: 68.1R51A.10E
PL10 PL11 = L112100-2030H158: tolerance: 68.R681A.10Q
PL5301 = L686647H119: tolerance: 68.5R610.10U
PL8602 = L686647H119: tolerance: 68.1R01B.10K
PQ4408 Q57 Q9630 U9616-U9618 = SOT23DGS2D4H44: tolerance: 84.2N702.J31
PQ5006 Q10 Q1228 Q6701 Q9501-Q9503 Q9614 Q9620 Q9646 = SOT-363H44: tolerance: 84.2N702.A3F
PQ5007 = SOT-363H44: tolerance: 84.00512.03F
PQ5301 PQ5302 Q7 Q12 Q24 Q30 Q31 Q53 Q58 Q64 Q65 Q103 Q1249 Q1261 Q1262 Q9626 Q9650 = SOT23DGS2D4H48: tolerance: 84.2N702.E31
PR1 PR4402 PR4403 PR8335 R10 R46-R62 R99 R100 R124 R127 R133 R143 R153 R154 R189 R190 R226 R251 R284-R286 R303 R335 R337 R338 R340 R343 R345 R357 R393 R410 R411 R416 R436 R440 R462 R466 R471 R605 R740 R1771 R1799 R1800 R1828 R1830 R1836-R1838 R1952 R1955 R1993 R5215 R5218 R9605 R79711-R79713 R79740 R79741 R79763 R79772 R79779 R79780 R79836 R79875 R79922 R79940 R79941 = R402H16: tolerance: 63.10234.1DL
PR2 PR8 PR20 PR43 PR74 PR77 PR79 PR83-PR85 PR89-PR91 PR95 PR98 PR103 PR105-PR107 PR114 PR145 PR153 PR154 PR157 PR160 PR190 PR211 PR4404 PR4476 PR5307 PR5308 PR8302 PR8313 PR8330 PR8615 = R805H24: tolerance: 63.2R231.16L
PR4 PR7 PR80 PR86 PR92 PR101 PR108 PR123 PR135 PR207 PR232 PR235 PR246 PR4475 PR5522 PR5523 PR5525 PR8331 PR8623 R20 R24 R42 R73-R75 R85 R86 R96 R103 R116 R122 R123 R134 R151 R156-R158 R160-R162 R165 R168-R170 R172-R177 R192 R196 R197 R199 R203 R249 R257 R262-R265 R267-R270 R277 R279 R283 R296 R314 R316 R317 R324 R373 R392 R394 R412 R413 R426 R455 R463 R467 R470 R475 R499 R508 R517 R523 R524 R530 R531 R533 R591 R596 R597 R599 R725 R731 R734 R738 R741 R747 R764 R876 R1194 R1659-R1663 R1684 R1685 R1687 R1688 R1733 R1801 R1812 R1815-R1817 R1820 R1826 R1922 R1923 R1954 R1956 R1961 R1964 R1970 R1992 R2091 R5201-R5209 R5216 R6702 R7918 R9505 R9507 R9508 R9532 R9533 R9542-R9545 R9554 R9557 R9563 R79205 R79236 R79237 R79376 R79637 R79638 R79687 R79714 R79715 R79720 R79729 R79730 R79732 R79737 R79748 R79750 R79753 R79770 R79771 R79797-R79802 R79806 R79820 R79831 R79838 R79839 R79850 R79852 R79867 R79868 R79917 R79925 R79931-R79933 R79938 R79939 R79942 R79946 R79949-R79951 R79975 R79985 R79988 R80018 R80054-R80058 R80229 R80230 R80236 R80240 = R402H16: tolerance: 63.10334.1DL
PR9 PR5286 R234 = R402H16: tolerance: 64.49925.6DL
PR10 PR4418 = R402H16: tolerance: 64.24925.6DL
PR11 PR8620 = R402H16: tolerance: 64.69815.6DL
PR12 PR4412 R711 R712 R714 R717 R719 R720 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: 2pins
PR13 = R402H16: tolerance: 64.93125.6DL
PR14 = R402H16: tolerance: 64.95315.6DL
PR15 = R402H16: tolerance: 64.30015.6DL; signal model: 2pins
PR16-PR18 PR4447 PR4801 PR8329 PR8333 R18 R181 R300 R360 R1821 R79695 R79731 R79759-R79762 R79948 = R402H14: tolerance: 64.10005.6DL
PR19 R586 R723 R79701 R80234 = R805H24: tolerance: 63.R0031.16L
PR60 PR4464-PR4466 PR8624 = NTC-402H22-U: tolerance: 69.60011.221
PR81 PR87 PR93 PR102 PR109 R1789 = R402H16: tolerance: 63.51034.1DL
PR82 PR88 PR94 PR104 PR110 = R1206H28: tolerance: 63.2R232.11L
PR136 = R402H16: tolerance: 64.75025.6DL
PR139 PR186 PR209 = R603H22: tolerance: 64.2R205.55L
PR143 PR210 R507 R79727 = R402H16: tolerance: 64.47035.6DL
PR146 = R402H16: tolerance: 64.11825.6DL
PR147 PR208 PR8308 R457 = R402H16: tolerance: 64.33025.6DL
PR152 PR162 PR5279 PR5291 R288 R319 R388 R396 R484 R501 R509 R512 R584 R615 R616 R619 R622 R630 R631 R728 R1735 R1963 R1988 R1990 R1991 R6703-R6705 R7916 R7917 R9603 R79668 R79717 R79719 R79728 R79738 R79755 R79756 R79764 R79916 R79981 R79983 R79984 R79987 R79994 R80225 = R402H16: tolerance: 63.10434.1DL
PR158 = R402H16: tolerance: 64.66515.6DL
PR159 PR4473 R439 R464 R469 R472 R503 R80215 = R402H16: tolerance: 64.15025.6DL
PR161 PR164 PR185 PR212 PR229 PR4458 PR4461 PR5302 PR5303 PR5305 PR5309 PR5518 PR8311 PR8621 R219 R231 R237 R238 R240 R243 R252 R259 R260 R272 R280 R290 R308-R313 R320 R321 R365 R398 R607 R621 R629 R633 R745 R1734 R1953 R9606 R79622-R79624 R79694 R79704 R79709 R79783 R79936 R79976 R79977 R79986 R79989 R79991 R80216 R80219 R80221 R80238 = R402H16: tolerance: 64.10025.6DL
PR163 = R402H16: tolerance: 64.56025.6DL
PR165 = R402H16: tolerance: 64.68025.6DL
PR166 PR4426 PR4428 PR4430 PR4439 PR4444-PR4446 PR8304 PR8327 PR8617 R407 R79708 R79773 R79827 R80060 = R402H16: tolerance: 64.10035.6DL
PR168 = R402H16: tolerance: 64.56225.6DL
PR169 = R402H16: tolerance: 64.62025.6DL
PR181 = R402H16: tolerance: 64.5R105.6DL
PR183 = R402H16: tolerance: 64.45315.6DL
PR184 R305 R368 R382-R384 R387 R886 R889-R892 R1730 R1732 R1748 R1749 R1822 R79812 R79813 R79833-R79835 R79842 R80226 R80227 = 0R0603-PAD: tolerance: ZZ.R0603.ZZZ
PR187 = R402H16: tolerance: 64.62035.6DL
PR192 R610 = R402H16: tolerance: 64.40225.6DL
PR193 = R402H16: tolerance: 64.48725.6DL
PR214 = R402H16: tolerance: 64.22625.6DL
PR227 PR5274 PR5290 PR8315 PR8319 PR8325 PR8609-PR8614 PR8619 PR8622 R1 R2 R22 R27 R30 R37 R38 R64 R77 R83 R88 R94 R115 R142 R155 R163 R164 R166 R191 R200 R256 R291 R341 R374 R522 R743 R762 R1683 R1736 R1948 R1949 R1951 R1973 R1977 R1984 R2281 R5217 R9509 R9527 R9530 R9536 R9546 R9556 R79690 R79691 R79693 R79696 R79699 R79705 R79723 R79724 R79754 R79777 R79790-R79795 R79814-R79819 R79830 R79859 R79860 R79873 = 0R0402-PAD: tolerance: ZZ.R0402.ZZZ
PR231 = R402H16: tolerance: 64.31615.6DL
PR583 PR4401 PR8328 R1989 R1994 R9601 R9604 R9609 R79915 = R402H16: tolerance: 63.47334.1DL
PR4407 PR4467 PR4802 PR4803 PR5268 PR5277 PR5285 PR8306 PR8317 PR8324 PR8338 R39 R40 R43 R44 R81 R92 R131 R150 R179 R292 R295 R297 R299 R301 R302 R306 R307 R332 R334 R336 R363 R370 R379 R381 R417 R418 R420 R458 R606 R632 R708 R709 R715 R722 R732 R1203 R1212 R1764 R1770 R1773 R1774 R1783-R1787 R1791 R1792 R1824 R1832 R1957 R9553 R9555 R79618-R79621 R79821-R79825 R79843 R79862 R79876 R79923 R79924 R79945 R79980 R79992 R80016 R80061 R80062 R80222-R80224 R80232 R80233 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11
PR4408 = R402H16: tolerance: 64.33015.6DL; signal model: 2pins
PR4409 = R402H16: tolerance: 64.30925.6DL
PR4413 = R402H16: tolerance: 64.43215.6DL; signal model: 2pins
PR4414 = R402H16: tolerance: 64.31625.6DL
