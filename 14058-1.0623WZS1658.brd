# Allegro board 14058-1.0623WZS1658.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EESCL: length 9.1
  TOP w0.102: v2(34.75,44.95) 34.74,44.96 34.6,44.96 34.01,45.54 SCA1.56
  BOTTOM w0.102: RN9503.2 34.2,45.32 34.25,45.27 34.41,45.27 34.73,44.95 v2(34.75,44.95) 35.03,44.66 v3(36.8,44.66) 36.95,44.82 U9502.6
EESDA: length 10.4
  TOP w0.102: SCA1.57 33.51,45.53 34.61,44.44 34.61,44.26 v2(34.69,44.18)
  BOTTOM w0.102: U9502.5 37.92,43.55 37.74,43.37 v3(35.58,43.37) 34.89,44.06 34.82,44.06 v2(34.69,44.18) 34.69,44.36 34.23,44.82 RN9503.3
EQ: length 6.8
  TOP w0.102: U118.17 157.17,45.08 v1(156.79,44.69) 156.48,44.99 155.02,44.99 R2085.1 R1593.2
EUP_DSW_SEL: length 7.8
  TOP w0.102: U109.57 108.18,65.66 108.35,65.84 108.35,66.22 108.35,66.22 108.35,66.26 107.94,66.66 107.77,66.66 107.47,66.96 107.47,68.29 R321.1 106.75,69.26 R320.2 106.43,70.28 v1(105.73,70.98)
FALL_INT2: length 5.4
  TOP w0.102: Q6701.2 26.49,108.42 26.59,108.32 27.03,108.32 27.14,108.42 Q6701.3 28.03,109.41 v1(28.49,109.87) 28.9,109.45 R6703.2
FAN_CTRL_POWER: length 250.2
  TOP w0.102: R79913.1 11.35,158.75 11.35,158.25 11.63,157.97 15.44,157.97 17.21,156.2 v2(17.6,156.2) ; v2(139.87,85.74) 139.92,85.79 139.92,85.83 140.11,86.02 U2.AB39
  L3 w0.127: v2(135.32,121.4) 134.87,121.4 131.79,124.48 126.78,124.48 110.56,140.7 85.29,140.7 82.49,143.5 81.85,143.5 81.71,143.36 62.64,143.36 62.5,143.5 58.11,143.5 55.48,140.87 47.53,140.87 44.13,144.26 31.88,144.26 31.19,143.58 31.19,137.21 32.96,135.44 32.96,134.13 31.41,132.57 22.68,132.57 21.41,131.3 v2(20.26,131.3) 19.25,132.32 19.25,137.27 18.51,138.01 18.51,153.74 17.6,154.66 v2(17.6,156.2)
  BOTTOM w0.102: v2(139.87,85.74) 140.28,86.14 140.28,87.15 140.53,87.41 140.53,88.39 140.33,88.6 140.33,90.16 140.73,90.57 140.73,95.92 139.49,97.17 139.49,100.72 138.65,101.56 138.65,104.7 138.7,104.75 138.7,105.17 138.65,105.23 v3(138.65,113.86) 135.32,117.18 v2(135.32,121.4) ; v2(20.26,131.3) 21.25,130.31 21.25,127.08 19.02,124.85 19.02,115.18 15.67,111.82 13.96,111.82 13.28,112.51 6.92,112.51 6.19,113.23 6.19,116.47 7.18,117.46 PR5305.2
FAN_OFF_D: length 6.6
  TOP w0.102: R79916.1 R79915.2 7.44,166.8 R79917.1 7.5,164.97 v1(7.49,164.96) 7.74,164.71 7.74,162.71 Q1227.D
FAN_OFF_G: length 3.2
  TOP w0.102: Q1227.G 9.59,161.64 9.85,161.38 9.85,160.16 v1(10,160.01) 10.39,159.61 R79913.2
FAN_OFF_G2: length 29.3
  TOP w0.102: v1(8.96,165.62) 8.39,166.19 R79917.2 8.39,166.93 C12325.1 9.21,169.02 9.21,170.17 8.3,171.08 8.3,176.61 11.5,179.81 13.7,179.81 15.59,177.92 Q9624.G 16.58,173.62 16.58,171.82 C12324.1
FB_CAL_PD_VDDQ: length 6
  TOP w0.102: GPU1.D22 74.48,102.62 74.88,103.02 v5(74.88,103.03)
  BOTTOM w0.102: v5(74.88,103.03) 74.88,103.36 75.29,103.77 75.29,103.96 75.56,104.23 76.88,104.23 77.22,104.57 v3(77.22,104.61) 77.39,104.61 77.74,104.25 77.74,103.36 R611.1
FB_CAL_PU_GND: length 2.2
  TOP w0.102: GPU1.C24 72.78,101.81 v5(72.39,101.42)
  BOTTOM w0.508: v3(71.63,101.62) 71.83,101.42 v5(72.39,101.42) 72.49,101.52 R79979.1
FB_CAL_TERM_GND: length 5.9
  TOP w0.127: GPU1.B25 71.98,100.78 71.56,100.36 71.56,100.03 70.8,99.27 70.35,98.82 v5(70.35,98.57)
  BOTTOM w0.508: v3(69.51,97.74) 69.51,98.32 69.8,98.61 70.3,98.61 v5(70.35,98.57)
  BOTTOM w0.635: R79782.1 70.48,97.51 69.77,97.51 69.54,97.74 v3(69.51,97.74)
FB_PLLAVDD: length 57.7
  TOP w0.3: v5(75.5,110.74) 75.08,111.16 74.66,111.16 GPU1.P22 ; v5(74.8,105.55) 74.72,105.55 74.42,105.85 GPU1.H22
  TOP w0.356: GPU1.F16 79.45,104.26 v5(79.85,104.66)
  TOP w0.635: v2(62.35,127.53) 62.38,127.56 62.38,128.33 63.32,129.27 64.38,129.27 65.27,128.38 C456.1 65.5,128.03 65.85,128.38 67.46,128.38 67.96,127.88 67.96,127.54 68.6,126.91 C449.1 69.13,127.16 69.13,128.03 69.79,128.69 L27.1
  L3 w0.508: 74.92,105.55 75.15,105.55 75.56,105.14 75.86,105.14 76.32,105.6 76.65,105.6 77.16,106.11 77.66,106.11 78.02,105.75 78.02,105.71 79.07,104.66 v5(79.85,104.66) ; 74.92,105.55 v5(74.8,105.55) ; 74.92,105.55 75.76,106.39 75.76,107.66 75.63,107.79 75.63,109.56 75.45,109.75 75.45,110.23 75.45,110.23 75.45,110.7 v5(75.5,110.74)
  L3 w0.635: v2(62.35,127.53) 62.35,127.06 63.06,126.35 67.48,126.35 70.4,123.43 71.57,123.43 72.01,122.99 72.37,122.99 72.78,122.58 72.78,122.22 72.96,122.04 72.96,121.54 73.35,121.14 73.86,121.14 74.76,120.24 74.76,115.35 75.15,114.96 75.44,114.96 75.9,114.51 75.9,114.22 76.46,113.66 76.46,112.36 75.5,111.41 v5(75.5,110.74)
  BOTTOM w0.635: v5(75.5,110.74) 75.5,110.87 75.21,111.15 74.56,111.15 C465.1 ; v3(61.46,127.47) 61.52,127.53 v2(62.35,127.53) ; C502.1 75.64,105.71 74.95,105.71 v5(74.8,105.55) ; v5(79.85,104.66) 79.53,104.98 C503.1
FB_VREF: length 6.1
  TOP w0.127: GPU1.D23 73.63,102.68 73.99,103.04 v5(74.05,103.04)
  BOTTOM w0.127: TP43.1 75.32,98.16 75.32,100.79 74.05,102.06 v5(74.05,103.04)
FBA_DEBUG0: length 3
  TOP w0.127: v5(74.89,104.71) 74.82,104.71 74.48,104.37 GPU1.F22
  BOTTOM w0.127: R608.1 76.65,105.4 75.99,104.74 v3(75.68,104.74) 74.92,104.74 v5(74.89,104.71)
FBA_DEBUG1: length 3.1
  TOP w0.102: v5(74.02,106.39) 74.02,106.4 GPU1.J22
  BOTTOM w0.127: R604.1 74.91,107.67 v3(74.76,107.52) 74.76,107.14 v5(74.02,106.39)
FFS_INT1: length 254.9
  TOP w0.102: R79872.1 114.9,44.72 114.9,43.89 114.28,43.27 v2(114.06,43.27) ; v2(120.03,122.39) 120.31,122.67 120.93,122.67 122.84,120.76 135.86,120.76 v2(136.52,121.42) ; R6702.2 R79658.2 34.71,110.13 v1(34.71,110.6) 35.09,110.98 v2(35.63,110.98) ; U2.AE45 142.49,88.87 142.49,89.06 142.93,89.5 142.93,89.89 v2(142.94,89.9) 143.4,90.36 143.4,93.07 144.76,94.43 144.76,95.49 143.91,96.35 143.79,96.35 143.48,96.66 143.48,98.17 143.67,98.36 143.67,100.49 142.3,101.87 v2(142.06,101.87)
  L3 w0.127: v2(35.63,110.98) 41.43,116.79 41.43,124.89 47.07,130.53 60.56,130.53 61.9,129.18 74.28,129.18 76.02,130.92 89.91,130.92 90.17,130.67 102.65,130.67 110.9,122.43 120,122.43 v2(120.03,122.39) ; v2(144.06,44) 143.91,44.16 143.91,50 146.5,52.59 146.5,58.81 144.62,60.69 144.62,62.42 144.1,62.94 144.1,68.23 144.36,68.49 145.23,68.49 145.24,68.48 145.98,68.48 146.2,68.69 146.97,68.69 147.39,69.11 147.39,70.44 146.91,70.92 146.89,70.92 146.66,71.16 146.66,71.93 145.67,72.92 145.67,73.55 144.24,74.98 144.24,77.18 143.64,77.78 142.81,77.78 142.55,78.04 142.55,79.22 142.74,79.42 142.74,84.72 142.39,85.08 142.19,85.08 141.86,85.41 141.86,87.18 140.49,88.54 140.49,90.1 140.9,90.51 142.34,90.51 v2(142.94,89.9)
  L4 w0.127: v2(114.06,43.27) 115,43.27 117.02,41.25 119.26,41.25 120.41,42.4 129.18,42.4 130.48,41.1 132.42,41.1 134.56,43.24 143.25,43.24 144.01,44 v2(144.06,44) ; v2(142.06,101.87) 141.94,101.75 141.1,101.75 137.99,104.86 137.99,117.84 136.52,119.32 v2(136.52,121.42)
  BOTTOM w0.102: v2(35.63,110.98) 35.63,110.98 34.99,110.98 v3(34.82,110.98)
FFS_INT1_C: length 6
  TOP w0.102: U6701.11 33.72,111.87 34.11,111.49 34.11,110.41 R79658.1 33.09,109.59 32.49,108.99 v1(32.2,108.99) 31.95,109.25 31.95,109.65 R79656.1
FFS_INT1_SIO: length 6.6
  TOP w0.102: U109.110 110.58,48.48 110.81,48.25 111.35,48.25 111.96,47.64 112.54,47.64 113.58,46.6 v1(114.5,46.6) 115,46.09 R79872.2
FFS_INT2: length 195.7
  TOP w0.102: R79657.2 21.47,109.14 20.64,109.97 v2(20.64,110.97) ; U2.AG43 142.85,87.81 143.17,88.13 143.17,88.44 143.1,88.52 143.1,88.81 144.85,90.56 144.85,90.74 v1(144.86,90.75) 145,90.89 145,93.16 145.32,93.48 145.32,95.94 144.64,96.62 144.64,101.17 143.49,102.32 141.39,102.32 v2(141.29,102.22)
  L3 w0.127: v2(32.12,142.31) 32.87,142.31 34.19,143.63 43.62,143.63 47.02,140.23 56.98,140.23 58.81,142.06 65.1,142.06 65.41,141.76 83.69,141.76 85.13,140.32 110.41,140.32 126.62,124.1 131.63,124.1 134.8,120.93 137.44,120.93 v2(137.46,120.94)
  L4 w0.127: v2(141.29,102.22) 141.29,104.89 139.52,106.67 139.52,118.6 137.46,120.66 v2(137.46,120.94) ; v2(32.12,142.31) 29.37,139.56 29.37,137.1 24.38,132.12 23.97,131.71 23.97,127.38 22.18,125.59 21.09,125.59 20.38,124.87 20.38,114.13 21.08,113.43 21.08,111.47 20.64,111.03 v2(20.64,110.97)
FFS_INT2_C: length 15.1
  TOP w0.102: U6701.9 32.72,111.32 R79656.2 R79668.1 30.99,110.73 v1(30.04,110.73) 28.8,111.97 26.71,111.97 26.49,111.75 Q6701.5 26.49,110.48 26.36,110.35 25.6,110.35 24.39,109.14 R6706.1 23.95,109.14 R6704.2 R79657.1
FFS_INT2_Q: length 10
  TOP w0.102: Q6701.6 24.58,110.03 R6706.2 R6705.2 24.16,111.01 21.26,111.01 20.8,111.47 20.8,114.02 SATAP1.5
FLASH_WP: length 39.6
  TOP w0.102: v2(33.62,28.56) 33.02,28.56 32.51,28.05 SCA1.108 ; R9509.1 v2(52.9,9.38)
  L3 w0.127: v2(33.22,19.16) 33.25,19.2 33.25,25.01 33.69,25.45 33.69,28.5 v2(33.62,28.56)
  BOTTOM w0.102: v2(33.22,19.16) 33.86,19.16 34.69,18.34 34.69,18.32 v3(35.38,17.64) 35.71,17.31 38.1,17.31 38.89,18.1 42.86,18.1 44.99,15.97 47.05,15.97 47.06,15.98 49.83,15.98 52.24,13.56 52.24,13.52 53.36,12.4 53.36,10.46 52.9,10.01 v2(52.9,9.38)
FP_RST_N: length 200.4
  TOP w0.102: v2(34.15,122.29) 34.05,122.29 33.91,122.44 31.69,122.44 31.12,123.01 C12242.1 31.12,124.83 R1762.2 R1783.1 ; U2.AW1 149,67.03 149.79,66.24 149.92,66.24 150.25,65.91 150.77,65.91 151.02,65.66 151.02,64.89 150.36,64.23 150.36,63.44 150.39,63.42 150.39,62.71 150.95,62.15 150.95,59.96 151.25,59.65 151.25,58.72 R128.1 151.82,57.78 151.28,57.23 151.28,56.81 149.95,55.49 149.95,54.69 147.53,52.26 131.17,52.26 130.41,51.5 v2(130.41,50.77)
  L4 w0.127: v2(130.41,50.77) 129.98,51.2 122.44,51.2 121.22,52.42 116.98,52.42 116.75,52.18 116.15,52.18 115.41,52.92 114.5,52.92 108.58,58.84 107.61,58.84 106.59,59.86 104.86,59.86 100.52,64.21 97.31,64.21 97.19,64.09 95.14,64.09 94.81,64.09 94.33,64.57 92.65,64.57 92.04,63.96 91.71,63.96 86.15,63.96 84.4,65.71 84.4,66.99 83.43,67.96 83.43,69.31 78.08,74.66 67.22,74.66 58.78,83.1 58.78,83.35 58.52,83.62 57.58,83.62 52.9,88.29 52.9,89.29 52.22,89.97 51.19,89.97 49.64,91.51 36.81,91.51 v2(36.39,91.93)
  BOTTOM w0.102: v2(36.39,91.93) 31.83,91.93 30.58,93.18 30.58,99.38 32.86,101.66 32.86,111.54 34.64,113.32 v3(34.64,114.34) 34.64,115.8 32.61,117.83 32.61,120.75 v2(34.15,122.29) 34.15,122.46 34.31,122.62 34.31,123.57 34.58,123.84 35,123.84 35.2,124.04 35.49,124.04 35.52,124.01 XDPC1.48
FP_RST_PCH_N_CN: length 1.4
  TOP w0.102: TP225.1 29.85,127.3 R1783.2
FWH_ID0: length 6.3
  TOP w0.102: R764.2 v2(136.28,50.35)
  L3 w0.127: v2(136.28,50.35) 136.28,50.34 136.56,50.63 LPC1.6
  BOTTOM w0.102: v3(137.09,50.35) v2(136.28,50.35)
GC6_FB_EN: length 11.4
  TOP w0.127: R80045.2 94.8,105.47 v1(94.04,105.47) 93.99,105.52 90.87,105.52 90.62,105.27 90.62,104.89 90.49,104.76 89.22,104.76 88.97,104.51 88.97,103.06 88.89,102.98 88.89,101.63 88.64,101.38 88.12,101.38 GPU1.C6
GPA7: length 4.2
  TOP w0.102: R270.1 111.19,67.47 v1(111.16,67.43) 110.18,66.45 U109.52
GPIO: length 3.7
  BOTTOM w0.102: R79850.1 191.01,136.95 191.09,137.03 v3(191.09,137.11) 191.16,137.17 191.16,138.03 191.19,138.07 U14.28
GPIO1_FBVDDQCTL: length 5.7
  TOP w0.127: TP260.1 94.94,98.03 94.01,98.96 93.04,98.96 91.97,100.02 91.97,100.39 91.73,100.64 91.36,100.64 GPU1.B2
GPIO2_BL_PWM: length 2.5
  TOP w0.127: v5(88.14,103.09) 88.14,103.04 87.72,102.62 GPU1.D6
  BOTTOM w0.127: R616.1 88.96,103.17 v3(88.92,103.14) 88.18,103.14 v5(88.14,103.09)
GPIO3_PPEN_R: length 2.9
  TOP w0.127: GPU1.C7 86.88,101.83 v5(87.27,102.22)
  BOTTOM w0.127: R622.1 88.83,102.13 88.11,101.41 88.1,101.41 v3(88.09,101.41) 88.09,101.41 88.08,101.41 v5(87.27,102.22)
GPIO4_BLEN: length 3.1
  TOP w0.127: GPU1.F9 85.59,103.87 v5(85.59,103.87)
  BOTTOM w0.127: v5(85.59,103.87) 85.59,104.53 85.2,104.92 v3(85.02,104.92) 84.97,104.92 84.71,104.67 R615.1
GPIO5_PWM_VID_BOOT_EN: length 1.5
  TOP w0.127: v2(90.43,99.68) 90.42,99.69 90.42,99.98 GPU1.A3
  BOTTOM w0.127: TP257.1 90.05,99.3 v2(90.43,99.68)
GPIO6_FB_CLAMP_TGL_REQ: length 4
  TOP w0.127: v2(91.23,99.25) 90.92,98.94 90.01,98.94 89.55,99.4 89.55,100.05 GPU1.A4
  BOTTOM w0.127: v2(91.23,99.25) 90.57,98.59 TP18.1
GPIO7_3D_STEREO: length 6.9
  TOP w0.127: v2(88.97,99.75) 88.86,99.86 88.26,99.86 88.08,100.04 88.08,100.62 GPU1.B6
  BOTTOM w0.127: R79981.1 90.77,96.56 v3(90.62,96.71) 90.65,96.73 90.65,97.35 88.98,99.01 88.98,99.74 v2(88.97,99.75)
GPIO8_OVERT#: length 30.5
  TOP w0.102: GPU1.A6 87.68,100.13 88.66,99.15 88.84,99.15
  TOP w0.127: 88.84,99.15 89.25,99.15 89.68,98.72 91.1,98.72 91.19,98.8 91.41,98.8 91.46,98.86 92.51,98.86 v2(93.06,98.31)
  L3 w0.165: v2(93.06,98.31) 93.67,98.92 96.75,98.92 97.43,98.24 98.06,98.24 98.37,97.93 98.37,93.84 97.07,92.54 97.07,89.9 96.56,89.39 v2(93.41,89.39)
  BOTTOM w0.127: v2(93.41,89.39) 93.22,89.2 Q9631.C 93.67,87.93 R79984.1 R603.2 95.65,86.03 95.7,86.08 v3(95.74,86.08)
GPIO9_ALERT#: length 26.4
  TOP w0.127: v5(86.49,103.84) 86.06,104.26 GPU1.F8 ; PR8319.1 104.46,95.62 105.35,94.73 v1(105.35,94.6) 104.67,94.6 104.46,94.8 v2(104.37,94.8)
  L3 w0.165: v5(86.49,103.84) 87.67,102.65 91.71,102.65 v2(93.41,100.95) 94.43,99.94 97.76,99.94 100.32,97.38 101.63,97.38 104.2,94.8 v2(104.37,94.8)
  BOTTOM w0.127: v2(93.41,100.95) 92.46,101.9 R631.1
GPIO10_MEM_VREF_CTL: length 4.2
  TOP w0.127: GPU1.C5 88.52,101.83 88.47,101.83 88.1,102.2 v5(88.08,102.2)
  BOTTOM w0.127: R619.1 90.04,102.04 v3(90.26,102.27) 89.92,102.61 88.41,102.61 88.08,102.28 v5(88.08,102.2)
GPIO11_PWM_VID: length 19.3
  TOP w0.127: v2(99.99,107.45) 100.32,107.78 v1(101.11,107.78) 101.14,107.76 101.14,107.49 PR8324.2 ; v5(87.31,104.72) 87.31,104.68 87.24,104.61 87.24,104.11 87.19,104.07 87.19,103.74 86.88,103.43 GPU1.E7
  L3 w0.165: v2(99.99,107.45) 99.89,107.35 99.89,106.86 97.05,104.02 94.67,104.02 93.75,104.93 88.93,104.93 88.71,105.15 87.74,105.15 v5(87.31,104.72)
GPIO12_AC_DETECT: length 8.9
  TOP w0.102: GPU1.D7 86.85,102.62 v5(86.46,103.01)
  BOTTOM w0.127: R79987.1 91.54,107.05 91.07,106.58 90.46,106.58 89.83,105.94 87.57,105.94 v3(86.19,104.56) 86.07,104.44 86.07,103.4 v5(86.46,103.01)
GPIO13_NVVDD_PSI: length 25.7
  TOP w0.102: GPU1.B4 89.78,100.62 89.78,99.72 90.25,99.25 90.61,99.25 91.04,99.68 91.99,99.68 92.6,99.07 92.93,98.74 93.36,98.74 v2(93.8,98.31)
  L4 w0.165: v2(93.8,98.31) 93.88,98.39 93.88,101.72 92.7,102.9 92.7,106.1 94.96,108.36 96,108.36 97.81,110.17 v2(97.81,110.76)
  BOTTOM w0.127: v2(97.81,110.76) 98.15,110.41 98.15,110.15 98.48,109.83 98.48,108.97 v3(98.52,108.93) 98.52,108.72 97.97,108.18 R80016.2
GPIO_FB_CLAMP_GPU: length 6.9
  TOP w0.127: GPU1.F3 90.39,104.53 90.65,104.53 90.87,104.76 93.34,104.76 93.95,104.15 v1(94.18,104.15) 94.26,104.24 R80045.1 95.27,104.11 PR5522.1
GPP_E0: length 5.4
  TOP w0.102: U2.AG36 142.86,84.5 142.93,84.57 143.29,84.57 143.35,84.51 v2(143.37,84.51)
  BOTTOM w0.102: TP203.1 143.28,81.43 143.65,81.43 143.9,81.68 143.9,82.84 143.65,83.09 143.52,83.09 143.42,83.2 143.11,83.2 142.91,83.39 142.91,84.07 143.35,84.51 v2(143.37,84.51)
GPP_E1: length 1.5
  TOP w0.102: U2.AG35 143.21,83.74 143.27,83.68 v2(143.36,83.68)
  BOTTOM w0.102: v2(143.36,83.68) 143.56,83.68 143.68,83.55 TP193.1
GPP_E2: length 6
  TOP w0.102: U2.AG39 142.83,85.7 143.33,85.2 143.47,85.2 143.83,85.57 144.42,85.57 v2(144.6,85.75)
  BOTTOM w0.102: v2(144.6,85.75) 144.6,85.94 144.11,86.42 144.11,86.78 144.37,87.03 144.63,87.03 145.07,87.47 145.07,87.85 145,87.92 TP194.1
GPP_E3: length 6.6
  TOP w0.102: v2(143.41,85.84) 143.14,86.11 143.14,86.15 142.78,86.51 U2.AF41
  BOTTOM w0.102: R79767.1 144.72,89.94 v3(144.45,89.67) 144.45,88.91 144.21,88.67 144.21,87.16 143.91,86.86 143.91,86.34 v2(143.41,85.84)
GPP_E4: length 1.9
  TOP w0.102: U2.AG42 142.96,87.27 143.33,86.9 v2(143.33,86.6)
  BOTTOM w0.102: TP195.1 143.33,87.13 v2(143.33,86.6)
GPP_F0: length 3.9
  TOP w0.102: U2.AD35 v2(141.03,83.74)
  BOTTOM w0.102: v2(141.03,83.74) 140.52,83.22 140.52,82.32 140.51,82.31 140.51,80.99 TP202.1
GPP_F1: length 4.9
  TOP w0.102: v2(140.98,83) 141.31,83.33 141.87,83.33 142.39,82.82 142.39,82.31 U2.AD31
  BOTTOM w0.102: TP201.1 141.75,82.13 140.98,82.9 v2(140.98,83)
GPP_F2: length 3
  TOP w0.102: v2(142.3,84.54) 142.3,84.62 142.17,84.74 142.17,84.83 141.74,85.26 U2.AD38
  BOTTOM w0.102: v2(142.3,84.54) 141.8,84.04 TP200.1 141.8,82.85 R79770.2
GPP_F3: length 9.6
  TOP w0.102: TP199.1 141.24,96.07 141.24,94.77 140.76,94.28 140.76,90.56 140.53,90.33 140.53,89.11 140.83,88.81 140.83,88.52 140.9,88.44 140.9,87.83 U2.AC43
GPP_F4: length 7.1
  TOP w0.102: U2.AB44 140.67,88.38 140.62,88.43 140.62,88.73 140.33,89.02 140.33,90.42 140.53,90.62 140.53,94.98 TP204.1
GPP_G23: length 6.2
  TOP w0.102: TP144.1 131.77,90.67 132.33,90.11 132.33,89.7 132.58,89.45 132.58,89.22 132.86,88.94 133.27,88.94 133.66,88.56 133.9,88.56 134.09,88.36 134.43,88.36 134.56,88.23 134.56,88.07 134.85,87.79 U2.L43
GPU_1D05V:
  vias: v1(102.35,126)
GPU_1D05V_EN: length 4.2
  TOP w0.102: PU5302.8 108.98,131.56 109.31,131.23 110.1,131.23 v1(110.18,131.3) 110.18,131.71 110.22,131.75 PC154.1 110.24,133.21 PR227.1
GPU_1D05V_FB: length 5.6
  TOP w0.254: PC157.2 PR231.2 ; PC157.2 v1(101.29,131.43) 101.29,131.58 101.24,131.63 101.24,131.67 PR229.1 ; PC157.2 101.61,130.29 PU5302.2
GPU_1D05V_PG: length 111
  TOP w0.102: PU8602.2 41.57,104.88 40.23,106.21 40.05,106.21 39.6,106.67 PR5525.2 38.65,106.07 37.84,106.07 37.72,105.95 37.71,105.95 37.61,105.85 37.61,105.84 37.51,105.74 37.51,105.31 PC56.1 35.31,103.11 D5206.A 34.11,103.62 35.5,105.02 v2(36.52,105.02) ; PU5302.7 108.93,130.29 109.39,130.75 111.21,130.75 111.66,131.2 111.66,132.78 109.8,134.65 v1(109.8,134.58) 108.43,135.95 100.55,135.95 98.49,133.89 v2(98.49,132.57)
  L4 w0.127: v2(36.52,105.02) 36.62,105.12 36.62,106.93 39.57,109.87 39.57,110.89 56.69,128.01 82.5,128.01 86.11,131.62 97.54,131.62 v2(98.49,132.57)
GPU_1D05V_VGA_EN: length 52.3
  TOP w0.102: v2(106.84,96.84) 106.84,96.82 105.7,95.68 PR8315.1 ; v2(106.11,132.45) 106.38,132.45 106.88,132.95 D5209.A 107.45,133.27 PR583.2 108.46,133.34 PR227.2
  L4 w0.127: v2(101.78,109.61) 102.39,110.22 105.73,110.22 106.28,109.68 v2(106.28,109.36)
  BOTTOM w0.102: v2(106.11,132.45) 106.11,131.3 104.13,129.32 v3(104.13,127.49) 104.13,124.65 104.89,123.89 104.89,122.51 101.66,119.28 101.45,119.07 101.45,110.95 101.78,110.62 v2(101.78,109.61) ; v2(106.84,96.84) 106.84,99.72 105.43,101.13 104.85,101.13 104.26,101.71 104.26,107.35 106.28,109.37 106.28,109.37 106.27,109.36 106.27,109.36 106.28,109.36 v2(106.28,109.36)
GPU_3D3V_S0_THERM: length 8.7
  TOP w0.508: v2(97.22,87.11) 97.33,87.21 97.33,87.25 97.61,87.53 R602.1 C475.2 96.16,88.06 95.5,87.39 Q59.B
  BOTTOM w0.508: v2(97.22,87.11) 97.28,87.06 97.28,86.45 95.97,85.14 R603.1
  BOTTOM w0.635: v3(94.43,84.19) 94.81,84.57 R603.1
GPU_3D3V_S0_THERM_2:
  vias: v1(94.65,83.58)
GPU_ALLPWR: length 3.2
  TOP w0.102: U109.125 116.58,48.07 v1(117.29,47.36) R80231.1
GPU_DMINUS: length 52.5
  L4 w0.127: v2(90.53,70.62) 90.32,70.62 89.91,71.03 89.91,79.79 91.51,81.39 91.51,88.38 90.37,89.52 90.37,91.42 90.54,91.59 90.67,91.59 90.96,91.3 v2(91.13,91.3)
  BOTTOM w0.127: v2(90.53,70.62) 90.49,70.59 90.49,69.68 ; 90.49,69.68 90.49,66.55 90.84,66.2 90.84,66.19 91.12,65.91 91.13,65.91 92.01,65.03 92.01,62.6 93.09,61.52 94.29,61.52 96.16,59.64 96.16,59.1 98.88,56.39 C12065.2 99.76,56.31 R79620.2 ; 90.49,69.68 v3(90.77,69.68) ; v2(91.13,91.3) 91.06,91.36 91.06,91.49 90.62,91.93 90.62,92.19 89.55,93.25 89.55,96.77 88.95,97.38 88.95,97.88 88.79,98.04 88.41,98.04 RT2.1 88.27,98.03 R80047.1
GPU_DMINUS_G: length 9.2
  TOP w0.127: v5(83.12,103.82) GPU1.E12
  BOTTOM w0.127: v5(83.12,103.82) 83.12,103.7 83,103.58 83,99.61 84.35,98.26 85.12,98.26 ; 85.12,98.26 v3(85.12,97.89) ; 85.12,98.26 86.14,98.26 R80047.2
GPU_DPLUS: length 57.9
  TOP w0.127: v2(101.12,55.21) 101.14,55.21 101.36,54.99 101.78,54.99 102.24,55.45 102.69,55.45 102.9,55.23 103.81,55.23 U109.85
  L4 w0.127: v2(91.13,92.14) 90.96,92.14 90.67,91.84 90.43,91.84 90.11,91.52 90.11,89.42 91.26,88.27 91.26,81.5 89.66,79.9 89.66,70.93 89.99,70.6 v2(89.99,70.09)
  BOTTOM w0.127: v3(90.39,65.9) 90.59,66.1 ; 90.59,66.1 90.59,66.09 91.02,65.66 91.02,65.66 91.76,64.93 91.76,62.49 92.99,61.26 94.18,61.26 95.91,59.54 95.91,59 98.38,56.53 98.38,55.92 C12065.1 100.02,55.42 R79624.1 100.23,55.21 v2(101.12,55.21) ; 90.59,66.1 90.24,66.44 90.24,69.84 v2(89.99,70.09) ; v2(91.13,92.14) 91.12,92.12 91,92.12 90.87,92.25 90.87,92.29 89.81,93.36 89.81,96.88 89.2,97.48 89.2,97.99 RT2.2 88.14,99.05 R80048.1
GPU_DPLUS_G: length 9.9
  TOP w0.127: GPU1.F12 82.72,104.27 v5(83.11,104.66)
  BOTTOM w0.102: 83.25,102.77 83.25,103.21 83.53,103.49 83.53,104.2 83.11,104.62 v5(83.11,104.66)
  BOTTOM w0.127: v3(84.42,98.96) 84.22,98.75 ; 84.22,98.75 83.25,99.71 83.25,102.77 ; 84.22,98.75 84.45,98.51 85.83,98.51 R80048.2
GPU_PLTRST: length 15.2
  TOP w0.102: Q9630.D 105.73,89.01 v1(105.1,88.38) 105.91,87.57 v2(105.94,87.57)
  L3 w0.127: v2(96.48,86.59) 96.85,86.22 97.89,86.22 98.27,86.6 100.53,86.6 102.09,88.16 105.06,88.16 105.66,87.57 v2(105.94,87.57)
  BOTTOM w0.102: v2(96.48,86.59) 95.68,87.39 Q9631.E
GPU_TESTMODE: length 3.3
  TOP w0.102: GPU1.AD9 85.2,119.23 85.6,119.63 v5(85.62,119.63)
  BOTTOM w0.127: v5(85.62,119.63) 85.62,120.03 v3(86.18,120.59) 86.18,120.6 86.95,121.37 R192.1
GPU_THERM_SHUTDOWN_N: length 1.5
  TOP w0.127: PR8325.1 102.91,109.76 TP99.1
GPU_THERM_SHUTDOWN_N_1: length 18.9
  TOP w0.127: R596.2 96.84,84.82 98.88,86.85 103.45,86.85 v2(103.7,86.6)
  BOTTOM w0.127: Q6704.B 110.53,84.63 C436.1 107.38,85.97 v3(107.32,86.03) 106.75,86.6 v2(103.7,86.6)
GPU_THERM_SHUTDOWN_N_2: length 6.6
  TOP w0.127: v1(95.54,85.86) 95.43,85.97 R597.1 94.37,86.09 94.37,88.47 v2(94.33,88.51)
  BOTTOM w0.127: C447.1 96.34,88.95 95.83,88.95 95.41,89.36 Q9631.B 95.13,89.31 v2(94.33,88.51)
GPU_THERMAL_INT: length 3.6
  TOP w0.102: v2(118,61.53) 118.15,61.53 118.23,61.61 U109.28
  BOTTOM w0.102: v2(118,61.53) 117.68,61.85 v3(117.19,61.85) 117.14,61.8 117.14,61.11 R263.1
GPU_VCC3_CTL: length 8.5
  TOP w0.127: D5205.A 99.38,118.1 98.46,117.18 98.41,117.18 R584.2 C414.2 v1(98.18,114.95) 98.18,114.26 98.23,114.21 98.23,113.32 97.64,112.73 97.64,111.95 Q53.G
GPU_VCC3_CTL_2: length 4.1
  TOP w0.254: Q54.G 95.26,118.44 C836.1 95.26,117.45 96.21,116.5 v1(96.21,116.32) 95.89,116 R1195.2
H_PECI: length 34.1
  TOP w0.102: R37.2 R41.1 59.87,145.21 61.21,143.88 v1(61.61,143.88) 62.32,144.59 62.32,144.96 62.61,145.24 62.61,173.63 CPU1.G7
H_PM_DOWN: length 9.5
  TOP w0.102: R79774.1 138.83,62.68 v1(139.52,63.38) 139.88,63.74 142.62,63.74 143.93,65.05 143.93,67.1 143.72,67.32 U2.AH2
H_PM_DOWN_R: length 224.7
  TOP w0.102: CPU1.D8 v5(59.04,174.45) ; v2(127.23,63.47) 127.23,63.46 128.33,62.37 129.79,62.37 132.21,59.96 137.91,59.96 R79774.2
  L4 w0.127: v5(59.04,174.45) 59.04,174.17 59.48,173.72 59.48,169.4 60.84,168.05 60.84,139.06 54.85,133.06 53.45,133.06 43.85,123.46 43.85,120.11 40.12,116.38 38.06,116.38 37.77,116.09 36.15,116.09 33.08,113.02 33.08,111.73 33.03,111.68 33.03,109.7 32.9,109.57 32.9,107.21 32.62,106.93 32.62,102.52 32.09,101.98 32.09,91.42 36.99,86.51 37.31,86.51 37.31,86.51 49.34,86.51 56.52,79.33 57.97,79.33 65.57,71.74 72.94,71.74 73.13,71.55 74.71,71.55 75.2,72.05 v2(76.02,72.05)
  BOTTOM w0.102: v2(127.23,63.47) 127.23,63.47 126.59,63.47 124.72,65.34 124.55,65.34 121.98,67.91 118.27,67.91 117.16,69.02 117.16,71.24 v3(114.45,73.95) 112.15,76.26 109.75,76.26 109.04,75.55 94.5,75.55 91.76,72.81 77.61,72.81 77.3,72.5 76.47,72.5 v2(76.02,72.05)
H_PM_SYNC: length 221.5
  TOP w0.102: v2(124.71,67.42) 124.99,67.14 124.99,66.84 127.96,63.87 127.96,63.24 128.47,62.72 130.06,62.72 131.56,61.23 R79775.2 ; v5(59.95,174.45) CPU1.E8
  L4 w0.127: v5(59.95,174.45) 59.95,170.58 61.77,168.77 61.77,167.6 61.27,167.11 61.27,139.18 61.27,139.18 61.27,138.95 55,132.68 53.6,132.68 44.23,123.31 44.23,119.95 40.27,116 38.22,116 37.93,115.71 36.31,115.71 33.97,113.37 33.97,110.1 33.28,109.41 33.28,107.05 33,106.77 33,102.36 32.47,101.82 32.47,91.58 37.15,86.89 49.5,86.89 56.68,79.71 58.13,79.71 65.72,72.12 73.22,72.12 v2(73.32,72.02)
  BOTTOM w0.102: v2(124.71,67.42) 123.31,68.82 123.31,73.6 123.74,74.04 123.74,74.5 123.41,74.83 114.59,74.83 112.44,76.97 109.45,76.97 108.77,76.29 94.16,76.29 91.39,73.52 75.9,73.52 v3(75.45,73.07) 74.3,71.92 73.42,71.92 v2(73.32,72.02)
H_PM_SYNC_0: length 17
  TOP w0.102: R79775.1 135.16,60.31 137.74,60.31 138.27,60.85 138.27,63.21 138.2,63.29 v1(138.2,63.38) 138.76,63.94 142.54,63.94 143.6,65.01 143.6,65.27 143.73,65.4 143.73,66.93 143.6,67.06 143.6,67.14 143.49,67.26 143.49,68 143.84,68.36 U2.AJ4
H_PRDY_N: length 58.3
  TOP w0.102: v2(56.99,176.84) 57.09,176.74 CPU1.B10 ; R1774.2 45.35,134.06 45.1,134.32 44.68,134.32 v2(44.52,134.48) 44.14,134.1 TP136.1
  L4 w0.127: v2(56.99,176.84) 56.99,176.26 56.56,175.84 56.56,167.07 58.08,165.55 58.08,148.93 57.4,148.25 57.4,146.91 57.38,146.89 57.38,140.03 53.21,135.85 v2(53.21,135.44)
  BOTTOM w0.102: XDPC1.5 44.2,134.51 44.23,134.48 v2(44.52,134.48) 44.67,134.63 49.25,134.63 49.81,135.19 52.96,135.19 v2(53.21,135.44)
H_PREQ_N: length 59.4
  TOP w0.102: R8.2 56.84,139.56 56.5,139.22 v2(56.5,138.24) ; v5(57.07,175.74) 57.17,175.74 57.26,175.82 CPU1.B9 ; TP135.1 43.79,135.08 44.36,135.08 v2(44.52,135.24) 44.68,135.08 R1773.2
  L4 w0.127: v2(56.5,138.24) 56.5,138.79 57.64,139.92 57.64,146.79 57.65,146.8 57.65,148.02 58.34,148.71 58.34,165.62 56.79,167.17 56.79,173.71 57.07,173.99 v5(57.07,175.74)
  BOTTOM w0.102: v2(56.5,138.24) 55.14,138.24 52.32,135.42 49.71,135.42 49.15,134.86 44.9,134.86 v2(44.52,135.24) 44.28,135.01 XDPC1.3
H_PROCHOT_N: length 432.3
  TOP w0.102: v2(12.59,244.54) 23.1,244.54 35.27,232.37 v2(35.91,232.37) 36.86,232.37 C12125.1 36.96,231.28 R12.2 R1821.1 ; v2(106.88,40.37) 107.56,41.06 108.75,41.06 108.75,41.06 113.29,41.06 113.87,40.49 115.67,40.49 116.58,41.39 116.58,43.65 119.02,46.09 R80245.2 ; v2(75.89,44.25) 75.89,45.14 PQ4408.D
  L3 w0.127: v2(12.59,244.54) 11.37,244.54 2.98,236.15 2.98,175.54 8.45,170.07 8.45,169.4 18.4,159.46 18.4,154.4 18.89,153.9 18.89,139.59 v2(19.76,138.72)
  L4 w0.127: v2(35.91,232.37) 36.77,232.37 36.87,232.27 45.45,232.27 50.23,237.05 50.23,237.69 50.23,254.48 v2(50.04,254.67) ; v2(106.88,40.37) 106,39.5 105.59,39.5 105.31,39.77 105.31,40.92 104.97,41.26 104.97,42.31 102.63,44.65 76.29,44.65 v2(75.89,44.25) 75.45,44.68 65.57,44.68 64.96,44.07 64.96,41.25 62.18,38.48 57.71,38.48 54.3,41.9 54.3,45.4 52.37,47.33 51.61,47.33 50.62,48.33 v2(50.57,48.33)
  BOTTOM w0.102: v2(50.04,254.67) PR4415.2 49.22,253.86 v3(49.09,253.73) 48.84,253.48 48.84,252.47 47.05,250.68 46.14,250.68 44.11,248.65 PU4401.12 ; v2(19.76,138.72) 19.27,138.23 19.27,133.43 20.07,132.62 20.35,132.62 21.61,131.37 21.61,126.94 19.38,124.71 19.38,114.36 20.44,113.3 20.44,112.1 20.06,111.72 20.06,110.7 20.8,109.97 20.8,102.42 23.46,99.76 23.46,90.84 21.74,89.11 17.26,89.11 12.56,84.42 7.01,84.42 4.79,82.19 4.79,68.29 6.02,67.07 13.62,67.07 20.01,60.68 20.01,58.79 21.08,57.72 23.52,57.72 24.53,58.74 30.54,58.74 34.17,55.1 47.02,55.1 53.61,48.51 53.61,48.13 53.13,47.65 51.25,47.65 v2(50.57,48.33)
H_PROCHOT_N_SIO: length 13
  TOP w0.102: U109.8 120.45,53.61 121.75,52.3 121.75,50.93 121.63,50.81 121.63,50 123.13,48.5 123.13,47.23 v1(123.01,47.1) 123.01,46.28 122.43,45.71 120.53,45.71 R80245.1
H_PROCHOT_R_N: length 37.5
  TOP w0.102: R1821.2 38.11,230.39 v2(40.1,230.39) ; v2(58.05,206.68) 58.28,206.68 CPU1.C39
  BOTTOM w0.102: v2(58.05,206.68) 56.51,208.22 54.72,208.22 52.11,210.83 52.11,217.93 49.01,221.03 49.01,223.2 41.82,230.39 v3(41.42,230.39) v2(40.1,230.39)
H_PWRGD: length 244.2
  TOP w0.102: v2(113.84,76.31) 117.77,72.38 117.77,68.65 119.99,66.43 123.85,66.43 125.39,64.89 125.39,62.9 125.6,62.7 130.01,58.29 131.15,58.29 131.29,58.15 141.16,58.15 143.84,60.83 143.84,60.83 R1981.2 ; v2(54.17,131.25) 54.09,131.18 54.09,130.96 53.52,130.39 49.85,130.39 49.11,131.13 47.27,131.13 46.17,130.03 46.17,129.08 R1775.1 ; CPU1.F8 60.86,174.44 v5(60.83,174.44)
  L4 w0.127: v2(74.11,72.38) 74.03,72.38 73.91,72.5 65.88,72.5 58.29,80.09 56.83,80.09 49.66,87.27 37.31,87.27 34.23,90.35 34.23,94.98 32.85,96.37 32.85,101.67 33.38,102.2 33.38,106.62 33.66,106.89 33.66,109.25 34.35,109.94 34.35,113.21 36.47,115.33 38.08,115.33 38.38,115.62 40.43,115.62 45.36,120.55 45.36,123.58 52.24,130.46 53.38,130.46 v2(54.17,131.25) 61.65,138.74 61.65,139.02 61.65,139.03 61.65,166.93 62.15,167.42 62.15,168.92 60.4,170.67 60.4,174.01 v5(60.83,174.44)
  BOTTOM w0.102: v2(113.84,76.31) 112.61,77.54 109.51,77.54 108.77,76.8 v3(107.64,76.8) 107.49,76.64 94.01,76.64 91.24,73.87 75.35,73.87 74.11,72.63 v2(74.11,72.38)
H_PWRGD_CPU: length 7.2
  TOP w0.102: R1981.1 143.86,62.04 144.8,62.98 144.8,63.5 v1(144.67,63.63) 145.02,63.97 145.02,66.93 145.18,67.1 145.18,67.26 145.23,67.31 145.23,67.74 145.51,68.02 U2.AM3
H_RSTOUT_XDP_N: length 6.9
  TOP w0.102: R1770.2 R1771.2 33.7,124.32 33.41,124.61 R1776.2 33.9,125.08 34.64,124.34 v2(34.64,124.32) v1(35.63,124.32)
  BOTTOM w0.102: v2(34.64,124.32) 34.83,124.51 XDPC1.46
H_SKTOCC_N: length 343.7
  TOP w0.102: U2.Y44 139.4,88.34 139.58,88.52 139.58,88.89 139.64,88.96 139.64,89.65 139.24,90.06 139.24,92.28 140.07,93.12 140.07,94.25 139.9,94.42 139.9,95.42 140,95.53 140,96.85 140.58,97.43 140.58,98.6 142.44,100.45 v2(142.44,101.08) ; v2(77.33,202.19) 76.93,201.8 CPU1.AB35 ; v2(109.04,234.05) 109.04,232.97 R20.2
  L3 w0.127: v2(77.33,202.19) 77.3,202.19 75.32,204.17 75.32,210.66 89.19,224.52 109.8,224.52 111.97,226.69 137.78,226.69 138.68,227.59 149.27,227.59 151.58,225.28 164.28,225.28 170.12,219.44 170.12,214.07 169.12,213.07 169.12,212.32 172.66,208.77 172.66,202.51 173.77,201.41 173.77,160.07 173.46,159.77 173.46,131.43 174.61,130.29 174.61,113.32 174.86,113.06 174.86,102.44 175.06,102.23 175.06,100.62 173.83,99.39 169.08,99.39 168.31,100.16 157.09,100.16 155.07,102.18 150.2,102.18 149.45,101.43 148.54,101.43 147.8,102.18 144.73,102.18 143.63,101.08 v2(142.44,101.08)
  BOTTOM w0.102: v2(77.33,202.19) 77.33,202.25 75.43,204.15 75.43,213.35 83.55,221.47 89.4,221.47 94.56,226.63 103.14,226.63 106.52,230.01 106.52,231.53 v3(107.74,232.75) v2(109.04,234.05)
H_TCK: length 245.4
  TOP w0.102: R32.1 43.12,121.08 43.12,120.08 v2(42.61,119.57) ; v2(145.06,56.52) 146.01,56.52 146.75,57.26 146.75,57.43 R131.2 ; CPU1.F11 v5(60.87,177.2)
  L4 w0.127: v2(145.06,56.52) 144.8,56.52 144.69,56.41 142.94,56.41 140.62,58.73 128.21,58.73 126.36,60.59 126.36,61.02 121.06,66.32 119.12,66.32 118.1,67.34 116.69,68.74 116.69,69.07 111.63,74.13 v2(110.53,74.13) ; v2(75.02,70.78) 74.63,71.17 72.97,71.17 72.78,71.36 65.41,71.36 57.82,78.95 55.26,78.95 51.83,82.37 51.83,83.48 49.18,86.13 37.47,86.13 36.84,86.13 31.7,91.26 31.7,102.14 32.24,102.67 32.24,107.09 32.52,107.37 32.52,109.73 32.64,109.85 32.64,111.83 32.7,111.88 32.7,113.17 35.99,116.47 37.61,116.47 38.51,117.37 40.55,117.37 41.05,117.87 41.05,118.01 v2(42.61,119.57) 43.46,120.42 43.46,123.62 53.29,133.45 54.69,133.45 60.46,139.21 60.46,167.92 58.62,169.76 58.62,174.66 60.87,176.91 v5(60.87,177.2)
  BOTTOM w0.102: XDPC1.57 41.07,121.51 40.84,121.27 40.84,120 41.27,119.57 v2(42.61,119.57) ; v2(110.53,74.13) 110.31,73.9 108.33,73.9 108.18,73.75 102.72,73.75 102.09,74.38 94.84,74.38 92.2,71.74 78.19,71.74 76.67,70.22 v3(76.14,70.22) 75.58,70.22 v2(75.02,70.78)
H_TDI: length 85.9
  TOP w0.102: R80242.2 32.09,117.28 33.19,117.28 33.37,117.11 R43.1 34.23,116.83 34.82,117.41 v2(34.82,117.92) ; CPU1.G12 v5(61.78,178.11)
  L4 w0.127: v2(39.45,122.4) 39.95,122.4 41.69,124.13 41.69,126.85 43.68,128.84 44.88,128.84 46.48,130.44 47.29,130.44 50.36,133.51 50.36,134.37 51.15,135.15 52.15,135.15 57.13,140.13 57.13,147 57.14,147.01 57.14,148.35 57.83,149.04 57.83,165.42 56.33,166.91 56.33,176.81 57.8,178.28 60.4,178.28 60.66,178.53 61.17,178.53 61.59,178.11 v5(61.78,178.11)
  BOTTOM w0.102: v2(34.82,117.92) 34.82,118.02 33.88,118.96 v3(33.88,119.32) 33.88,119.89 34.66,120.68 34.66,121.55 35.12,122.01 XDPC1.56 39.06,122.01 v2(39.45,122.4)
H_TDO: length 105.3
  TOP w0.102: v2(39.46,123.45) 37.43,123.45 v1(36.47,122.49) 36.24,122.26 34.77,122.26 34.29,121.78 R79769.1 ; R14.2 37.73,144.52 R40.1 38.85,144.96 39.78,144.96 40.63,144.11 43,144.11 47.5,148.6 54.65,148.6 55.31,147.94 v2(55.43,147.94) ; CPU1.H13 v5(62.7,179.03)
  L4 w0.127: v2(39.46,123.45) 39.95,123.45 41.18,124.68 41.18,127.06 43.47,129.35 44.67,129.35 46.29,130.97 47.1,130.97 49.76,133.64 49.76,135.28 55.43,140.95 v2(55.43,147.94) 55.43,149.32 56.3,150.2 56.3,165.02 55.11,166.21 55.11,177.74 58.64,181.27 61.04,181.27 61.36,180.95 61.36,180.68 61.61,180.43 61.88,180.43 62.2,180.11 62.2,179.52 v5(62.7,179.03)
  BOTTOM w0.102: XDPC1.52 38.43,123.01 38.87,123.45 v2(39.46,123.45)
H_TMS: length 90.5
  TOP w0.102: v2(57.08,148.95) 57.08,148.95 57.35,149.21 58.74,149.21 61.03,146.93 R44.1 ; v5(58.97,179.03) 59.07,178.94 59.65,178.94 59.71,178.88 60.2,178.88 60.26,178.94 60.78,178.94 CPU1.F13
  L4 w0.127: v5(58.97,179.03) 58.57,178.62 57.82,178.62 56.1,176.91 56.1,166.82 57.57,165.35 57.57,149.45 v2(57.08,148.95) 57.08,148.64 56.88,148.44 56.88,140.24 52.04,135.41 51.04,135.41 50.02,134.38 50.02,133.53 47.21,130.72 46.4,130.72 44.77,129.09 43.58,129.09 41.43,126.95 41.43,124.24 40.09,122.89 39.28,122.89 38.98,122.59 38.98,122.11 39.44,121.65 v2(39.44,121.64)
  BOTTOM w0.102: v5(58.97,179.03) 58.49,178.55 v3(58.49,178.17) ; R80241.2 37.15,116.06 35.38,117.84 35.38,118.43 35.02,118.78 35.02,121.35 35.18,121.51 XDPC1.58 39.29,121.51 39.42,121.64 v2(39.44,121.64)
H_TRST_N: length 101.5
  TOP w0.102: R1789.1 33.57,120.64 v2(34.21,121.27) v1(38.14,121.27) 39.04,121.27 v2(39.44,120.88) ; v5(60.87,178.11) 61.06,178.3 CPU1.F12 ; v2(58.39,147) 55.49,147 54.12,148.37 47.59,148.37 43.1,143.88 40.4,143.88 39.76,144.52 R39.1
  L4 w0.127: v5(60.87,178.11) 60.4,177.64 60.4,177.05 59.87,176.52 59.59,176.52 57.7,174.63 57.7,174.24 57.9,174.05 57.9,166.95 58.86,165.99 58.86,147.47 v2(58.39,147) 57.89,146.5 57.89,138.81 54.06,134.97 52.44,134.97 47.65,130.19 46.58,130.19 44.98,128.59 43.79,128.59 41.94,126.74 41.94,124.03 40.07,122.16 40.07,121.51 v2(39.44,120.88)
  BOTTOM w0.102: XDPC1.54 35.03,122.51 34.21,121.68 v2(34.21,121.27)
H_TRST_N_R: length 198.2
  TOP w0.102: v2(40.47,143.16) 40.03,143.16 39.56,143.63 R39.2 ; v2(149.14,68.92) 149.14,68.92 149.17,68.95 149.2,68.95 149.34,69.08 U2.AY5
  L3 w0.127: v2(40.47,143.16) 40.47,143.06 40.94,142.59 40.94,141.71 44.74,137.91 52.49,137.91 54.42,135.98 55.71,135.98 56.45,136.73 63.08,136.73 64.08,137.73 80.62,137.73 82.87,135.48 91.49,135.48 93.27,137.26 110.03,137.26 123.68,123.62 123.68,119.12 v2(123.5,118.95)
  L4 w0.127: v2(123.5,118.95) 123.6,118.95 124.03,119.38 125.88,119.38 127.17,118.09 127.17,101.23 126.87,100.93 126.87,96.38 126.98,96.26 126.98,88 123.25,84.27 122.17,84.27 119.27,81.37 119.27,78.86 118.52,78.11 118.52,76.06 120.39,74.19 121.83,74.19 122.38,73.64 122.38,68.36 125.86,64.89 126.48,64.89 128.69,62.68 128.69,61.56 v2(128.87,61.38)
  BOTTOM w0.102: v2(149.14,68.92) 148.89,68.92 148.5,68.54 148.5,68.25 148.47,68.22 148.47,67.79 148.53,67.74 148.53,64.96 146.68,63.11 146.47,63.11 145.87,62.51 v3(145.69,62.51) 144.86,61.68 140.57,61.68 140.54,61.66 140.07,61.66 139.3,60.9 129.36,60.9 v2(128.87,61.38)
H_VIDALERT_N: length 5.4
  TOP w0.102: R23.2 35.35,233.54 v1(34.94,233.95) 35.68,234.68 R16.2 R22.2
H_VIDSCK: length 3.7
  TOP w0.152: v1(39.64,235.34) 40.12,235.83 R27.2 R17.2 R25.1
H_VIDSOUT: length 4
  TOP w0.152: R28.1 R18.2 R30.2 40.2,232.4 39.62,231.81 v1(39.62,231.58)
HDD_LED_5V: length 9.4
  TOP w0.305: 38.37,15.66 37.69,15.66 37.42,15.92 PWRCN1.10
  TOP w0.762: R79858.2 44.75,14.54 v1(43.63,14.54) 39.49,14.54 38.37,15.66
HDMI1_CK+: length 147
  TOP w0.089: v2(41.92,32.24) 42.22,32.53 42.76,32.53 42.84,32.45 SCA1.9 ; v2(162.91,14.18) 162.56,14.53 161.74,14.53 161.66,14.46 D5203.4 D5203.7 159.74,14.46 158.8,15.39 157.83,15.39 R5208.2 157.14,15.57 156.39,15.57 156.22,15.39 TR5204.2
  L4 w0.102: v2(162.91,14.18) 162.63,14.46 150.22,14.46 146.72,17.97 145.24,17.97 144.07,19.14 138.46,19.14 133.83,23.78 126.07,23.78 124.84,25.01 117.17,25.01 112.55,29.63 91.75,29.63 86.62,34.76 67.16,34.76 66.19,35.72 60.7,35.72 59.51,34.53 54.55,34.53 53.25,33.23 52.68,33.23 51.81,32.36 51.81,31.25 51.51,30.96 50.96,30.96 50.67,31.25 50.67,32.36 50.56,32.46 50.28,32.46 50.18,32.36 50.18,31.25 49.89,30.96 49.33,30.96 49.04,31.25 49.04,32.36 48.94,32.46 42.15,32.46 v2(41.92,32.24)
  BOTTOM w0.089: v3(42.51,32.4) v2(41.92,32.24)
HDMI1_CK+_C: length 4.9
  TOP w0.089: HDMI2.10 152.3,13.52 152.39,13.61 152.39,13.76 152.48,13.85 152.74,13.85 153.61,14.72 153.61,15.19 153.98,15.56 154.07,15.56 154.24,15.39 TR5204.1
HDMI1_CK-: length 146.7
  TOP w0.089: TR5204.3 156.24,16.07 156.41,15.91 157.33,15.91 R5207.2 157.99,15.73 158.84,15.73 ; v2(162.9,15.1) 162.68,14.88 161.74,14.88 161.66,14.96 D5203.5 D5203.6 159.72,14.96 158.95,15.73 158.84,15.73 ; 158.84,15.73 v1(158.84,16.12) ; SCA1.10 42.84,32.96 42.76,32.88 42.22,32.88 v2(41.92,33.17)
  L4 w0.102: v2(41.92,33.17) 42.31,32.79 49.07,32.79 49.37,32.5 49.37,31.39 49.47,31.29 49.75,31.29 49.85,31.39 49.85,32.5 50.15,32.79 50.7,32.79 51,32.5 51,31.39 51.1,31.29 51.38,31.29 51.48,31.39 51.48,32.5 52.54,33.56 53.11,33.56 54.42,34.86 59.37,34.86 60.57,36.05 66.33,36.05 67.29,35.09 86.76,35.09 91.89,29.96 112.68,29.96 117.31,25.34 124.98,25.34 126.21,24.11 133.96,24.11 138.6,19.47 144.21,19.47 145.37,18.3 146.86,18.3 150.36,14.79 162.6,14.79 v2(162.9,15.1)
HDMI1_CK-_C: length 4.9
  TOP w0.089: HDMI2.12 152.3,14.52 152.39,14.43 152.39,14.28 152.48,14.19 152.6,14.19 153.27,14.86 153.27,15.34 153.84,15.91 154.07,15.91 154.24,16.07 TR5204.4
HDMI1_D0+: length 146.4
  TOP w0.089: SCA1.4 44.93,29.96 45.01,29.88 46.76,29.88 v2(47.06,30.17) ; v2(162.91,12.43) 162.61,12.73 162.08,12.73 161.85,12.96 D5203.1 D5203.10 159.96,12.96 159.47,12.47 158.84,12.47 R5204.2 158.25,12.55 156.1,12.55 TR5202.2
  L4 w0.102: v2(47.06,30.17) 46.72,29.83 46.42,29.83 46.04,29.45 46.04,28.94 46.63,28.36 49.28,28.36 49.57,28.65 49.57,29.14 49.67,29.24 49.95,29.24 50.05,29.14 50.05,28.65 50.35,28.36 50.9,28.36 51.2,28.65 51.2,29.14 51.3,29.24 51.58,29.24 51.68,29.14 51.68,28.65 51.97,28.36 52.53,28.36 52.82,28.65 52.82,29.14 52.92,29.24 53.2,29.24 53.3,29.14 53.3,28.65 53.6,28.36 54.49,28.36 61.04,34.91 65.73,34.91 66.69,33.95 86.28,33.95 91.42,28.82 112.21,28.82 117.14,23.89 124.81,23.89 125.74,22.96 133.39,22.96 138.06,18.3 143.76,18.3 145,17.05 146.32,17.05 150.64,12.74 162.6,12.74 v2(162.91,12.43)
  BOTTOM w0.089: v3(47.62,30.42) v2(47.06,30.17)
HDMI1_D0+_C: length 4
  TOP w0.089: TR5202.1 154.24,12.47 154.07,12.64 153.95,12.64 153.66,12.35 152.48,12.35 152.39,12.26 152.39,12.11 152.3,12.02 HDMI2.7
HDMI1_D0-: length 146.5
  TOP w0.089: TR5202.3 156.27,12.9 158.25,12.9 R5206.2 159.01,12.81 159.33,12.81 159.97,13.46 D5203.9 D5203.2 161.84,13.46 162.22,13.07 162.61,13.07 v2(162.91,13.37) ; SCA1.3 44.93,29.46 45.01,29.53 46.76,29.53 v2(47.06,29.24)
  L4 w0.102: v2(162.91,13.37) 162.6,13.07 150.78,13.07 146.46,17.39 145.14,17.39 143.89,18.63 138.19,18.63 133.53,23.29 125.87,23.29 124.95,24.22 123.77,24.22 123.54,24.44 123.24,24.44 123.01,24.22 122.71,24.22 122.48,24.44 122.18,24.44 121.95,24.22 120.9,24.22 120.67,24.44 120.37,24.44 120.14,24.22 119.84,24.22 119.61,24.44 119.31,24.44 119.08,24.22 118.78,24.22 118.55,24.44 118.25,24.44 118.02,24.22 117.27,24.22 112.35,29.15 91.55,29.15 86.42,34.28 66.83,34.28 65.86,35.24 60.9,35.24 54.35,28.69 53.74,28.69 53.64,28.79 53.64,29.28 53.34,29.57 52.79,29.57 52.49,29.28 52.49,28.79 52.39,28.69 52.11,28.69 52.01,28.79 52.01,29.28 51.71,29.57 51.16,29.57 50.87,29.28 50.87,28.79 50.76,28.69 50.49,28.69 50.38,28.79 50.38,29.28 50.09,29.57 49.54,29.57 49.24,29.28 49.24,28.79 49.14,28.69 46.76,28.69 46.37,29.08 46.37,29.31 46.56,29.5 46.79,29.5 v2(47.06,29.24)
  BOTTOM w0.089: v2(47.06,29.24) v3(46.58,28.87)
HDMI1_D0-_C: length 4
  TOP w0.089: TR5202.4 154.24,13.15 154.07,12.98 153.81,12.98 153.51,12.69 152.48,12.69 152.39,12.78 152.39,12.93 152.3,13.02 HDMI2.9
HDMI1_D1+: length 147.1
  TOP w0.089: TR5203.2 156.32,9.42 156.53,9.64 157.23,9.64 R5203.2 157.95,9.72 158.82,9.72 ; 158.82,9.72 159.37,9.72 160.1,9 D5204.2 D5204.9 161.76,9 161.91,9.15 162.99,9.15 v2(163.21,8.93) ; 158.82,9.72 v1(158.82,9.43) ; SCA1.6 44.93,30.95 45.01,30.88 45.46,30.88 46.15,31.57 46.77,31.57 v2(46.99,31.79)
  L4 w0.102: v2(46.99,31.79) 46.76,31.56 45.86,31.56 45.2,30.91 45.2,28.63 46.29,27.55 54.82,27.55 60.41,33.13 85.95,33.13 91.51,27.57 112.18,27.57 116.93,22.82 124.73,22.82 125.4,22.15 132.99,22.15 139.1,16.04 145.64,16.04 147.47,14.2 150.61,11.06 151.99,9.69 160.52,9.69 161,9.21 162.93,9.21 v2(163.21,8.93)
HDMI1_D1+_C: length 4.7
  TOP w0.089: HDMI2.4 152.3,10.52 152.39,10.61 152.39,10.76 152.48,10.85 153.06,10.85 153.52,10.38 153.52,9.91 153.84,9.59 154.07,9.59 154.24,9.42 TR5203.1
HDMI1_D1-: length 147.4
  TOP w0.089: v2(163.23,9.69) 163.03,9.5 D5204.10 D5204.1 160.08,9.5 159.51,10.06 157.95,10.06 R5205.2 157.07,9.98 156.53,9.98 156.41,10.11 TR5203.3 ; v2(46.99,30.93) 46.99,30.93 46.69,31.23 46.3,31.23 45.6,30.53 45.01,30.53 44.93,30.45 SCA1.5
  L4 w0.102: v2(163.23,9.69) 163.08,9.54 161.14,9.54 160.66,10.02 159.06,10.02 158.84,10.25 158.53,10.25 158.31,10.02 158,10.02 157.78,10.25 157.47,10.25 157.24,10.02 156.94,10.02 156.71,10.25 156.41,10.25 156.18,10.02 155,10.02 154.78,10.25 154.47,10.25 154.25,10.02 152.12,10.02 150.71,11.44 150.71,11.76 150.49,11.97 150.17,11.97 149.95,12.19 149.95,12.51 149.74,12.72 149.42,12.72 145.77,16.37 139.24,16.37 133.12,22.48 125.54,22.48 124.87,23.15 117.07,23.15 112.32,27.9 91.65,27.9 86.08,33.46 60.27,33.46 54.69,27.88 46.43,27.88 45.54,28.77 45.54,30.77 45.99,31.23 46.69,31.23 v2(46.99,30.93)
  BOTTOM w0.089: v2(163.23,9.69) 162.97,9.94 162.92,9.94 v3(162.77,10.1)
HDMI1_D1-_C: length 4.7
  TOP w0.089: HDMI2.6 152.3,11.52 152.39,11.43 152.39,11.28 152.48,11.19 153.2,11.19 153.87,10.53 153.87,10.05 153.98,9.94 154.07,9.94 154.24,10.11 TR5203.4
HDMI1_D2+: length 146.8
  TOP w0.089: TR5201.2 156.54,6.5 156.71,6.67 157.52,6.67 ; v2(162.84,7.29) 162.54,7.59 161.84,7.59 161.74,7.5 D5204.6 D5204.5 160.11,7.5 159.49,6.88 159.17,6.88 R5201.2 158.42,6.67 157.52,6.67 ; v1(157.52,6.29) 157.52,6.67 ; v2(41.47,31) 42.43,31.95 SCA1.8
  L4 w0.102: v2(162.84,7.29) 162.62,7.5 150.79,7.5 149.17,9.13 144.76,9.13 132.56,21.34 123.03,21.34 122.36,22.01 116.53,22.01 110.38,26.76 90.18,26.76 84.61,32.32 60.75,32.32 55.16,26.73 45.95,26.73 44.95,27.74 43.86,27.74 41.66,29.93 41.66,30.8 v2(41.47,31)
HDMI1_D2+_C: length 5.8
  TOP w0.089: TR5201.1 154.24,6.5 154.07,6.67 153.84,6.67 152.89,7.62 152.89,9.03 152.57,9.35 152.48,9.35 152.39,9.26 152.39,9.11 152.3,9.02 HDMI2.1
HDMI1_D2-: length 147
  TOP w0.089: SCA1.7 42.93,31.46 42.77,31.61 42.57,31.61 42.25,31.29 v2(42.25,31) ; TR5201.3 156.54,7.18 156.71,7.02 158.17,7.02 R5202.2 159.01,7.23 159.35,7.23 160.12,7.99 D5204.4 D5204.7 161.87,7.99 161.93,7.93 162.72,7.93 v2(162.84,8.05)
  L4 w0.102: v2(162.84,8.05) 162.62,7.83 154.28,7.83 154.06,8.06 153.75,8.06 153.53,7.83 153.22,7.83 153,8.06 152.69,8.06 152.47,7.83 152.16,7.83 151.94,8.06 151.63,8.06 151.4,7.83 150.93,7.83 149.3,9.46 147.85,9.46 147.62,9.69 147.31,9.69 147.09,9.46 146.78,9.46 146.56,9.69 146.25,9.69 146.03,9.46 144.9,9.46 132.69,21.67 123.17,21.67 122.5,22.34 116.65,22.34 110.49,27.09 90.32,27.09 88.23,29.17 87.48,29.92 87.48,29.92 86.95,30.46 86.73,30.67 86.73,30.99 86.52,31.21 86.2,31.21 84.75,32.65 60.61,32.65 55.02,27.06 46.09,27.06 45.09,28.07 44,28.07 41.99,30.07 41.99,30.74 v2(42.25,31)
  BOTTOM w0.089: v3(42.83,30.8) v2(42.25,31)
HDMI1_D2-_C: length 5.8
  TOP w0.089: HDMI2.3 152.3,10.02 152.39,9.93 152.39,9.78 152.48,9.69 152.71,9.69 153.23,9.17 153.23,7.76 153.98,7.02 154.07,7.02 154.24,7.18 TR5201.4
HDMI1_DATA_IC_N0: length 6.9
  TOP w0.102: C12213.2 166.52,50.89 166.52,50.34 165.27,49.08 164.85,49.08 ; U118.2 162.32,48.6 162.41,48.69 162.41,48.87 162.62,49.08 164.85,49.08 ; 164.85,49.08 v1(164.85,49.48)
HDMI1_DATA_IC_N1: length 4.2
  TOP w0.102: C12211.2 162.68,50.93 162.68,50.81 161.82,49.95 ; 161.82,49.95 161.21,49.34 161.21,48.75 161.12,48.66 U118.5 ; 161.82,49.95 v1(161.54,50.23)
HDMI1_DATA_IC_N2: length 4.4
  TOP w0.102: C12209.2 158.9,50.89 158.9,50.52 158.98,50.44 ; 158.98,50.44 v1(158.73,50.19) ; 158.98,50.44 159.33,50.1 159.63,50.1 160.41,49.32 160.41,48.75 160.32,48.66 U118.7
HDMI1_DATA_IC_N3: length 7
  TOP w0.102: v1(154.93,50.02) 155.2,50.29 ; 155.2,50.29 156.13,49.36 158.9,49.36 159.21,49.04 159.21,48.75 159.12,48.66 U118.10 ; 155.2,50.29 154.96,50.52 154.96,50.89 C12215.2
HDMI1_DATA_IC_P0: length 6.8
  TOP w0.102: 166.39,49.9 165.36,48.86 162.71,48.86 162.63,48.78 162.63,48.68 162.72,48.59 U118.1 ; 166.39,49.9 v1(166.67,49.62) ; 166.39,49.9 166.74,50.25 166.74,50.89 C12212.2
HDMI1_DATA_IC_P1: length 4.2
  TOP w0.102: U118.4 161.52,48.67 161.43,48.76 161.43,49.25 162.61,50.44 ; 162.61,50.44 162.95,50.77 162.95,50.91 C12210.2 ; 162.61,50.44 v1(162.88,50.16)
HDMI1_DATA_IC_P2: length 4.4
  TOP w0.102: U118.6 160.72,48.66 160.63,48.75 160.63,49.41 159.92,50.12 ; C12208.2 159.12,50.89 159.12,50.61 159.42,50.32 159.72,50.32 159.92,50.12 ; v1(160.2,50.41) 159.92,50.12
HDMI1_DATA_IC_P3: length 7
  TOP w0.102: U118.9 159.52,48.66 159.43,48.75 159.43,49.13 158.98,49.58 156.62,49.58 ; v1(156.62,49.99) 156.62,49.58 ; 156.62,49.58 156.22,49.58 155.18,50.61 155.18,50.89 C12214.2
HDMI1_SCL: length 159.3
  TOP w0.102: R9546.1 41.09,22.86 41.09,20.31 41.22,20.18 v2(41.22,20.31) ; R9534.2 46.46,18.63 R9533.2 45.47,18.46 v2(45.41,18.53) ; R80062.1 v2(146.31,26.21)
  L3 w0.127: v2(45.41,18.53) 44.77,17.89 42.21,17.89 40.96,19.14 40.96,20.05 v2(41.22,20.31) 40.88,20.64 40.88,24.82 40.23,25.47 40.23,32.86 41.09,33.72 41.09,39.24 41.31,39.45 41.31,45.04 41.63,45.36 42.66,45.36 44.14,46.84 44.14,48.63 v2(44.52,49.01)
  L4 w0.127: v2(146.31,26.21) 137.97,26.21 136.83,27.35 130.77,27.35 129.31,28.82 122.88,28.82 118.38,33.31 116.79,33.31 109.92,40.17 109.92,41.57 103.87,47.62 101.61,47.62 100.93,48.31 99.65,48.31 98.99,47.66 64.81,47.66 61.71,50.76 49.58,50.76 48.76,49.95 46.2,49.95 45.27,49.01 v2(44.52,49.01)
  BOTTOM w0.102: v3(145.74,25.64) v2(146.31,26.21)
HDMI1_SCL_C: length 8.6
  TOP w0.102: 149.32,25.32 149.51,25.13 R5210.2 ; 149.32,25.32 v2(149.32,25.27) ; 149.32,25.32 C12219.1 R80062.2 R5213.2 144.66,25.32 143.58,24.24 143.07,24.24
  BOTTOM w0.102: v2(149.32,25.27) 149.56,25.51 v3(150.18,25.51)
HDMI1_SDA: length 164.7
  TOP w0.102: v2(40.4,20.3) 40.58,20.47 R9536.1 ; v2(47.95,16.45) 47.17,16.45 R9532.2 47.12,17.31 R9535.2 ; R80061.1 v2(146.32,23.29)
  L3 w0.127: v2(45.36,16.78) 44.5,17.64 42.11,17.64 40.71,19.04 40.71,19.99 v2(40.4,20.3) 40.4,24.94 39.98,25.37 39.98,32.96 40.84,33.82 40.84,39.34 41.05,39.56 41.05,45.15 42.33,46.43 42.55,46.43 42.87,46.74 42.87,48.74 43.73,49.6 v2(44.02,49.6)
  L4 w0.127: v2(45.36,16.78) 45.69,16.45 v2(47.95,16.45) ; v2(146.32,23.29) 146.78,23.75 146.78,26.41 145.86,27.33 137.22,27.33 136.94,27.61 130.88,27.61 129.42,29.07 123.01,29.07 118.51,33.56 116.89,33.56 110.18,40.28 110.18,41.68 103.98,47.88 101.72,47.88 101.03,48.56 99.54,48.56 98.89,47.91 64.92,47.91 61.81,51.01 46.78,51.01 45.37,49.6 v2(44.02,49.6)
  BOTTOM w0.102: v3(145.81,23.93) 145.81,23.8 v2(146.32,23.29)
HDMI1_SDA_C: length 8.5
  TOP w0.102: 143.07,22.97 143.58,22.97 144.79,24.18 R5214.2 R80061.2 C12218.1 v2(149.32,24.18) 150.06,24.18 R5211.2
  BOTTOM w0.102: v2(149.32,24.18) 149.23,24.18 v3(148.66,24.75)
HDMI_5V: length 35.2
  TOP w0.305: v2(149.17,18.53) 149.17,18.4 150.05,17.52 HDMI2.18
  TOP w0.508: D5201.1 154.31,19.36 v2(153.1,20.56) ; v2(149.17,18.53) 145.99,18.53 143.01,15.54 142.31,15.54 C12216.1 142.12,15.35 R5218.1 ; R80225.1 157.68,26.97 D5202.3 155.64,25.5 154.87,26.28 153.95,26.28 153.1,27.12 v2(153.1,27.16)
  L3 w0.508: v2(153.1,27.16) v2(153.1,20.56) 151.96,20.56 149.93,18.53 v2(149.17,18.53)
  BOTTOM w0.508: v3(153.1,28.08) v2(153.1,27.16)
HDMI_DET_SIO: length 8
  TOP w0.102: R7916.2 109.61,45.39 109.8,45.2 109.8,44.31 110,44.11 Q7903.D 110.6,46.43 v1(110.56,46.47) 110.56,47.04 109.78,47.82 U109.108
HDMI_HDCP_READY: length 178.2
  TOP w0.102: SCA1.114 35.51,28.69 35.68,28.85 35.68,28.88 35.88,29.08 35.88,30.39 36.34,30.85 38.04,30.85 v2(38.17,30.97) ; v2(140.81,12.2) 141.27,12.2 U5202.1 141.79,13.44 141.23,13.99 R5218.2 141.23,15.48 R5219.1
  L3 w0.127: v2(140.81,12.2) 139.35,13.66 139.35,17.95 140.55,19.15 149.37,19.15 151.33,21.1 151.33,26.02 v2(151.58,26.28) ; v2(43.05,49.58) 43.05,49.55 42.58,49.08 42.58,48.05 41.42,46.89 41.42,45.88 41.15,45.6 40.73,45.6 39.88,44.76 39.88,39.6 40.39,39.09 40.39,33.74 39.72,33.07 39.72,32.53 v2(38.17,30.97)
  L4 w0.127: v2(43.05,49.58) 43.33,49.58 43.82,50.07 45.43,50.07 46.63,51.27 61.92,51.27 65.02,48.16 98.78,48.16 99.44,48.82 101.14,48.82 101.82,48.13 104.08,48.13 110.43,41.78 110.43,40.39 117,33.82 123.98,33.82 126.84,30.96 127.89,30.96 130.98,27.86 137.04,27.86 137.32,27.58 150.27,27.58 v2(151.58,26.28)
  BOTTOM w0.102: v3(140,12.2) v2(140.81,12.2)
HDMI_HPDET: length 13.2
  TOP w0.102: HDMI2.19 151.15,18.7 150.77,19.09 142.99,19.09 141.8,17.89 v2(141.8,17.64) 141.29,17.13 R5219.2
  BOTTOM w0.102: v3(141.8,18.45) v2(141.8,17.64)
HDMI_IN_DET#_R: length 3.6
  TOP w0.102: R7917.1 113.61,45.83 112.97,46.47 v1(112.34,46.47) 112.08,46.21 112.08,45.51 Q7903.S
HDMI_LANE0_DN: length 17.1
  TOP w0.102: 163.35,35.94 162.47,35.05 162.31,35.05 162.1,34.84 162.1,34.68 161.88,34.46 161.72,34.46 161.51,34.25 161.51,34.09 161,33.58 160.84,33.58 160.63,33.37 160.63,33.21 160.41,32.99 160.25,32.99 160.04,32.78 160.04,32.62 159.82,32.4 155.5,32.4 155.37,32.54 U28.2 U28.9 153.3,32.54 153.17,32.4 152.98,32.4 152.75,32.63 152.5,32.63 152.4,32.73 152.4,32.92 152.3,33.02 HDMI1.3 ; 163.35,35.94 v1(163.09,36.2) ; 163.35,35.94 164.3,36.88 164.3,37.32 164.07,37.56 TR16.2
HDMI_LANE0_DP: length 17.1
  TOP w0.102: 160.96,33.24 164.52,36.79 164.52,37.26 164.75,37.5 TR16.3 ; 160.96,33.24 v1(161.2,33) ; 160.96,33.24 159.91,32.19 155.5,32.19 155.37,32.06 U28.1 U28.10 153.3,32.06 153.17,32.19 152.89,32.19 152.66,32.41 152.5,32.41 152.4,32.31 152.4,32.12 152.3,32.02 HDMI1.1
HDMI_LANE0_IC_DN: length 5.7
  TOP w0.102: TR16.1 164.07,39.12 164.3,39.36 164.3,40.25 ; 164.3,40.25 164.3,40.89 163.12,42.06 162.67,42.06 162.41,42.31 162.41,42.62 162.32,42.71 U118.29 ; 164.3,40.25 v1(163.95,40.25)
HDMI_LANE0_IC_DP: length 5.7
  TOP w0.102: U118.30 162.72,42.7 162.63,42.61 162.63,42.4 162.76,42.28 163.21,42.28 164.15,41.34 ; v1(164.41,41.59) 164.15,41.34 ; 164.15,41.34 164.52,40.98 164.52,39.33 164.75,39.1 TR16.4
HDMI_LANE1_DN: length 15
  TOP w0.102: HDMI1.6 152.3,34.52 152.4,34.42 152.4,34.23 152.5,34.13 152.8,34.13 153,33.93 153.17,33.93 153.3,34.06 U28.6 U28.5 155.37,34.06 155.5,33.93 156.22,33.93 156.34,34.04 156.64,34.04 156.75,33.93 157.06,33.93 157.17,34.04 157.47,34.04 157.58,33.93 157.89,33.93 158,34.04 158.31,34.04 158.42,33.93 160.2,33.93 160.49,34.22 160.81,34.54 ; 160.81,34.54 v1(160.53,34.82) ; 160.81,34.54 161.29,35.02 161.29,35.18 161.51,35.4 161.67,35.4 162.14,35.87 162.14,37.32 161.91,37.56 TR17.2
