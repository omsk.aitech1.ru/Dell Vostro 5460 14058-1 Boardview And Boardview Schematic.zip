# Allegro board 14058-1.0623WZS1658.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MDA4: length 22.1
  TOP w0.127: v5(75.73,102.2) 75.73,102.21 75.73,102.22 76.12,102.61 GPU1.D20 ; VRAM2.H3 68.29,88.68 v5(67.5,88.68)
  L3 w0.102: v5(75.73,102.2) 75.73,102.04 75.32,101.64 75.32,100.2 75.07,99.94
  L3 w0.165: v5(67.5,88.68) 68.95,88.68 69.78,89.51 69.78,91.49 69.77,91.49 69.77,92.12 70.51,92.85 70.51,92.85 71.26,93.6 71.26,95.47 72.49,96.7 74.25,96.7 74.92,97.37 74.92,99.8 75.07,99.94
  BOTTOM w0.127: v5(67.5,88.68) 68.29,88.68 VRAM2.H3
MDA5: length 18.7
  TOP w0.127: v5(74.87,102.23) 74.89,102.23 GPU1.D21 ; VRAM2.E3 v5(69.07,91.09)
  L3 w0.102: v5(74.87,102.23) 74.45,101.81 73.92,101.81 73.25,101.14 73.25,99.93 73.62,99.56 73.62,99.42
  L3 w0.165: 73.62,99.42 73.62,98.98 69.89,95.25 69.21,95.25 68.85,94.89 68.85,92.65 69.23,92.26 69.23,91.86 69.1,91.73 68.06,91.73 67.93,91.6 67.93,91.32 68.16,91.09 v5(69.07,91.09)
  BOTTOM w0.127: VRAM4.F7 68.69,90.69 69.07,91.07 v5(69.07,91.09)
MDA6: length 22.3
  TOP w0.127: GPU1.F20 76.12,104.21 v5(75.71,103.8) ; v5(68.31,89.47) 68.3,89.47 67.89,89.88 VRAM2.G2
  L3 w0.102: 74.5,100.26 74.5,101.24 75.3,102.05 75.3,103.69 75.4,103.8 v5(75.71,103.8)
  L3 w0.165: v5(68.31,89.47) 68.57,89.22 69.03,89.22 69.51,89.7 69.51,89.95 69.26,90.21 69.26,90.51 69.51,90.77 69.51,91.37 69.51,91.38 69.51,92.37 69.11,92.76 69.11,93.46 69.24,93.58 69.66,93.58 69.79,93.71 69.79,94.53 72.86,97.6 73.24,97.6 73.65,97.19 74.11,97.19 74.54,97.62 74.54,99.93 74.5,99.98 74.5,100.26
  BOTTOM w0.127: VRAM4.H8 67.9,89.08 68.29,89.47 v5(68.31,89.47)
MDA7: length 21.7
  TOP w0.127: v5(68.29,90.31) 68.26,90.31 VRAM2.F2 ; GPU1.E21 75.22,103.42 74.84,103.8 v5(74.84,103.9)
  L3 w0.102: 73.65,102.68 73.65,103.36 73.77,103.49 74.72,103.49 74.84,103.62 v5(74.84,103.9)
  L3 w0.165: v5(68.29,90.31) 67.05,91.55 67.05,94.42 67.73,95.1 68.12,95.1 68.74,95.73 69.8,95.73 72.69,98.63 72.69,99.41 72.86,99.57 72.86,101.35 73.25,101.74 73.45,101.74 73.75,102.04 74.16,102.04 74.31,102.19 74.31,102.47 74.18,102.6 73.72,102.6 73.65,102.68
  BOTTOM w0.127: v5(68.29,90.31) 68.26,90.31 VRAM2.F2
MDA8: length 20
  TOP w0.127: v5(79.84,103.01) 79.85,103.02 79.85,103.03 GPU1.E15 ; VRAM1.F2 81.92,90.68 82.31,91.07 82.32,91.07 v5(82.32,91.08)
  L3 w0.165: v5(79.84,103.01) 79.8,102.96 79.8,99.17 80.07,98.89 80.43,98.89 80.56,98.77 80.56,98.28 80.43,98.16 80.18,98.16 79.96,97.94 79.96,95.43 80.13,95.26 81.12,95.26 81.28,95.1 81.28,94.7 81.16,94.58 80.09,94.58 79.96,94.45 79.96,93.53 80.09,93.41 80.94,93.41 81.07,93.28 81.07,92.37 81.19,92.24 81.34,92.24 81.34,92.24 81.75,92.24 81.88,92.11 81.88,91.76 81.75,91.63 81.42,91.63 81.29,91.5 81.29,91.15 81.42,91.02 82.26,91.02 v5(82.32,91.08)
  BOTTOM w0.127: v5(82.32,91.08) 81.92,90.68 VRAM1.F2
MDA9: length 19.1
  TOP w0.127: v5(79.03,102.18) 79.08,102.23 79.85,102.23 GPU1.D15 ; v5(81.52,89.48) 81.91,89.88 VRAM1.G2
  L3 w0.165: v5(79.03,102.18) 78.58,101.73 78.58,101.14 78.98,100.74 78.98,98.67 79.15,98.5 79.15,92.9 79.92,92.13 79.92,89.73 80.2,89.45 80.74,89.45 80.86,89.32 80.86,88.96 80.99,88.83 81.75,88.83 81.88,88.96 81.88,89.36 81.75,89.48 v5(81.52,89.48)
  BOTTOM w0.127: VRAM3.H8 81.92,89.11 81.54,89.48 v5(81.52,89.48)
MDA10: length 21.4
  TOP w0.127: v5(79.83,103.84) 79.87,103.84 80.24,104.21 GPU1.F15 ; v5(83.5,89.46) 83.13,89.08 VRAM1.H3
  L3 w0.102: 79.47,102.03 79.47,102.76 79.43,102.79 79.43,103.45 v5(79.83,103.84)
  L3 w0.165: v5(83.5,89.46) 83.5,89.9 83.38,90.03 83.38,90.38 83.25,90.51 82.79,90.51 82.67,90.38 82.67,90.08 82.54,89.95 82.11,89.95 81.98,90.08 81.98,90.61 81.85,90.74 81.21,90.74 80.96,90.99 80.96,91.82 80.76,92.02 80.76,92.75 80.64,92.87 79.68,92.87 79.56,93 79.56,98.63 79.4,98.8 79.4,101.21 79.47,101.28 79.47,102.03
  BOTTOM w0.127: VRAM1.H3 83.13,89.08 v5(83.5,89.46)
MDA11: length 23
  TOP w0.127: VRAM1.E3 82.79,91.48 v5(83.21,91.06) ; GPU1.F13 81.98,104.2 81.99,104.2 82.36,103.83 v5(82.36,103.83)
  L3 w0.102: 80.2,102.19 80.2,102.55 80.26,102.61 80.26,103.95 80.5,104.19 81.36,104.19 81.72,103.83 v5(82.36,103.83)
  L3 w0.165: 80.2,102.19 80.2,99.43 80.33,99.3 80.68,99.3 80.96,99.02 80.96,98.44 81.4,98 82.21,98 82.47,97.75 82.47,96.62 82.3,96.46 80.57,96.46 80.41,96.29 80.41,95.93 80.57,95.77 82.59,95.77 82.76,95.6 82.76,91.51 v5(83.21,91.06)
  BOTTOM w0.127: VRAM3.F7 82.83,90.68 v5(83.21,91.06)
MDA12: length 21.8
  TOP w0.127: v5(85.05,89.01) 85.12,89.08 VRAM1.H7 ; v5(82.33,101.4) 81.92,101.81 GPU1.C13
  L3 w0.165: v5(85.05,89.01) 86.63,90.59 86.63,92.04 86.5,92.16 86.01,92.16 85.88,92.29 85.88,95.66 86.17,95.95 86.17,96.92 86.34,97.08 87.43,97.08 87.67,97.32 87.67,98.9 87.51,99.07 86.34,99.07 86.17,99.23 86.17,100.19 85.48,100.88 83.09,100.88 82.57,101.4 v5(82.33,101.4)
  BOTTOM w0.127: VRAM1.H7 85.12,89.08 v5(85.05,89.01)
MDA13: length 19.7
  TOP w0.127: v5(82.32,100.61) 81.92,101.01 GPU1.B13 ; VRAM1.F7 85.92,90.69 85.59,91.02 v5(85.46,91.02)
  L3 w0.165: v5(82.32,100.61) 82.74,100.61 82.87,100.48 82.87,100.01 83,99.88 83.45,99.88 83.58,100.01 83.58,100.35 83.71,100.47 85.31,100.47 85.66,100.12 85.66,99.81 85.54,99.68 84.52,99.68 84.41,99.57 84.41,99.05 84.53,98.92 84.72,98.92 85.76,97.88 85.76,96.12 85.59,95.94 85.59,93.89 85.33,93.64 85.33,93.2 85.59,92.95 85.59,92.49 85.46,92.37 85.23,92.37 85.1,92.24 85.1,91.86 85.23,91.73 86.23,91.73 86.36,91.6 86.36,91.24 86.23,91.11 85.55,91.11 v5(85.46,91.02)
  BOTTOM w0.127: v5(85.46,91.02) 85.49,91.02 85.92,91.45 VRAM3.E3
MDA14: length 20.8
  TOP w0.127: v5(82.32,103.01) 81.92,103.41 GPU1.E13 ; VRAM1.H8 87.11,89.47 v5(87.11,89.48)
  L3 w0.165: v5(87.11,89.48) 88.62,90.98 88.62,99.14 88.56,99.19 88.56,99.2 87.88,99.89 87.88,101.53 87.71,101.69 83.64,101.69 v5(82.32,103.01)
  BOTTOM w0.127: v5(87.11,89.48) 86.72,89.87 VRAM3.G2
MDA15: length 21.4
  TOP w0.127: VRAM1.F8 86.72,90.68 v5(87.12,91.08) ; GPU1.D13 81.92,102.61 82.32,102.21 v5(82.34,102.21)
  L3 w0.165: v5(82.34,102.21) 83.26,101.29 86.47,101.29 86.88,100.87 86.88,99.69 87.05,99.53 87.7,99.53 88.18,99.05 88.18,96.75 88.02,96.58 87.29,96.58 86.73,96.58 86.6,96.45 86.6,96.07 86.73,95.95 87.57,95.95 87.69,95.82 87.69,95.52 87.57,95.39 86.97,95.39 86.81,95.22 86.81,94.89 86.97,94.73 87.43,94.73 87.56,94.6 87.56,91.52 v5(87.12,91.08)
  BOTTOM w0.127: v5(87.12,91.08) 86.72,90.68 VRAM1.F8
MDA16: length 18.8
  TOP w0.127: v5(86.32,93.48) VRAM1.C8 ; GPU1.B15 80.27,101.02 80.95,100.34 80.95,100.32 81.41,99.86 81.55,99.86 82.2,99.21 82.2,98.78 82.46,98.51 83.38,98.51 84.3,97.59 84.3,97.24 v1(84.14,97.09) 84.04,96.99 83.58,96.99 83.41,97.15 83.41,97.45 82.94,97.92 v5(82.94,97.93)
  L4 w0.165: v5(86.32,93.48) 85.98,93.48 85.82,93.64 85.82,98.07 85.65,98.23 85.3,98.23 85.14,98.07 85.14,97.43 84.97,97.27 84.64,97.27 84.48,97.43 84.48,98.07 84.31,98.23 83.25,98.23 v5(82.94,97.93)
  BOTTOM w0.127: VRAM1.C8 v5(86.32,93.48)
MDA17: length 16.9
  TOP w0.127: VRAM1.D7 86.31,92.67 v5(86.32,92.68) ; GPU1.C16 79.85,101.41 79.85,100.91 80.18,100.58 80.39,100.58 80.72,100.24 80.72,100.23 81.37,99.58 81.51,99.58 81.93,99.16 81.93,98.68 82.51,98.09 82.51,97.72 v5(82.97,97.27)
  L4 w0.165: v5(86.32,92.68) 86.32,91.64 86.16,91.48 85.55,91.48 85.39,91.64 85.39,96.18 84.69,96.87 83.36,96.87 v5(82.97,97.27)
  BOTTOM w0.127: VRAM3.C3 86.31,92.68 v5(86.32,92.68)
MDA18: length 17.3
  TOP w0.127: v5(82.62,99.12) 82.61,99.12 82.61,99.27 81.92,99.97 GPU1.A13 ; v5(86.32,94.28) 86.72,93.88 VRAM1.B8
  L4 w0.165: v5(86.32,94.28) 86.86,93.74 87.46,93.74 87.62,93.9 87.62,94.94 87.46,95.1 87.08,95.1 86.91,95.27 86.91,95.6 87.08,95.76 87.46,95.76 87.62,95.93 87.62,96.26 87.46,96.42 87.08,96.42 86.91,96.59 86.91,96.92 87.08,97.08 87.46,97.08 87.62,97.25 87.62,97.58 87.46,97.74 87.08,97.74 86.91,97.91 86.91,99.71 86.66,99.96 85.31,99.96 84.47,99.12 v5(82.62,99.12)
  BOTTOM w0.127: VRAM3.A2 v5(86.32,94.28)
MDA19: length 17.8
  TOP w0.127: GPU1.A15 80.24,100.09 81.08,99.25 81.24,99.25 v5(81.45,99.05) ; VRAM1.A7 86.32,95.08 v5(86.32,95.11)
  L4 w0.165: v5(86.32,95.11) 86.32,98.52 86.16,98.68 82.84,98.68 82.44,98.28 80.9,98.28 80.74,98.45 80.74,100.79 80.9,100.95 81.69,100.95 81.86,100.79 81.86,99.46 v5(81.45,99.05)
  BOTTOM w0.127: v5(86.32,95.11) 86.32,95.08 VRAM1.A7
MDA20: length 17.2
  TOP w0.127: GPU1.B18 77.76,100.87 78.33,100.3 78.33,99.27 79.32,98.29 79.32,98.03 v1(79.14,97.85) 78.42,97.85 v5(78.22,98.06) ; v5(82.31,95.06) 82.34,95.06 VRAM1.A3
  L4 w0.165: v5(82.31,95.06) 82.11,95.26 80.37,95.26 80.21,95.43 80.21,96.43 79.44,97.19 79.44,97.93 80.03,98.51 80.03,100.1 79.86,100.27 79.36,100.27 79.19,100.1 79.19,98.51 78.73,98.06 v5(78.22,98.06)
  BOTTOM w0.127: VRAM1.A3 82.34,95.06 v5(82.31,95.06)
MDA21: length 15.7
  TOP w0.127: GPU1.A18 77.97,100.01 77.97,98.77 77.46,98.26 77.46,96.4 77.67,96.2 v1(77.82,96.2) 78.2,96.2 78.4,96.4 78.4,97.09 v5(78.2,97.29) ; VRAM1.A2 v5(82.32,94.28)
  L4 w0.165: v5(82.32,94.28) 81.72,94.88 79.41,94.88 79.24,95.05 79.24,95.38 79.41,95.54 79.56,95.54 79.72,95.71 79.72,96.25 79.22,96.76 79.02,96.76 78.86,96.59 78.86,96.12 78.69,95.96 78.47,95.96 78.2,96.23 v5(78.2,97.29)
  BOTTOM w0.127: v5(82.32,94.28) VRAM3.B8
MDA22: length 16.7
  TOP w0.127: GPU1.A19 76.96,99.45 v5(77.46,98.94) ; VRAM1.C3 83.15,92.64 v5(83.2,92.64)
  L4 w0.165: v5(83.2,92.64) 82.77,92.21 82.77,90.9 82.5,90.64 82.14,90.64 80.99,91.79 80.99,92.3 77.35,95.94 77.35,98.83 v5(77.46,98.94)
  BOTTOM w0.127: VRAM3.D7 83.08,92.64 v5(83.2,92.64) ; v5(77.46,98.94) 77.46,98.64 v3(77.06,98.23)
MDA23: length 15.5
  TOP w0.127: v5(77.47,99.59) 77.35,99.71 77.35,101.43 GPU1.C19 ; VRAM1.C2 v5(82.32,92.68)
  L4 w0.165: v5(77.47,99.59) 78.64,99.59 78.81,99.43 78.81,98.87 78.64,98.7 78.01,98.7 77.73,98.43 77.73,96.14 79.47,94.4 80.6,94.4 80.97,94.02 80.97,93.4 81.25,93.13 81.87,93.13 v5(82.32,92.68)
  BOTTOM w0.127: VRAM1.C2 v5(82.32,92.68)
MDA24: length 15.3
  TOP w0.127: v5(67.49,93.48) 67.89,93.08 VRAM2.C2 ; v5(72.39,100.62) 72.78,101 GPU1.B24
  L4 w0.165: v5(67.49,93.48) 67.49,93.65 67.05,94.1 67.05,95.03 66.2,95.88 66.2,99 67.1,99.9 69.29,99.9 70.28,100.88 71.13,100.88 71.26,100.75 71.26,100.38 71.39,100.26 72.03,100.26 v5(72.39,100.62)
  BOTTOM w0.127: v5(67.49,93.48) 67.89,93.08 VRAM2.C2
MDA25: length 17.8
  TOP w0.127: v5(73.16,99.22) 73.14,99.24 73.14,101.33 GPU1.C23 ; VRAM2.C3 68.3,92.69 v5(68.29,92.69)
  L4 w0.165: v5(68.29,92.69) 68.58,92.98 68.85,92.98 69.08,93.2 69.08,93.89 69.57,94.38 69.57,94.38 69.83,94.63 69.83,94.64 69.86,94.67 69.86,95.36 69.74,95.49 69.38,95.49 69.04,95.83 68.37,95.83 68.24,95.96 68.24,96.57 68.37,96.7 69.05,96.7 69.24,96.89 69.74,96.89 69.86,97.01 69.86,97.78 69.99,97.9 71.14,97.9 71.62,98.38 71.62,98.89 71.74,99.02 72.96,99.02 v5(73.16,99.22)
  BOTTOM w0.127: v5(73.16,99.22) 73.16,99.18 72.54,98.56 72.54,98.36 v3(72.51,98.33) ; VRAM4.D7 68.69,92.29 v5(68.29,92.69)
MDA26: length 14.9
  TOP w0.127: v1(71.11,97.65) 71.11,98.48 v5(70.98,98.61) 70.98,98.91 71.98,99.91 GPU1.A25 ; v5(69.39,94.81) 68.82,94.81 VRAM2.A3
  L4 w0.165: v5(69.39,94.81) 69.27,94.81 68.52,95.57 67.6,95.57 67.48,95.69 67.48,97.09 67.6,97.22 69.33,97.22 69.46,97.34 69.46,97.98 69.33,98.11 68.97,98.11 68.85,98.23 68.85,98.94 68.97,99.06 70.89,99.06 70.98,98.97 v5(70.98,98.61)
  BOTTOM w0.127: VRAM2.A3 69.25,94.68 v5(69.39,94.81)
MDA27: length 14.7
  TOP w0.127: GPU1.A24 72.78,100.2 72.25,99.67 v5(72.25,99.55) ; VRAM2.A2 67.9,94.68 v5(68.29,94.29)
  L4 w0.165: v5(72.25,99.55) 72.17,99.47 67.15,99.47 67.02,99.34 67.02,98.69 67.15,98.56 68.06,98.56 68.19,98.44 68.19,97.9 68.06,97.78 67.58,97.78 67.04,97.24 67.04,95.62 68.29,94.37 v5(68.29,94.29)
  BOTTOM w0.127: v5(68.29,94.29) 68.29,94.28 VRAM4.B8
MDA28: length 17.7
  TOP w0.127: GPU1.A21 75.28,99.42 75.27,99.4 75.25,99.4 75.13,99.27 75.13,98.92 75,98.79 71.72,98.79 71.6,98.67 71.6,98.39 71.72,98.26 75.58,98.26 75.71,98.13 75.71,97.34 75.58,97.22 75.2,97.22 75.04,97.06 v1(74.5,97.06) v5(73.91,97.65) ; VRAM2.B8 72.69,93.9 72.32,94.26 v5(72.28,94.26)
  L4 w0.165: v5(73.91,97.65) 73.91,95.92 73.22,95.24 73.22,95.2 v5(72.28,94.26)
  BOTTOM w0.127: VRAM4.A2 72.28,94.27 v5(72.28,94.26)
MDA29: length 18.5
  TOP w0.127: VRAM2.A7 71.89,95.33 v5(72.1,95.54) ; v5(73.04,97.17) 73.04,96.51 72.91,96.38 72.25,96.38 72.12,96.51 72.12,97.67 72.25,97.8 73.31,97.8 73.46,97.65 73.46,97.46 73.48,97.45 73.48,96.16 73.64,96 74.64,96 74.77,96.12 74.77,96.4 75.15,96.79 76.32,96.79 76.44,96.91 v1(76.44,97.72) 76.44,98.28 76.32,98.41 76.01,98.41 75.67,98.75 75.67,100.44 75.28,100.83 GPU1.B21
  L4 w0.165: v5(73.04,97.17) 73.04,95.74 72.84,95.54 v5(72.1,95.54)
  BOTTOM w0.127: VRAM2.A7 71.89,95.33 v5(72.1,95.54)
MDA30: length 20
  TOP w0.127: v5(75.23,96.15) 75.23,94.8 75.5,94.53 v1(76.85,94.53) 77.47,94.53 77.79,94.86 77.79,95.26 77.05,96 77.05,98.51 76.72,98.84 76.18,98.84 76.03,98.99 76.03,100.52 75.74,100.81 75.74,101.44 GPU1.C20 ; v5(72.29,93.48) 72.69,93.09 VRAM2.C8
  L4 w0.165: v5(72.29,93.48) 72.91,93.48 73.58,94.16 73.58,94.99 74.28,95.69 74.28,96.89 74.41,97.01 75.1,97.01 75.23,96.89 v5(75.23,96.15)
  BOTTOM w0.127: v5(72.29,93.48) 72.69,93.09 VRAM2.C8
MDA31: length 18
  TOP w0.127: GPU1.C21 75.28,101.81 74.88,101.41 74.88,100.64 v5(74.9,100.62) ; v5(71.31,92.17) 71.32,92.17 71.43,92.28 VRAM2.D7
  L4 w0.165: v5(74.9,100.62) 75.23,100.29 75.23,99.02 75.48,98.77 75.48,98.41 75.35,98.28 74.8,98.28 74.67,98.16 74.67,97.6 74.8,97.47 75.54,97.47 75.67,97.34 75.67,95.41 75.81,95.26 75.81,94.68 75.66,94.52 74.55,94.52 73.53,93.5 73.53,92.54 73.4,92.42 72.94,92.42 72.81,92.54 72.81,92.82 72.69,92.95 71.44,92.95 71.31,92.82 v5(71.31,92.17)
  BOTTOM w0.127: v5(71.31,92.17) 71.32,92.17 71.32,92.51 VRAM4.C3
MDA32: length 27.2
  TOP w0.127: VRAM5.H3 59.64,105.85 v5(59.64,105.85) ; GPU1.R22 74.81,112.15 v5(74.81,112.18)
  L3 w0.102: 71.06,113.44 71.67,113.44 71.94,113.17 73.19,113.17 73.8,112.56 74.44,112.56 74.81,112.18 v5(74.81,112.18)
  L3 w0.165: v5(59.64,105.85) 59.64,105.86 59.2,106.3 59.2,107.13 59.32,107.25 59.32,108.23 59.9,108.82 59.9,110.4 60.58,111.07 60.58,111.31 60.21,111.68 60.21,111.89 60.46,112.14 60.68,112.14 61.05,111.77 61.28,111.77 62.67,113.16 62.9,113.16 63.21,112.85 63.39,112.85 63.68,113.14 63.68,113.32 63.37,113.63 63.37,113.86 63.57,114.06 69.61,114.06 70.23,113.44 71.06,113.44
  BOTTOM w0.127: v5(59.64,105.85) 59.64,105.85 VRAM5.H3 ; v3(75.55,111.85) 75.55,111.85 75.53,111.87 75.12,111.87 v5(74.81,112.18)
MDA33: length 21.2
  TOP w0.127: VRAM5.G2 60.03,106.25 v5(59.64,106.65) ; GPU1.R24 72.37,112.17 72.37,112.72 72.13,112.96 v5(71.56,112.96)
  L3 w0.165: v5(59.64,106.65) 59.64,108.11 59.76,108.24 60.18,108.24 60.31,108.37 60.31,110.23 62.53,112.45 63.51,112.45 64.74,113.68 66.05,113.68 66.21,113.52 66.21,113.41 66.38,113.24 66.71,113.24 66.87,113.41 66.87,113.52 67.04,113.68 67.37,113.68 67.53,113.52 67.53,113.41 67.7,113.24 68.03,113.24 68.19,113.41 68.19,113.52 68.36,113.68 69.4,113.68 70,113.07 71.44,113.07 v5(71.56,112.96)
  BOTTOM w0.127: v5(59.64,106.65) VRAM7.H8
MDA34: length 21.7
  TOP w0.127: v5(74,112.14) 74,112.14 74.42,112.56 GPU1.T22 ; VRAM5.E3 61.04,104.85 v5(60.83,104.85)
  L3 w0.165: v5(60.83,104.85) 60.88,104.9 60.88,106.96 61.37,107.45 61.37,108.13 61.89,108.65 61.89,108.82 62.43,109.36 62.43,110.42 63.02,111.02 64.77,111.02 65.75,112 66.13,112 66.54,112.4 68.2,112.4 68.32,112.29 70.83,112.29 70.92,112.2 72.51,112.2 72.98,111.73 73.59,111.73 v5(74,112.14)
  BOTTOM w0.127: VRAM7.F7 60.77,105.45 60.52,105.2 60.52,104.98 60.64,104.85 v5(60.83,104.85)
MDA35: length 24
  TOP w0.127: VRAM5.F2 60.59,106.25 60.44,106.41 v5(60.44,106.65) ; v5(73.16,112.16) 73.46,112.16 73.58,112.05 GPU1.R23
  L3 w0.165: v5(73.16,112.16) 73.37,112.16 73.5,112.29 73.5,112.53 73.14,112.89 72.43,112.89 72.3,112.76 72.3,112.58 72.18,112.46 71.21,112.46 71.04,112.64 68.62,112.64 68.45,112.81 66.36,112.81 65.98,112.43 65.7,112.43 65.53,112.6 65.53,113.1 65.37,113.27 65.04,113.27 64.87,113.1 64.87,112.6 64.71,112.43 64.26,112.43 63.87,112.05 62.7,112.05 61.7,111.05 61.7,110.81 61.95,110.56 61.95,110.33 61.72,110.09 61.49,110.09 61.23,110.34 61,110.34 60.75,110.09 60.75,108.78 61.11,108.43 61.11,107.56 60.78,107.23 60.24,107.23 60.11,107.11 60.11,106.78 60.24,106.65 v5(60.44,106.65)
  BOTTOM w0.127: VRAM5.F2 v5(60.44,106.65)
MDA36: length 26.3
  TOP w0.127: GPU1.N25 71.57,110.49 v5(71.57,110.49) ; VRAM5.H8 59.24,101.44 v5(59.64,101.04)
  L3 w0.102: 67.91,108.56 69.65,108.56 v5(71.57,110.49)
  L3 w0.165: v5(59.64,101.04) 59.24,100.65 58.62,100.65 58.29,100.32 56.43,100.32 56.3,100.44 56.3,101.41 57.22,102.32 57.7,102.32 57.85,102.48 58.64,102.48 58.87,102.25 59.38,102.25 59.73,102.6 61.29,102.6 62.4,103.71 62.4,104.84 62.96,105.41 64.75,105.41 67.91,108.56
  BOTTOM w0.127: VRAM7.G2 60.04,101.45 59.64,101.05 v5(59.64,101.04)
MDA37: length 25.6
  TOP w0.127: v5(59.3,102.93) 59.24,102.87 VRAM5.H7 ; v5(70.78,110.5) 70.78,110.48 GPU1.N26
  L3 w0.102: v5(70.78,110.5) 70.78,110.01 69.72,108.95 68.07,108.95 67.47,108.95 67.41,108.89
  L3 w0.165: 67.41,108.89 66.99,108.46 66.99,108.45 66.87,108.33 66.63,108.33 66.52,108.44 66.52,108.8 66.39,108.92 66.16,108.92 66.03,108.8 66.03,107.06 65.51,106.54 65.07,106.54 64.92,106.69 64.92,107.4 65.4,107.89 65.4,108.8 65.12,109.08 64.76,109.08 64.46,108.77 64.46,107.67 63.95,107.16 63.95,106.44 63.8,106.29 63.54,106.29 63.39,106.44 63.39,106.67 63.24,106.82 62.98,106.82 62.83,106.67 62.83,105.65 62.1,104.93 62.1,103.8 61.17,102.87 59.37,102.87 v5(59.3,102.93)
  BOTTOM w0.127: v5(59.3,102.93) 59.24,102.87 VRAM5.H7
MDA38: length 26.1
  TOP w0.127: v5(61.24,101.85) 60.84,102.25 VRAM5.F7 ; GPU1.N23 73.6,110.08 v5(74.01,109.68)
  L3 w0.102: 72.78,110.1 73.59,110.1 v5(74.01,109.68)
  L3 w0.165: 72.78,110.1 71.83,109.15 71.21,109.15 70.07,108.01 68.62,108.01 65.82,105.21 65.82,103.47 65.69,103.34 65.37,103.34 65.25,103.47 65.25,104.05 65.12,104.18 64.84,104.18 64.71,104.05 64.71,103.44 64.59,103.31 63.9,103.31 63.75,103.16 63.75,102.45 63.59,102.29 62.19,102.29 61.99,102.09 61.99,101.74 62.12,101.61 62.26,101.61 62.38,101.48 62.38,101.11 62.2,100.93 61.31,100.93 60.85,100.47 60.85,100.32 60.72,100.19 60.43,100.19 60.11,100.5 60.11,100.9 60.34,101.13 60.52,101.13 v5(61.24,101.85)
  BOTTOM w0.127: VRAM7.E3 61.64,102.25 v5(61.24,101.85)
MDA39: length 26.1
  TOP w0.127: VRAM5.F8 v5(60.44,101.85) ; GPU1.N24 72.39,110.47 v5(72.39,110.51)
  L3 w0.165: v5(60.44,101.85) 60.1,101.51 59.4,101.51 58.92,101.03 58.46,101.03 58.06,100.62 57.04,100.62 56.86,100.8 56.86,101.26 57.02,101.41 57.86,101.41 57.86,101.41 58.22,101.41 58.78,101.97 59.56,101.97 59.92,102.34 61.65,102.34 63.77,104.46 64.53,104.46 64.55,104.48 65.06,104.48 65.31,104.73 65.31,105.34 68.29,108.32 69.96,108.32 71.19,109.56 71.43,109.56 v5(72.39,110.51)
  BOTTOM w0.127: VRAM5.F8 v5(60.44,101.85)
MDA40: length 21.4
  TOP w0.127: GPU1.V23 73.58,114.24 73.15,113.82 v5(73.13,113.82) ; v5(61.25,115.88) 61.24,115.87 61.23,115.87 VRAM6.F8
  L3 w0.102: v5(73.13,113.82) 71.9,113.82 71.74,113.98 71.34,113.98
  L3 w0.152: 64.89,116.32 64.83,116.38 62.1,116.38 61.94,116.22 61.94,115.79 62.23,115.49 62.42,115.49 62.58,115.33 62.58,115.01 62.22,114.65 61.86,114.65 61.25,115.26 v5(61.25,115.88)
  L3 w0.165: 64.89,116.32 65.01,116.19 65.01,115.73 65.14,115.61 65.68,115.61 65.88,115.4 65.88,114.92 66.01,114.79 66.52,114.79 66.65,114.92 66.65,115.24 66.98,115.57 67.61,115.57 67.76,115.41 67.76,115.05 67.91,114.9 68.49,114.9 68.64,115.05 68.64,115.74 69.03,116.13 69.33,116.13 69.67,115.79 69.67,115.16 70.85,113.98 71.34,113.98
  BOTTOM w0.127: v5(61.25,115.88) 60.84,115.48 VRAM6.F8
MDA41: length 24.5
  TOP w0.127: VRAM6.H7 59.24,116.33 v5(59.63,116.72) ; GPU1.V22 74.81,113.85 v5(74.82,113.85)
  L3 w0.102: 71.79,114.6 71.84,114.6 72.2,114.23 72.56,114.23 72.75,114.43 73.43,114.43 73.6,114.26 74.41,114.26 v5(74.82,113.85)
  L3 w0.165: v5(59.63,116.72) 59.63,117.13 59.9,117.4 61.44,117.4 61.44,117.39 61.65,117.39 62.11,116.93 65.18,116.93 65.21,116.97 66.27,116.97 66.44,117.13 66.44,118.22 66.75,118.53 67.16,118.53 67.67,118.02 68.06,118.02 68.27,117.82 68.27,117.17 68.43,117 68.76,117 68.93,117.17 68.93,117.85 69.09,118.02 69.47,118.02 69.64,117.85 69.64,116.76 70.62,115.78 70.62,115.19 71.21,114.6 71.79,114.6
  BOTTOM w0.127: v5(59.63,116.72) 59.24,116.33 VRAM6.H7 ; v5(74.82,113.85) 75.16,113.85 v3(75.52,113.5)
MDA42: length 22.6
  TOP w0.127: GPU1.T23 73.93,112.91 73.95,112.91 v5(74.03,112.99) ; v5(59.64,115.88) 59.24,115.49 VRAM6.H8
  L3 w0.102: v5(74.03,112.99) 73.97,112.93 73.72,112.93 73.6,113.06 73.6,113.24 73.47,113.37 73.28,113.37 72.99,113.37 72.76,113.6 72.51,113.6 72.28,113.37 72.03,113.37 71.69,113.71 71.01,113.71
  L3 w0.165: 71.01,113.71 70.54,113.71 69.78,114.47 63.56,114.47 63.34,114.69 62.69,114.69 62.43,114.43 62.43,113.43 61.33,112.32 61.11,112.32 60.74,112.69 60.74,112.91 61.68,113.85 61.68,114.46 60.66,115.47 60.04,115.47 v5(59.64,115.88)
  BOTTOM w0.127: VRAM8.G2 v5(59.64,115.88)
MDA43: length 23.7
  TOP w0.127: v5(61.22,116.69) 60.84,116.31 VRAM6.F7 ; GPU1.U22 74.79,113.03 v5(74.79,112.99)
  L3 w0.102: v5(74.79,112.99) 75.17,112.61 75.71,112.61 75.86,112.76 75.86,113.44 75.71,113.59 75.23,113.59 75.06,113.42 73.85,113.42 73.58,113.7 73.58,113.95 73.3,114.22 72.96,114.22 72.77,114.03 72.07,114.03 71.82,114.28
  L3 w0.165: 71.82,114.28 71.12,114.28 70.11,115.29 70.11,115.91 69.4,116.62 68.07,116.62 67.54,116.09 67.53,116.09 67.46,116.01 66.41,116.01 65.73,116.7 65.32,116.7 65.29,116.67 62,116.67 61.54,117.13 61.33,117.13 61.33,117.13 60.37,117.13 60.22,116.98 60.22,116.71 60.37,116.56 61.09,116.56 v5(61.22,116.69)
  BOTTOM w0.127: VRAM8.E3 61.23,116.69 v5(61.22,116.69)
MDA44: length 23.3
  TOP w0.127: GPU1.Y24 72.38,116.28 v5(72.38,117.13) ; VRAM6.E3 61.24,119.88 v5(61.24,119.89)
  L3 w0.165: v5(72.38,117.13) 72.02,117.13 71.81,117.34 71.81,118.38 71.93,118.5 72.3,118.5 72.43,118.63 72.43,118.93 72.3,119.06 71.93,119.06 71.81,119.19 71.81,119.47 69.71,121.57 66.9,121.57 66.74,121.74 66.74,121.91 66.57,122.08 66.24,122.08 66.08,121.91 66.08,121.74 65.91,121.57 65.26,121.57 64.82,121.14 63.31,121.14 63.18,121.01 63.18,120.48 63.06,120.36 62.7,120.36 62.57,120.48 62.57,120.99 62.42,121.14 60.49,121.14 60.36,121.01 60.36,120.46 60.49,120.33 60.97,120.33 61.24,120.06 v5(61.24,119.89)
  BOTTOM w0.127: v5(61.24,119.89) 61.24,119.88 VRAM8.F7 ; v5(72.38,117.13) 71.95,116.7 v3(71.7,116.7)
MDA45: length 22.1
  TOP w0.127: VRAM6.F2 60.84,120.27 v5(60.44,119.88) ; v5(73.17,117.12) 73.16,117.12 72.78,116.74 GPU1.AA24
  L3 w0.165: v5(60.44,119.88) 60.25,119.88 60.09,120.04 60.09,121.76 60.52,122.19 65.52,122.19 65.91,122.57 67.34,122.57 67.5,122.4 67.5,122.15 67.67,121.98 68,121.98 68.16,122.15 68.16,122.4 68.33,122.57 69.41,122.57 72.73,119.24 72.73,118.55 73.17,118.11 v5(73.17,117.12)
  BOTTOM w0.127: v5(73.17,117.12) 73.17,117.84 v3(73.23,117.91) ; VRAM6.F2 60.84,120.27 v5(60.44,119.88)
MDA46: length 20.9
  TOP w0.127: VRAM6.G2 59.67,119.91 v5(59.67,119.87) ; GPU1.Y22 74.01,116.29 v5(74.01,116.29)
  L3 w0.102: v5(74.01,116.29) 74.04,116.31 74.04,116.59 73.93,116.7 72.82,116.7 72.64,116.53
  L3 w0.165: 72.64,116.53 72.12,116.53 71.4,117.24 71.4,119.3 69.54,121.17 66.1,121.17 65.87,120.94 65.87,120.41 64.89,119.44 60.1,119.44 v5(59.67,119.87)
  BOTTOM w0.127: v5(59.67,119.87) 59.26,120.28 VRAM8.H8
MDA47: length 23.3
  TOP w0.127: VRAM6.H3 59.24,119.41 v5(58.87,119.04) ; v5(74,117.13) 73.59,116.72 GPU1.AA23
  L3 w0.102: 72.88,119.67 73.58,118.97 73.58,117.56 v5(74,117.13) ; 59.25,120.94 59.25,119.42 v5(58.87,119.04)
  L3 w0.165: 72.88,119.67 69.37,123.18 65.84,123.18 65.25,122.59 60.19,122.59 59.25,121.65 59.25,120.94
  BOTTOM w0.127: VRAM6.H3 59.24,119.41 v5(58.87,119.04)
MDA48: length 12.2
  TOP w0.127: GPU1.AD27 70.05,119.22 69.1,120.17 69.1,121.09 68.88,121.32 68.88,121.58 69.13,121.83 69.13,122.38 68.97,122.54 68.01,122.54 67.91,122.44 v1(67.91,121.53) v5(67.91,120.66) ; VRAM6.A2 64.45,120.67 64.44,120.67 v5(64.43,120.68)
  L4 w0.165: v5(64.43,120.68) 64.49,120.68 64.93,121.12 67.44,121.12 v5(67.91,120.66)
  BOTTOM w0.127: VRAM8.B8 64.43,120.67 v5(64.43,120.68)
MDA49: length 15.7
  TOP w0.127: GPU1.AB25 71.54,117.96 71.09,117.96 70.75,118.3 69.77,118.3 69.77,118.29 69.42,118.29 69.17,118.54 69.17,119.46 68.98,119.65 68.59,119.65 68.44,119.49 68.44,119.29 68.29,119.14 67.93,119.14 67.76,119.31 v1(67.76,119.77) 67.46,120.08 67.23,120.08 66.95,119.8 66.95,119.11 66.82,118.99 66.29,118.99 66.16,119.11 66.16,120.13 66.72,120.69 v5(67.2,120.69) ; VRAM6.A3 64.83,119.48 v5(64.43,119.88)
  L4 w0.165: v5(64.43,119.88) 65.52,119.88 66.33,120.69 v5(67.2,120.69)
  BOTTOM w0.127: VRAM6.A3 64.83,119.48 v5(64.43,119.88)
MDA50: length 13.7
  TOP w0.127: v5(62.85,119.9) 63.11,119.65 63.11,119.61 VRAM6.C3 ; GPU1.AD26 70.79,119.61 70.21,119.61 69.58,120.24 69.58,120.43 v5(69.56,120.46)
  L4 w0.165: v5(62.85,119.9) 63.31,119.44 66.59,119.44 67.15,120 68.98,120 69.41,119.57 70.1,119.57 70.22,119.7 70.22,120.33 70.1,120.46 v5(69.56,120.46)
  BOTTOM w0.127: v5(69.56,120.46) 69.56,120.03 v3(69.89,119.7) ; VRAM8.D7 62.44,119.48 v5(62.85,119.9)
MDA51: length 14.9
  TOP w0.127: VRAM6.C2 63.28,120.28 v5(63.67,120.66) ; GPU1.AC25 71.77,118.37 71.3,118.83 70.12,118.83 68.65,120.3 v5(68.65,120.7)
  L4 w0.165: v5(63.67,120.66) 63.77,120.76 63.77,121.51 64.27,122.01 64.96,122.01 65.3,121.68 65.56,121.68 65.73,121.84 65.73,122.05 65.89,122.21 66.22,122.21 66.39,122.05 66.39,121.84 66.55,121.68 66.88,121.68 67.05,121.84 67.05,122.05 67.21,122.21 67.54,122.21 67.71,122.05 67.71,121.84 67.87,121.68 68.29,121.68 68.65,121.32 v5(68.65,120.7)
  BOTTOM w0.127: v3(68.24,121.5) 68.65,121.09 v5(68.65,120.7) ; v5(63.67,120.66) 63.28,120.28 VRAM6.C2
MDA52: length 9.9
  TOP w0.127: GPU1.AA27 69.97,116.72 69.75,116.94 67.98,116.94 67.56,116.53 v5(67.35,116.53) ; VRAM6.D7 62.84,115.88 v5(62.85,115.88)
  L4 w0.165: v5(67.35,116.53) 67.18,116.7 63.67,116.7 v5(62.85,115.88)
  BOTTOM w0.127: VRAM8.C3 63.24,116.28 62.85,115.89 v5(62.85,115.88) ; v3(67.13,115.99) v5(67.35,116.53)
MDA53: length 15.4
  TOP w0.127: VRAM6.A7 65.49,116.28 v5(65.5,116.26) ; v5(68.34,116.07) 68.34,116.06 68.19,116.06 68.05,116.2 68.05,116.58 68.18,116.71 69.22,116.71 69.35,116.58 69.35,116.46 69.48,116.33 70.58,116.33 70.97,116.72 GPU1.AA26
  L4 w0.165: v5(65.5,116.26) 66.36,116.26 66.53,116.09 67.56,116.09 67.86,116.39 67.86,116.83 68.55,117.51 70.35,117.51 70.48,117.38 70.48,116.88 70.35,116.75 69.03,116.75 v5(68.34,116.07)
  BOTTOM w0.127: v3(68.93,116.6) v5(68.34,116.07) ; v5(65.5,116.26) 65.49,116.28 VRAM6.A7
MDA54: length 16.3
  TOP w0.127: VRAM6.B8 64.04,115.48 v5(64.44,115.88) ; GPU1.W26 71.15,115.07 71.15,115.39 70.78,115.75 69.27,115.75 v5(69.08,115.56)
  L4 w0.165: v5(64.44,115.88) 64.75,115.57 67.43,115.57 67.43,115.56 67.73,115.56 68.22,115.07 69.62,115.07 69.78,115.24 69.78,115.53 69.91,115.66 70.32,115.66 70.44,115.53 70.44,115.24 70.61,115.07 70.91,115.07 71.04,115.2 71.04,116.19 70.91,116.32 69.21,116.32 69.08,116.19 v5(69.08,115.56)
  BOTTOM w0.127: v5(69.08,115.56) 69.04,115.56 68.47,115 v3(68.29,115) ; VRAM8.A2 64.84,115.48 v5(64.44,115.88)
MDA55: length 15.9
  TOP w0.127: GPU1.Y25 71.82,115.88 71.44,116.26 70.89,116.26 70.63,116 68.91,116 68.47,115.56 67.81,115.56 67.38,115.13 v5(67.25,115.13) 67.01,115.36 v1(67.01,115.71) ; v5(63.64,115.87) 63.64,115.84 63.28,115.48 VRAM6.C8
  L4 w0.165: v5(67.25,115.13) 66.76,114.64 63.16,114.64 63.11,114.69 62.44,114.69 62.4,114.64 61.86,114.64 61.6,114.9 61.6,115.26 61.86,115.52 62.59,115.52 62.66,115.44 63.21,115.44 v5(63.64,115.87)
  BOTTOM w0.127: VRAM6.C8 63.28,115.48 63.64,115.84 v5(63.64,115.87)
MDA56: length 20.2
  TOP w0.127: v5(64.44,101.85) 64.04,101.46 VRAM5.B8 ; v5(69.52,110.56) 69.52,111.13 69.83,111.44 70.21,111.44 70.24,111.4 70.81,111.4 71.17,111.76 GPU1.R26
  L4 w0.165: v5(64.44,101.85) 65.63,101.85 65.76,101.73 65.76,100.96 65.89,100.83 66.37,100.83 66.5,100.96 66.5,101.73 66.63,101.85 66.89,101.85 67.06,101.69 67.06,100.99 67.22,100.83 67.55,100.83 67.72,100.99 67.72,101.69 67.88,101.85 68.38,101.85 68.64,102.11 68.64,106.69 69.28,107.32 69.28,110.32 v5(69.52,110.56)
  BOTTOM w0.127: VRAM7.A2 v5(64.44,101.85)
MDA57: length 20.8
  TOP w0.127: v5(65.14,102.81) 65.14,102.55 VRAM5.A7 ; GPU1.T25 71.72,112.56 71.31,112.15 69.88,112.15 69.09,111.35 67.95,111.35 67.07,110.48 66.33,110.48 66.18,110.32 v1(66.18,110.1) 66.18,109.04 66.31,108.91 67.68,108.91 v5(68.38,109.62)
  L4 w0.165: v5(65.14,102.81) 65.14,102.83 65.7,103.39 66.87,103.39 67.76,104.28 67.76,107.08 68.38,107.7 v5(68.38,109.62)
  BOTTOM w0.127: v5(65.14,102.81) 65.14,102.55 VRAM5.A7
MDA58: length 18.8
  TOP w0.127: VRAM5.C8 63.63,101.84 v5(63.63,101.85) ; GPU1.N27 69.9,110.08 v5(69.81,109.99)
  L4 w0.165: v5(69.81,109.99) 69.81,107.3 69.05,106.53 69.05,105.08 69.72,104.41 69.72,103.31 69.24,102.82 69.24,100.69 68.94,100.4 64.25,100.4 64.08,100.57 64.08,101.58 63.81,101.85 v5(63.63,101.85)
  BOTTOM w0.127: v5(63.63,101.85) 63.63,101.84 VRAM5.C8
MDA59: length 19.8
  TOP w0.127: v5(62.78,102.74) 62.44,102.4 VRAM5.D7 ; GPU1.R27 69.82,111.76 69.06,111 68.24,111 67.86,110.62 v1(67.86,110.33) 68.09,110.1 68.69,110.1 v5(68.82,110.23)
  L4 w0.165: v5(68.82,110.23) 68.87,110.17 68.87,107.55 68.29,106.97 68.29,103.44 67.83,102.98 67.31,102.98 67.14,102.82 67.14,102.51 66.98,102.35 66.65,102.35 66.48,102.51 66.48,102.82 66.32,102.98 65.94,102.98 65.25,102.29 63.99,102.29 63.54,102.74 v5(62.78,102.74)
  BOTTOM w0.127: VRAM7.C3 62.78,102.71 v5(62.78,102.74)
MDA60: length 18.5
  TOP w0.127: v5(64.44,105.85) 64.7,105.85 64.84,105.98 VRAM5.A2 ; v5(66.26,111.44) 65.98,111.44 65.83,111.59 65.83,112.61 v1(66.29,113.07) 66.29,113.52 66.64,113.88 67.63,113.88 68.31,114.56 70.02,114.56 70.06,114.6 70.53,114.6 70.88,114.24 GPU1.V26
  L4 w0.165: v5(64.44,105.85) 64.41,105.85 63.95,106.3 63.95,107.05 64.5,107.6 64.5,108.61 64.66,108.77 66.09,108.77 66.26,108.94 66.26,109.24 66.09,109.41 65.54,109.41 65.37,109.57 65.37,109.88 65.54,110.04 66.09,110.04 66.26,110.21 v5(66.26,111.44)
  BOTTOM w0.127: v5(64.44,105.85) 64.18,105.85 64.04,105.99 VRAM7.B8
MDA61: length 19
  TOP w0.127: VRAM5.A3 64.84,104.95 v5(64.88,104.91) ; GPU1.V27 70.17,114.03 68.48,114.03 67.8,113.35 67.38,113.35 66.58,112.55 66.58,111.73 66.79,111.52 v5(66.79,110.98)
  L4 w0.165: v5(66.79,110.98) 66.75,110.94 66.75,108.55 66.6,108.39 65.55,108.39 65.4,108.24 65.4,107.95 65.55,107.79 65.97,107.79 66.12,107.64 66.12,107.42 66.12,107.31 65.97,107.16 65.04,107.16 64.89,107.01 64.89,106.67 65.04,106.51 66,106.51 66.12,106.39 66.12,106.12 65.81,105.8 65.02,105.8 64.88,105.66 v5(64.88,104.91)
  BOTTOM w0.127: v3(66.74,110.2) 66.74,110.93 v5(66.79,110.98) ; VRAM5.A3 64.88,105.41 v5(64.88,104.91)
MDA62: length 19.4
  TOP w0.127: VRAM5.C3 63,105.45 62.87,105.32 62.87,105.04 63,104.91 v5(63.09,104.91) ; GPU1.W27 69.91,115.04 69.69,114.82 68.05,114.82 67.56,114.33 66.66,114.33 65.52,113.19 65.52,111.18 v5(65.57,111.14)
  L4 w0.165: v5(65.57,111.14) 65.31,111.14 62.66,108.49 62.21,108.49 61.97,108.24 61.97,107.28 62.12,107.12 62.84,107.12 63.09,106.87 v5(63.09,104.91)
  BOTTOM w0.127: v5(65.57,111.14) v3(65.57,111.95) ; VRAM7.D7 62.95,104.94 63.06,104.94 v5(63.09,104.91)
MDA63: length 18
  TOP w0.127: v5(63.63,105.85) 63.63,105.87 63.26,106.25 VRAM5.C2 ; GPU1.W25 71.62,114.68 71.03,114.68 70.79,114.93 70.79,115.13 70.53,115.4 69.81,115.4 69.55,115.14 67.89,115.14 67.43,114.68 66.51,114.68 64.94,113.12 v1(64.94,112.23) 64.94,110.98 v5(65.39,110.53)
  L4 w0.165: v5(63.63,105.85) 63.51,105.98 63.51,108.64 v5(65.39,110.53)
  BOTTOM w0.127: v5(63.63,105.85) 63.24,106.25 VRAM5.C2
MDAT: length 5
  TOP w0.102: U109.79 105.58,57.61 v2(105.62,57.65)
  BOTTOM w0.102: RN3.2 106.35,58.13 105.86,57.65 v2(105.62,57.65) 104.97,58.29 104.97,58.36 v3(104.94,58.39)
ME_CNTL: length 7.1
  TOP w0.102: v2(121.28,51.3) 121.48,51.49 121.48,52.18 120.45,53.21 U109.7
  BOTTOM w0.102: v2(121.28,51.3) 121.67,50.91 v3(122.75,50.91) R1836.2 R80244.1
ME_CNTL1: length 43.3
  TOP w0.102: Q5.B 163.48,56.72 163.58,56.82 163.58,56.98 v2(163.62,57.03)
  BOTTOM w0.102: v2(163.62,57.03) 162.97,56.37 155.57,56.37 155.03,55.84 155.03,55.83 154.79,55.59 154.79,55.59 154.78,55.58 154.78,55.41 154.78,54.87 154.05,54.14 152.27,54.14 152.04,53.91 150.23,53.91 148.51,52.18 127.58,52.18 126.31,50.91 v3(125.93,50.91) R1836.1
ME_CNTL2: length 138.4
  TOP w0.102: Q5.E 162.84,54.42 164.19,54.42 165.17,55.4 165.17,57.01 163.49,58.69 v2(163.49,59.32) ; v2(183.37,122.41) 181.7,122.41 v1(181.68,122.39) 181.65,122.41 180.94,122.41 179.67,123.68 177.85,123.68 173.13,128.41 157.19,128.41 155.91,127.12 149.42,127.12 148.63,127.91 141.84,127.91 138.18,124.26 136.21,124.26 135.71,123.75 R150.2
  L3 w0.127: v2(183.37,122.41) 183.37,121.94 185.07,120.24 185.07,91.81 184.3,91.05 181.55,91.05 180.54,90.03 177.9,90.03 176.85,88.98 176.85,85.63 174.57,83.35 174.57,82.23 172.27,79.93 172.27,78.37 172.27,78.16 171.58,77.46 171.58,76.82 167.47,72.71 165.82,72.71 164.41,71.3 164.41,61.05 163.49,60.13 v2(163.49,59.32)
MIC2-L: length 12.4
  TOP w0.203: 181.14,70.01 181.17,70.04 181.79,70.04 C263.1 ; 181.14,70.01 v1(181.12,70.03) ; 181.14,70.01 v2(181.14,68.98) ; U9.47 176.7,64.18 v2(176.78,64.25)
  L3 w0.203: v2(176.78,64.25) 176.78,65.26 177.39,65.87 179.32,65.87 181.48,68.03 181.48,68.64 181.33,68.79 v2(181.14,68.98)
MIC2-L-1: length 3.8
  TOP w0.203: v1(186.68,71.63) 185.9,70.84 R410.1 185.37,70.84 184.61,70.08 184.14,70.08 C263.2
MIC2-R: length 14.1
  TOP w0.203: v2(176.07,63.13) 176.3,62.89 U9.48 ; C265.1 184.92,69.09 184.68,68.85 183.56,68.85 v1(183.19,68.48) 183.18,68.48 182.91,68.74 181.62,68.74 181.12,68.24 v2(180.97,68.24)
  L3 w0.203: v2(176.07,63.13) 176.07,63.94 176.27,64.14 176.27,65.47 177.13,66.33 178.95,66.33 180.29,67.68 180.37,67.68 180.92,68.24 v2(180.97,68.24)
MIC2-R-1: length 2.7
  TOP w0.203: R411.1 187.17,70.74 v1(186.73,70.31) 186.44,70.01 C265.2
MIC2-VREFO-L: length 16.9
  TOP w0.203: v2(183.08,70.6) 183.23,70.75 183.76,70.75 183.85,70.84 R414.1 ; v2(175.76,64.35) 175.56,64.15 175.56,61.5 175.48,61.43 U9.1
  L3 w0.203: v2(175.76,64.35) 175.76,65.77 176.78,66.79 178.76,66.79 179.65,67.68 179.65,68.78 180.96,70.09 182.57,70.09 v2(183.08,70.6)
  BOTTOM w0.203: v2(175.76,64.35) 176.24,64.83 v3(176.24,65.01)
MIC2-VREFO-R: length 24.9
  TOP w0.203: v2(188.92,72.88) 188.28,73.52 v1(188.16,73.52) 185.68,73.52 R415.1 ; v2(184.42,58) 184.32,58.1 183.31,58.1 182.57,58.84 U9.30
  L4 w0.203: v2(188.92,72.88) 188.92,72.67 184.73,68.48 184.73,67.1 183.63,66.01 183.63,61.96 185.01,60.59 185.01,58.94 184.88,58.81 184.88,58.46 v2(184.42,58)
MIC-CAP: length 7
  TOP w0.203: 181.53,61.71 U9.36
  TOP w0.254: v1(185.75,65.85) 185.29,65.85 184.5,65.06 C206.2 182.26,63.11 181.94,63.11 181.53,62.69 181.53,62.25 181.53,62.25 181.53,61.71
MPCIE_DISABLE_N: length 308.6
  TOP w0.102: v2(141.04,245.48) 141.04,243.57 140.16,242.69 R706.1 ; v2(109.67,67.97) 108.05,67.97 107.82,67.73 RN6.3 107.82,67.11 108.58,66.35 108.58,66.31 108.58,66.31 108.58,65.74 108.58,65.74 U109.56
  L3 w0.127: v2(141.04,245.48) 144.57,245.48 152.95,237.1 153.92,237.1 157.47,233.54 165.35,233.54 182.73,216.16 182.73,161.69 199.95,144.47 199.95,138.79 190.95,129.78 187,129.78 182.35,125.13 182.35,121.74 184.31,119.79 184.31,96.12 182.57,94.38 182.57,93.35 181.03,91.81 180.1,91.81 179.46,91.17 177.96,91.17 175.96,89.17 175.96,86 171.51,81.54 171.51,78.47 170.81,77.78 170.81,77.13 167.15,73.47 164.13,73.47 163.52,72.86 163.52,63.86 v2(162.92,63.26)
  BOTTOM w0.102: v2(109.67,67.97) 109.99,67.97 111.15,69.13 113.95,69.13 115.31,67.77 115.31,66.12 115.83,65.59 116.53,65.59 116.71,65.77 121.21,65.77 123.7,63.28 123.87,63.28 126.81,60.34 127.62,60.34 129.21,58.75 130.43,58.75 131.2,59.51 140.66,59.51 141.48,60.34 145.68,60.34 147.96,62.62 v3(148.56,62.62) 148.74,62.8 151.28,62.8 151.71,62.37 154.25,62.37 154.6,62.01 160.91,62.01 161.03,62.14 161.35,62.14 162.53,63.32 162.86,63.32 v2(162.92,63.26)
MS_INS#: length 2.5
  BOTTOM w0.102: U14.31 189.99,139.27 189.77,139.05 189.3,139.05 188.54,138.29 TP205.1
NCP81172_FB1: length 3.2
  TOP w0.254: v2(98.75,104.1) 98.62,103.97 PR8318.1
  BOTTOM w0.254: v2(98.75,104.1) 98.75,103.06 98.77,103.03 v3(98.77,102.93) 98.77,102.86 98.46,102.54 PC8312.1
NGFF_ALERT_N: length 5.1
  TOP w0.102: NGFF1.62 133.92,244 134.56,244.64 134.8,244.64 v1(135.83,245.68) 135.89,245.74 R701.2
NGFF_BT_DISABLE: length 221.8
  TOP w0.102: v2(133.27,89.39) 133.86,89.39 134.46,88.79 134.46,88.63 U2.L44 ; v2(156.03,227.57) 156.03,234.17 153.49,236.71 153.49,237.86 149.69,241.67 v1(143.66,241.67) 140.79,241.67 140.49,241.96 138.23,241.96 R707.1
  L3 w0.127: v2(133.27,89.39) 133.27,89.64 137.48,93.86 137.48,95.82 137.17,96.14 137.17,97.34 138.49,98.67 145.97,98.67 148.48,101.18 149.56,101.18 150.22,101.84 155.05,101.84 156.98,99.91 168.2,99.91 168.98,99.13 173.94,99.13 175.32,100.51 175.32,102.34 175.11,102.54 175.11,113.17 174.86,113.42 174.86,130.47 173.72,131.62 173.72,159.66 174.02,159.97 174.02,216.62 163.07,227.57 v2(156.03,227.57)
NGFF_CLKREQ0_N: length 6.6
  TOP w0.102: NGFF1.53 123.05,241.75 v1(122.18,242.62) 121.6,243.2 R709.1
NGFF_CLKREQ1_N: length 6.4
  TOP w0.102: TP241.1 137.81,246.82 135.47,246.82 134.17,245.52 134.02,245.52 134,245.5 NGFF1.68
NGFF_DETECT_PCIE: length 265
  TOP w0.102: R710.2 116.77,242.19 116.24,242.72 v1(116.24,247.51) 116.24,249.88 117.58,251.22 121.48,251.22 122.19,250.51 137.42,250.51 142.79,245.13 v2(142.79,243.45) ; U2.AB33 140.22,82.98 139.9,83.3 v2(139.79,83.3)
  L3 w0.127: v2(142.79,243.45) 142.79,241.75 154.8,229.74 163.6,229.74 176.81,216.52 176.81,156.7 175.62,155.51 175.62,132.5 177.73,130.39 177.73,114.32 178.47,113.59 178.47,107.88 178.41,107.83 178.41,106.29 178.72,105.99 178.72,102.42 178.28,101.98 178.28,98.37 174.57,94.66 173.6,94.66 170.72,91.78 170.72,91.1 170.44,90.83 162.16,90.83 160.23,88.9 155.64,88.9 154,90.54 153.58,90.54 150.6,93.52 150.6,94.41 149.45,95.56 148.85,95.56 147.39,94.1 147.39,91.94 146.77,91.32 144.44,91.32 143.57,92.2 142.43,92.2 141.82,91.59 141.27,91.59 139.9,90.22 139.9,88.66 139.38,88.15 139.38,83.71 v2(139.79,83.3)
NGFF_DETECT_PCIE_C: length 7.6
  TOP w0.102: R710.1 R715.1 119.87,241.17 120.03,241.34 v1(120.06,241.34) 120.06,241.36 120.59,241.9 122.22,241.9 122.87,241.25 NGFF1.51
NGFF_DETECT_USB: length 152.3
  TOP w0.102: U2.AB41 140.11,86.79 v2(139.83,86.51) ; v2(135.96,127.75) 134.56,129.15 134.56,135.5 130.5,139.56 130.5,146.8 119.16,158.14 119.16,226.99 119.63,227.47 R721.2
  BOTTOM w0.102: v2(135.96,127.75) 135.96,126.22 134.87,125.13 134.87,116.67 138.19,113.35 v3(138.19,104.96) 138.19,101.51 139.13,100.57 139.13,96.7 140.38,95.46 140.38,90.55 140.07,90.24 140.07,88.23 139.67,87.83 139.67,86.67 v2(139.83,86.51)
NGFF_DETECT_USB_C: length 5.5
  TOP w0.102: R722.1 R721.1 122.25,227.47 v1(122.26,227.47) 122.57,227.47 123.85,228.75 NGFF1.1
NGFF_PCIE0_RXN: length 7.1
  TOP w0.102: 120.32,238.08 119.96,237.72 119.3,237.72 R714.1 ; 120.32,238.08 v1(120.06,238.34) ; 120.32,238.08 121.34,239.11 123.64,239.11 123.78,239.25 NGFF1.43
NGFF_PCIE0_RXP: length 7.2
  TOP w0.102: 122.27,238.89 121.43,238.89 120.05,237.51 119.3,237.51 R717.1 ; 122.27,238.89 v1(122.27,238.49) ; 122.27,238.89 123.64,238.89 123.78,238.75 NGFF1.41
NGFF_PCIE0_TXN: length 7.4
  TOP w0.102: 120.41,236.31 121.7,237.61 123.64,237.61 123.78,237.75 NGFF1.37 ; 120.41,236.31 v1(120.13,236.59) ; 120.41,236.31 119.79,235.69 119.3,235.69 R719.1
NGFF_PCIE0_TXP: length 8.2
  TOP w0.102: v1(118.48,234.02) 118.9,234.44 R720.1 119.3,235.47 119.88,235.47 121.79,237.39 123.64,237.39 123.78,237.25 NGFF1.35
NGFF_PCIE1_RXN: length 6.5
  TOP w0.102: NGFF1.67 123.78,245.25 123.64,245.11 123.3,245.11 121.68,246.73 121.13,247.28 120.11,247.28 TP245.1
NGFF_PCIE1_RXP: length 6.5
  TOP w0.102: TP244.1 120.05,247.06 121.04,247.06 122.1,246 123.21,244.89 123.64,244.89 123.78,244.75 NGFF1.65
NGFF_PCIE1_TXN: length 8.1
  TOP w0.102: NGFF1.61 123.78,243.75 123.64,243.61 123.15,243.61 120.74,246.01 118.66,246.01 TP247.1
NGFF_PCIE1_TXP: length 8
  TOP w0.102: TP246.1 118.5,245.8 120.66,245.8 123.06,243.39 123.64,243.39 123.78,243.25 NGFF1.59
NGFF_PEWAKE0_N: length 6.8
  TOP w0.102: NGFF1.55 123.24,242.25 122.74,242.75 122.74,242.85 122.41,243.18 122.31,243.18 121.27,244.22 v1(120.31,244.22) R708.1
NGFF_PEWAKE1_N: length 4
  TOP w0.102: TP254.1 135.35,247.38 133.97,246 NGFF1.70
NGFF_POWER_CTRL: length 291.2
  TOP w0.102: v2(152.22,238.49) 152.41,238.3 152.41,236.83 152.1,236.52 R732.1 ; v2(109.21,67.36) 109.11,67.46 RN6.4 108.47,67.1 108.98,66.59 U109.55
  L3 w0.127: v2(152.22,238.49) 153.36,237.35 154.02,237.35 157.58,233.79 165.46,233.79 182.99,216.26 182.99,161.8 200.21,144.58 200.21,138.68 191.05,129.53 187.11,129.53 182.61,125.02 182.61,121.85 184.56,119.89 184.56,95.89 182.82,94.15 182.82,93.24 181.13,91.55 180.21,91.55 179.57,90.92 178.07,90.92 176.35,89.2 176.35,86.02 171.76,81.44 171.76,78.37 171.07,77.67 171.07,77.03 167.26,73.21 164.42,73.21 163.77,72.56 163.77,63.45 162.77,62.45 v2(162.35,62.45)
  BOTTOM w0.102: v2(109.21,67.36) 109.7,67.36 111.25,68.9 113.86,68.9 115.08,67.68 115.08,66.02 115.74,65.37 116.63,65.37 116.81,65.54 121.11,65.54 123.6,63.05 123.69,63.05 126.64,60.11 127.42,60.11 129.01,58.52 131.59,58.52 132.35,59.28 141.78,59.28 142.31,59.8 145.47,59.8 147.78,62.11 148.77,62.11 148.95,62.29 v3(150.64,62.29) 150.87,62.06 154.15,62.06 154.42,61.79 161,61.79 161.13,61.91 161.71,61.91 162.25,62.45 v2(162.35,62.45)
NGFF_POWER_CTRL_1: length 5.8
  TOP w0.102: v2(150.31,238.37) 149.86,238.37 v1(149.27,237.78) 149.64,237.41 R729.2 R732.2
  BOTTOM w0.102: Q58.G 149.37,237.43 v2(150.31,238.37)
NGFF_POWER_CTRL_V2: length 4.9
  TOP w0.102: R734.1 C519.1 149.29,242.49 v2(149.29,243.57)
  BOTTOM w0.102: v2(149.29,243.57) v3(149.29,242.56) 149.29,241.41 148.91,241.03 Q60.B
NGFF_REFCLKN0: length 6.9
  TOP w0.102: v1(121.99,241.01) 121.99,240.61 ; 121.99,240.61 120.94,240.61 120.09,239.75 119.3,239.75 R711.1 ; 121.99,240.61 123.64,240.61 123.78,240.75 NGFF1.49
NGFF_REFCLKN1: length 8
  TOP w0.102: NGFF1.73 123.78,246.75 123.64,246.61 123.28,246.61 121.04,248.84 118.55,248.84 118.53,248.83 TP243.1
NGFF_REFCLKP0: length 6.9
  TOP w0.102: NGFF1.47 123.78,240.25 123.64,240.39 121.03,240.39 120.51,239.87 ; R712.1 119.3,239.54 120.17,239.54 120.51,239.87 ; v1(120.77,239.61) 120.51,239.87
NGFF_REFCLKP1: length 8
  TOP w0.102: TP242.1 118.64,248.63 120.95,248.63 123.19,246.39 123.64,246.39 123.78,246.25 NGFF1.71
NGFF_W_DISABLE1_N: length 4.5
  TOP w0.102: NGFF1.56 135.58,242.5 135.71,242.38 v1(135.81,242.38) 136.74,242.38 R706.2
NGFF_W_DISABLE2_N: length 4.6
  TOP w0.102: NGFF1.54 134.32,242 v1(134.79,241.53) 136.91,241.53 R707.2
ODTA0: length 95
  TOP w0.102: v5(84.48,85.85) 83.75,86.58 83.75,86.81 83.45,87.11 81.49,87.11 VRAM1.K1 ; VRAM2.K1 67.09,87.48 67.78,87.11 69.18,87.11 69.49,86.8 69.5,86.8 69.74,86.57 69.74,86.55 69.82,86.47 69.82,86.05 70.14,85.73 v5(70.14,85.64)
  TOP w0.127: GPU1.C27 70.1,101.82 69.23,100.95 69.23,98.06 69.22,98.05 69.22,97.81 65.61,94.2 65.61,93.21 v5(65.11,92.72) ; v5(76.86,77.88) 76.59,77.62 PR5523.1
  L3 w0.127: v5(70.14,85.64) 68.77,85.64 68.55,85.86 68.51,85.86 68.46,85.9 68.11,85.9 67.87,85.66 67.87,84.9 67.28,84.31 67.28,84.28 67.06,84.06 67.06,83.72 67.07,83.71 67.07,82.9 67.46,82.51 67.46,80.93 70.18,78.21 71.56,78.21 72.52,77.24 74.69,77.24 74.82,77.37 74.82,77.68 74.95,77.81 75.2,77.81 75.33,77.68 75.33,77.37 75.46,77.24 76.21,77.24 v5(76.86,77.88) 77.37,78.4 78.91,78.4 79.74,79.22 80.08,79.22 80.18,79.12 80.18,78.8 80.28,78.7 80.49,78.7 80.59,78.8 80.59,79.12 80.69,79.22 80.89,79.22 80.99,79.12 80.99,78.8 81.1,78.7 81.3,78.7 81.4,78.8 81.4,79.12 81.5,79.22 81.76,79.22 82.01,79.47 82.15,79.47 82.44,79.18 82.58,79.18 82.73,79.32 82.73,79.46 82.44,79.75 82.44,79.9 82.67,80.13 82.67,80.28 82.4,80.56 82.4,80.74 82.51,80.85 82.68,80.85 83.51,80.02 83.68,80.02 83.8,80.14 83.8,80.31 82.87,81.23 82.87,81.4 82.99,81.52 83.16,81.52 83.54,81.14 83.68,81.14 84.24,81.7 84.24,83.2 84.88,83.83 84.88,85.46 v5(84.48,85.85)
  L3 w0.165: v5(64.23,83.17) 64.15,83.17 63.42,83.91 63.42,84.64 63.9,85.13 63.9,86.35 62.93,87.31 62.93,90.26 62.97,90.29 62.97,90.57 v5(65.11,92.72)
  BOTTOM w0.102: VRAM3.K1 87.07,87.03 85.71,87.03 85.36,86.68 85.2,86.68 84.48,85.95 v5(84.48,85.85) ; VRAM4.K1 73.21,87.48 72.81,87.07 72.62,87.07 72.31,86.77 72.31,86.63 71.93,86.25 71.78,86.25 71.36,85.84 70.89,85.84 70.81,85.76 70.26,85.76 v5(70.14,85.64)
  BOTTOM w0.127: v5(64.23,83.17) 64.86,83.17 65.58,82.45 65.58,82.3 65.81,82.07 65.81,81.68 66.29,81.2 70.54,81.2 71.23,80.5 73.68,80.5 74.47,79.72 74.87,79.72 75.23,79.36 v3(75.28,79.36) 75.7,79.36 76.18,78.88 76.18,78.87 76.42,78.63 76.42,78.33 76.85,77.9 76.85,77.89 v5(76.86,77.88)
ODTA1: length 96.5
  TOP w0.102: v5(72.39,108.88) 72.39,108.88 72.78,109.28 GPU1.M24 ; VRAM6.K1 57.25,120.69 57.25,118.83 56.3,117.89 v5(56.04,117.89) ; VRAM5.K1 57.26,106.67 57.26,104.89 v5(56.65,104.27)
  TOP w0.127: PR232.1 46.34,112.38 47.94,110.78 v5(48.25,110.78)
  L3 w0.127: v5(56.65,104.27) 56.56,104.18 56.56,102.71 55.57,101.72 55.57,101.41 55.29,101.13 52.75,101.13 51.66,102.23 51.51,102.23 51.3,102.01 51.15,102.01 51.01,102.15 51.01,102.3 51.23,102.51 51.23,102.66 51.08,102.8 50.94,102.8 50.72,102.58 50.58,102.58 50.43,102.73 50.43,102.87 50.65,103.09 50.65,103.23 48.73,105.15 48.73,109.99 48.25,110.47 v5(48.25,110.78) 48.22,110.81 48.22,112.83 48.58,113.19 48.58,117.22 52.28,120.92 54.48,120.92 54.66,121.1 55.03,121.1 55.28,120.85 55.28,120.48 54.6,119.79 54.6,118.49 54.85,118.24 55.69,118.24 v5(56.04,117.89)
  L3 w0.165: v5(72.39,108.88) 71.4,108.88 70.24,107.72 68.92,107.72 66.13,104.94 66.13,103.31 65.58,102.76 65.58,102.36 63.83,100.61 61.56,100.61 60.63,99.67 58.19,99.67 58.02,99.85 56.41,99.85 55.5,98.94 54.97,98.94 54.41,99.5 52.49,99.5 52.26,99.73 v5(50.95,99.73)
  BOTTOM w0.102: v5(56.04,117.89) 56.04,116.77 56.38,116.43 56.38,116.27 56.82,115.84 56.95,115.84 57.31,115.48 57.31,115.18 57.64,114.85 VRAM8.K1 ; VRAM7.K1 57.64,100.67 57.23,101.08 57.23,102.4 57.11,102.53 57.11,102.84 56.66,103.28 56.66,104.26 v5(56.65,104.27)
  BOTTOM w0.127: v5(48.25,110.78) 48.25,110.47 49.31,109.41 v3(49.31,108.95) 49.31,107.43 50.09,106.65 50.09,100.6 v5(50.95,99.73)
OPC_1P8_AB37: length 28.6
  TOP w0.254: v2(77.31,204.13) 77.31,204.1 76.87,203.66 CPU1.AB37
  BOTTOM w0.254: v2(77.31,204.13) 76.09,205.35 76.09,211.71 76.09,211.71 76.09,212.29 84.32,220.52 90.04,220.52 TP226.1
OS_MODE_SEL: length 167.7
  TOP w0.102: v2(140.12,97.62) 140.02,97.73 140.02,98.06 139.83,98.25 R79938.1 139.15,97.98 137.83,97.98 137.18,97.33 137.18,96.45 137.52,96.11 137.52,93.84 138.32,93.04 138.32,92.16 137.64,91.48 137.64,91.04 138.17,90.5 138.17,88.89 138.17,88.89 138.17,88.51 U2.V44 ; v2(33.22,25.64) 33.01,25.84 SCA1.109
  L3 w0.127: v2(141.22,94.09) 137.48,90.36 137.48,88.85 136.58,87.95 136.58,87.46 135.58,86.45 135.58,85.96 132.59,82.97 132.43,82.97 129.71,80.25 123.82,80.25 121.54,77.96 119.61,77.96 110.09,68.44 109.48,68.44 102.05,61.01 102.05,60.91 100.91,59.77 100.91,58.78 98.84,56.71 98.84,54.18 97.64,52.98 93.01,52.98 92.99,53 91.76,53 91.74,52.98 91.16,52.98 90.54,52.36 87.11,52.36 82.29,47.55 81.16,47.55 79.78,46.18 64.32,46.18 63.18,47.31 57.28,47.31 54.66,44.69 53.37,44.69 50.92,42.24 50.21,42.24 45.08,37.11 45.08,28.87 45.2,28.74 v2(45.2,26.78)
  BOTTOM w0.102: v2(33.22,25.64) 33.85,25.01 41.04,25.01 42.31,26.28 44.65,26.28 45.15,26.78 v2(45.2,26.78) ; v2(141.22,94.09) 141.22,96.46 v3(141.06,96.61) 140.12,97.55 v2(140.12,97.62)
OSD_BIST_N: length 30.5
  TOP w0.102: R743.2 v2(20.52,16.88)
  L3 w0.127: v2(20.52,16.88) 18.83,18.57 18.83,24.97 19.79,25.93 19.79,30.84 19.16,31.48 19.16,35.96 19.44,36.24 19.44,40.71 v2(17.85,42.3)
  BOTTOM w0.102: R535.1 18.71,41.77 18.41,41.46 v3(17.98,41.46) 17.85,41.59 v2(17.85,42.3)
OSD_BIST_N_1: length 2.9
  BOTTOM w0.254: Q9628.2 19.12,42.59 R535.2 v3(21.02,41.77)
OSD_CONTROL_SEL: length 166.2
  TOP w0.102: SCA1.111 34.01,28.09 34.08,28.15 34.08,28.87 33.63,29.31 v2(33.63,29.32) ; v2(145.62,84.81) 146.11,84.32 U2.AN36
  L3 w0.127: v2(146.58,91.79) 144.51,91.79 143.14,93.17 141.98,93.17 138.27,89.46 138.27,88.74 137.04,87.5 137.04,83.81 136.09,82.85 134.67,82.85 132.4,80.58 131.73,80.58 129.71,78.56 123.92,78.56 120.51,75.16 117.88,75.16 110.69,67.96 110.69,67.63 107.82,64.76 107.82,63.12 107.23,62.53 107.21,62.53 106.58,61.9 106.58,61.88 106.21,61.51 105.55,61.51 105.52,61.54 105.03,61.54 104.21,60.72 104.21,60.1 100.24,56.14 100.24,53.56 97.64,50.96 87.69,50.96 82.87,46.15 81.73,46.15 80.36,44.78 69.57,44.78 62.6,37.81 57.86,37.81 53.31,33.26 51.95,33.26 51.31,32.63 49.49,32.63 v2(48.43,31.56)
  BOTTOM w0.102: R79939.1 145.26,95.66 145.26,95.1 145.46,94.89 145.46,94.14 146.7,92.9 146.7,92 146.58,91.89 v2(146.58,91.79) 146.65,91.72 146.65,89.67 146.33,89.34 146.33,88.89 146.17,88.74 146.17,87.3 147.07,86.4 147.07,85.31 146.78,85.01 146.55,85.01 146.35,84.81 v2(145.62,84.81) ; v2(33.63,29.32) 33.63,30.25 34.23,30.85 36.14,30.85 37.08,31.79 39.44,31.79 40.94,30.29 43.04,30.29 43.5,30.75 43.5,31.5 44.88,32.88 v3(46.17,32.88) 47.11,32.88 v2(48.43,31.56)
OSD_DN: length 305.5
  TOP w0.102: v2(145.92,99.66) 145.32,99.06 145.32,96.91 146.08,96.15 147.52,96.15 147.91,95.76 R79795.1 ; v2(37.6,53) 37.6,52.91 37.15,52.46 R79790.2 ; R750.1 C528.1 22.68,20.37 22.68,20.62 v2(22.55,20.75) 22.17,20.37 R748.1
  L3 w0.127: v2(161.87,30.47) 161.99,30.59 161.99,38.36 165.68,42.04 165.68,43.62 166.44,44.38 166.44,48.04 170.41,52 170.41,52.99 172.4,54.97 172.4,59.59 172.31,59.68 172.31,68.22 173.68,69.6 173.68,71.26 179.49,77.08 179.49,79.89 185.32,85.71 v2(185.74,85.71) ; v2(22.55,20.75) 24.52,22.72 24.52,43.74 30.12,49.34 30.12,50.12 32.48,52.49 35.12,52.49 35.36,52.25 36.85,52.25 v2(37.6,53)
  L4 w0.127: v2(161.87,30.47) 161.02,29.62 152.27,29.62 150.47,31.42 138.97,31.42 138.19,30.63 134.14,30.63 133.06,31.72 127.16,31.72 122.78,36.09 116.97,36.09 112.72,40.34 112.72,40.58 103.71,49.58 99.06,49.58 98.71,49.22 75.29,49.22 74.86,49.66 73.01,49.66 72.94,49.73 67.62,49.73 67.31,49.42 64.84,49.42 62.23,52.03 46.23,52.03 45.04,50.84 40.02,50.84 38.19,52.67 37.93,52.67 v2(37.6,53)
  BOTTOM w0.102: v2(145.92,99.66) 146.26,100 146.88,100 147.15,100.27 147.15,100.65 147.71,101.21 152.42,101.21 152.97,101.76 154.72,101.76 158.15,98.33 164.74,98.33 165.53,97.55 172.18,97.55 176.6,93.13 v3(176.6,87.49) 178.38,85.71 v2(185.74,85.71)
