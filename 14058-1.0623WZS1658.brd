# Allegro board 14058-1.0623WZS1658.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TPA3131_BSNL: length 2.8
  TOP w0.305: U10.19 171.15,30.13 171.15,30.12 v1(171.15,29.97) 171.04,29.86 C242.1
TPA3131_BSNR: length 4.3
  TOP w0.305: U10.22 172.65,29.93 172.66,29.92 v1(172.66,29.58) 172.66,29.09 C239.1
TPA3131_BSPL: length 3.4
  TOP w0.305: C244.1 167.46,31.23 167.84,31.61 v1(167.84,31.74) 168.6,32.5 168.6,32.65 168.84,32.9 U10.15
TPA3131_BSPR: length 3
  TOP w0.305: C235.1 176.71,32.1 176.03,32.79 v1(176.03,32.8) 175.93,32.9 U10.26
TPA3131_FAULT#: length 3.4
  TOP w0.102: U10.30 176.33,34.9 v1(176.56,34.67) 177.2,34.03 R381.2
TPA3131_GAIN: length 5.1
  TOP w0.203: U10.3 172.65,37.44 173.09,37.88 174.14,37.88 v1(174.34,38.09) 173.45,38.98 R399.1 173.4,39 R396.2
TPA3131_LINN: length 5
  TOP w0.203: C240.2 171.34,40.94 v1(171.34,39.94) 171.95,39.33 171.95,38.59 171.65,38.29 U10.5
TPA3131_LINN_1: length 3
  TOP w0.203: C240.1 172.73,42.7 R387.2 172.87,42.61 173.97,41.5 v1(174.1,41.5)
TPA3131_MUTE: length 19.7
  TOP w0.203: v2(180.51,32.09) 180.54,32.12 Q9626.D 181.23,34.02 R388.1 R79934.2 ; U10.7 170.65,37.18 v2(170.12,37.71)
  L4 w0.203: v2(170.12,37.71) 170.12,36.31 170.76,35.67 173.04,35.67 174.31,34.4 176.85,34.4 179.14,32.12 180.49,32.12 v2(180.51,32.09)
  BOTTOM w0.203: v3(180.51,32.9) v2(180.51,32.09)
TPA3131_PLIMIT: length 7.4
  TOP w0.203: U10.1 175.06,36.74 175.65,37.32 v1(176.24,37.32) 176.27,37.35 R397.2 177.41,38.01 178,38.59 C250.2 177.32,39.01 R398.1
TPA3131_RINN: length 5.6
  TOP w0.203: U10.32 175.05,35.9 175.63,36.49 177.79,36.49 v1(178,36.28) 178.02,36.26 179.49,36.26 C236.2
TPA3131_RINN_1: length 2.9
  TOP w0.203: R382.2 179.51,39.95 v1(180.41,39.05) 179.65,38.29 C236.1
TPA3131_SYNC: length 2.9
  TOP w0.203: U10.11 168.45,34.9 v2(168.18,35.17)
  BOTTOM w0.203: v2(168.18,35.17) 168.43,35.42 TP109.1
TPEV_CFG_RCOMP: length 5
  TOP w0.305: CPU1.M11 66.87,177.65 v2(68.9,179.69) 69.09,179.88 R45.1
  BOTTOM w0.305: v2(68.9,179.69) 68.9,180.21 v3(68.65,180.46)
TS#_DIMM0_1: length 25.8
  TOP w0.203: DIMM2.198 167.32,137.15 v5(167.19,137.02) ; v5(150.99,137.55) 150.99,137.5 151.34,137.15 DIMM1.198
  BOTTOM w0.203: v5(150.99,137.55) v3(155.87,137.55) 158.72,137.55 160.57,139.41 164.4,139.41 164.74,139.07 167.86,139.07 168.27,138.66 168.27,138.1 v5(167.19,137.02) 167.44,136.77 R73.1
U15_ZQ: length 12.5
  TOP w0.127: v5(89.69,81.77) 89.69,81.23 90.34,80.58 90.95,80.58 v1(91,80.63) 91,81.66 R235.1 ; VRAM1.L8 86.76,86.68 87.09,86.35 87.37,86.35 87.38,86.34 87.66,86.34 87.67,86.35 87.75,86.35 v2(88.33,86.93)
  L4 w0.165: v5(89.69,81.77) 88.36,81.77 87.64,82.5 87.64,86.13 88.33,86.83 v2(88.33,86.93)
U19_ZQ: length 5.1
  TOP w0.127: VRAM5.L8 56.84,101.33 57.22,100.95 57.22,99.68 57.47,99.43 v1(57.47,98.16) 57.16,97.84 R587.1
U35_ZQ: length 8.4
  TOP w0.127: VRAM2.L8 72.93,86.68 73.33,87.08 73.67,87.08 74.06,87.47 75.69,87.47 v1(75.94,87.72) 75.94,88.15 75.44,88.65 75.44,90.23 v5(75.15,90.51)
  BOTTOM w0.127: R620.1 75.69,91.05 v5(75.15,90.51)
U36_ZQ: length 13.6
  TOP w0.127: R79998.1 51.38,113.65 52.14,112.89 55.6,112.89 v1(56.25,112.24) 56.6,112.24 56.95,112.58 58.54,112.58 58.82,112.86 58.82,113.32 57.8,114.34 57.5,114.34 57.3,114.54 57.3,114.84 56.84,115.29 VRAM6.L8
U9626_ZQ: length 5.3
  BOTTOM w0.127: VRAM4.L8 67.68,86.68 67.34,86.34 66.83,86.34 66.16,87.01 v3(64.36,87.01) 63.17,87.01 R80028.1
U9627_ZQ: length 5.5
  BOTTOM w0.127: R80020.1 78.16,88.89 v3(78.81,88.89) 79.27,88.43 79.27,87.92 80.17,87.02 81.26,87.02 81.6,86.68 VRAM3.L8
U9628_ZQ: length 5
  BOTTOM w0.127: VRAM8.L8 56.84,120.59 57.22,120.97 57.22,121.4 57.85,122.03 57.85,122.49 v3(58.84,123.48) 59,123.63 R80034.1
U9629_ZQ: length 7.1
  BOTTOM w0.127: VRAM7.L8 56.84,106.41 57.22,106.79 57.22,108.95 57.6,109.33 58.77,109.33 v3(59.15,109.71) 59.15,110.31 R80040.1
UART0_RX: length 31.2
  TOP w0.102: v2(149.24,86.24) 149.24,86.68 149.51,86.94 U2.BA41 ; CN3.3 173.02,92.42 172.57,91.97 172.57,91.63 v2(172.15,91.22)
  L3 w0.127: v2(149.24,86.24) 149.24,86.52 148.46,87.3 148.46,87.83 148.77,88.14 152.96,88.14 153.08,88.02 162.21,88.02 162.46,87.78 168.11,87.78 170.4,90.07 171,90.07 v2(172.15,91.22)
  BOTTOM w0.102: v2(172.15,91.22) 172.15,91.3 172.54,91.68 v3(172.92,91.68)
UART0_TX: length 31.7
  TOP w0.102: CN3.2 172.81,93.22 172.15,92.57 v2(172.15,92.19) ; v1(149.04,90.82) 149.04,90.51 v2(148.38,89.85) 148.76,89.47 148.76,88.91 148.58,88.73 148.58,88.38 U2.AV44
  L3 w0.127: v2(148.38,89.85) 148.99,89.85 149.41,90.27 152.12,90.27 154.11,88.28 162.32,88.28 162.56,88.04 168.01,88.04 170.3,90.32 170.65,90.32 171.23,90.89 171.23,91.26 v2(172.15,92.19)
USB2_COMP: length 3.3
  TOP w0.102: v2(143.4,68.87) 143.4,68.28 U2.AG3
  BOTTOM w0.102: R188.1 143.83,67.98 144.29,68.44 144.29,68.87 v3(144.26,68.9) 143.42,68.9 v2(143.4,68.87)
USB2_ID: length 3
  TOP w0.102: U2.AG2 143.24,67.45 143.2,67.41 143.2,67.27 143.11,67.18 143.11,67.18 143.07,67.14 143.07,66.66 v2(143.05,66.63)
  BOTTOM w0.102: R189.1 143.2,66.48 v2(143.05,66.63) 142.54,67.14 v3(142.54,67.27)
USB2_VBUSSENSE: length 4.7
  TOP w0.102: v2(141.01,71.39) 141.2,71.2 U2.AD10
  BOTTOM w0.102: v2(141.01,71.39) 141.38,71.02 v3(142.07,71.02) 142.86,71.02 143.26,71.42 144,71.42 R190.1
USB3_RX1_DN: length 118.6
  TOP w0.102: v5(126.91,70.27) 126.91,70.05 127.12,69.84 129.42,69.84 129.75,70.16 130.06,70.16 130.12,70.22 130.37,70.22 130.68,69.9 U2.B7 ; v2(182.29,113.78) 182.67,114.16 183.3,114.16 183.52,113.95 L20.1
  L4 w0.127: v2(182.29,113.78) 182.64,114.13 184.4,114.13 184.9,113.63 184.9,88.86 176.89,80.84 176.89,76.24 170.95,70.3 170.95,61.31 168.42,58.79 145.94,58.79 142.72,62 141.44,62 141.31,62.14 140.93,62.14 140.79,62 140.41,62 140.27,62.14 139.89,62.14 139.75,62 139.37,62 139.23,62.14 138.85,62.14 138.72,62 138.33,62 138.13,62.2 133.15,62.2 129.58,65.77 129.22,65.77 127.74,67.26 127.74,67.69 127.09,68.33 127.09,69.56 127.01,69.65 127.01,70.17 v5(126.91,70.27)
USB3_RX1_DP: length 118.6
  TOP w0.102: v6(182.31,114.74) 182.68,114.37 183.26,114.37 183.51,114.63 L20.4 ; v2(126.51,69.65) 126.64,69.78 126.87,69.78 127.03,69.62 129.51,69.62 129.84,69.94 130.23,69.94 U2.A7
  L4 w0.127: v6(182.31,114.74) 182.66,114.4 184.51,114.4 185.17,113.74 185.17,88.75 177.16,80.73 177.16,76.13 171.21,70.19 171.21,61.2 168.54,58.52 145.83,58.52 142.61,61.73 138.22,61.73 138.02,61.94 133.04,61.94 129.47,65.51 129.11,65.51 127.47,67.14 127.47,67.58 126.83,68.22 126.83,69.34 126.56,69.61 126.56,69.61 126.51,69.66 126.51,69.65 v2(126.51,69.65)
USB3_RX2_DN: length 88.7
  TOP w0.102: v2(183.74,92.57) 184.12,92.95 184.55,92.95 184.76,92.74 L18.1 ; U2.C8 131.13,70.5 130.8,70.83 130.47,70.83 130.34,70.69 130.12,70.69 129.81,71 129.37,71 129.23,70.87 129.12,70.87 128.72,70.47 v2(128.47,70.47)
  L4 w0.127: v2(128.47,70.47) 128.49,70.45 128.49,69.79 129.44,68.84 129.44,68.35 131.33,66.46 132.79,66.46 135.65,63.6 142.91,63.6 146.39,60.12 153.9,60.12 154.34,60.55 168.38,60.55 169.82,61.99 169.82,70.77 175.44,76.39 175.44,81 181.55,87.11 181.55,91.25 182.9,92.59 183.71,92.59 v2(183.74,92.57)
USB3_RX2_DP: length 88.7
  TOP w0.102: v2(183.71,93.46) 184,93.17 184.51,93.17 184.76,93.42 L18.4 ; U2.B8 130.52,70.48 130.03,70.48 129.72,70.79 129.46,70.79 129.33,70.66 v2(129.33,70.45)
  L4 w0.127: v2(183.71,93.46) 183.38,93.13 183.38,92.99 183.25,92.86 182.79,92.86 181.29,91.36 181.29,89.49 181.15,89.35 181.15,88.97 181.29,88.83 181.29,88.45 181.15,88.32 181.15,87.93 181.29,87.8 181.29,87.22 177.38,83.31 177.18,83.31 176.91,83.04 176.91,82.84 176.64,82.57 176.45,82.57 176.18,82.3 176.18,82.11 175.91,81.84 175.72,81.84 175.45,81.57 175.45,81.38 175.18,81.11 175.18,76.5 169.55,70.88 169.55,62.1 168.27,60.82 154.23,60.82 153.79,60.39 153.13,60.39 153,60.52 152.61,60.52 152.48,60.39 150.85,60.39 150.72,60.52 150.34,60.52 150.2,60.39 149.82,60.39 149.68,60.52 149.3,60.52 149.16,60.39 146.5,60.39 143.02,63.87 138.86,63.87 138.73,64 138.35,64 138.21,63.87 137.83,63.87 137.69,64 137.31,64 137.17,63.87 136.79,63.87 136.66,64 136.27,64 136.14,63.87 135.76,63.87 132.9,66.72 131.44,66.72 131.18,66.99 131.18,67.19 130.91,67.46 130.71,67.46 130.44,67.73 129.71,68.46 129.71,68.95 128.76,69.9 128.76,70.03 128.94,70.21 129.1,70.21 v2(129.33,70.45)
USB3_TX1_C_DN: length 131.4
  TOP w0.102: C347.1 180.45,116.58 180.16,116.58 v2(179.77,116.19) ; v2(126.71,71.61) 126.97,71.87 128.82,71.87 129.28,71.4 130.86,71.4 131.1,71.64 U2.C11
  L4 w0.127: v2(179.77,116.19) 180.12,116.53 181.29,116.53 181.42,116.4 181.81,116.4 181.94,116.53 182.32,116.53 182.46,116.4 182.84,116.4 182.98,116.53 183.36,116.53 183.5,116.4 183.88,116.4 184.02,116.53 184.62,116.53 185.89,115.27 185.89,113.46 185.75,113.32 185.75,112.94 185.89,112.8 185.89,112.42 185.75,112.29 185.75,111.91 185.89,111.77 185.89,111.39 185.75,111.25 185.75,110.87 185.89,110.73 185.89,105.65 185.75,105.51 185.75,105.13 185.89,105 185.89,104.62 185.75,104.48 185.75,104.1 185.89,103.96 185.89,103.58 185.75,103.44 185.75,103.06 185.89,102.92 185.89,88.82 177.65,80.58 177.65,76.02 171.65,70.01 171.65,61.02 168.71,58.09 145.48,58.09 142.26,61.3 141.08,61.3 140.74,60.96 132.53,60.96 129.86,63.62 129.86,64.15 125.43,68.58 125.43,69.43 125.57,69.57 125.57,69.95 125.43,70.09 125.43,70.47 125.57,70.6 125.57,70.99 125.43,71.12 125.43,71.5 125.91,71.98 126.34,71.98 v2(126.71,71.61)
USB3_TX1_C_DP: length 131.4
  TOP w0.102: C348.1 180.56,116.79 180.19,116.79 v6(179.77,117.21) ; v2(126.71,72.5) 126.71,72.35 126.98,72.08 128.91,72.08 129.37,71.62 130.65,71.62 U2.B11
  L4 w0.127: v6(179.77,117.21) 180.18,116.8 184.73,116.8 186.16,115.38 186.16,88.71 177.92,80.47 177.92,75.91 171.91,69.9 171.91,60.91 168.82,57.82 145.37,57.82 142.15,61.03 141.19,61.03 140.85,60.69 132.42,60.69 129.6,63.51 129.6,64.03 125.16,68.47 125.16,71.61 125.8,72.25 126.46,72.25 v2(126.71,72.5)
USB3_TX1_EMI_DN: length 2.2
  TOP w0.102: C347.2 182.05,116.51 183.13,116.51 183.4,116.23 L19.1
USB3_TX1_EMI_DP: length 2.2
  TOP w0.102: L19.4 183.33,116.91 183.14,116.72 182.08,116.72 C348.2
USB3_TX2_C_DN: length 90.7
  TOP w0.102: v6(183.23,89.22) 182.83,89.62 182.83,90.1 C349.1 ; v2(128.84,73.34) 129.05,73.13 130.02,73.13 130.6,72.54 130.6,72.41 U2.B12
  L4 w0.127: v2(128.84,73.34) 128.62,73.12 127.87,73.12 127.44,72.68 127.44,69.83 128.4,68.86 128.4,68.28 129.96,66.72 129.96,66 133.31,62.65 142.69,62.65 146.12,59.22 153.99,59.22 154.63,59.85 168.88,59.85 170.52,61.49 170.52,70.48 176.14,76.1 176.14,80.71 182.96,87.53 182.96,88.95 v6(183.23,89.22)
USB3_TX2_C_DP: length 90.3
  TOP w0.102: C350.1 182.61,90.05 182.61,89.56 v2(182.26,89.21) ; U2.A12 130.38,72.39 130.38,72.44 130.39,72.44 130.39,72.45 129.93,72.91 129.18,72.91 v2(128.85,72.57)
  L4 w0.127: v2(128.85,72.57) 128.57,72.85 127.98,72.85 127.7,72.57 127.7,72.19 127.84,72.05 127.84,71.67 127.7,71.53 127.7,69.94 128.67,68.97 128.67,68.39 130.23,66.83 130.23,66.11 133.43,62.91 133.81,62.91 133.94,63.05 134.32,63.05 134.46,62.91 134.84,62.91 134.98,63.05 135.36,63.05 135.5,62.91 135.88,62.91 136.02,63.05 136.4,63.05 136.53,62.91 136.92,62.91 137.05,63.05 137.43,63.05 137.57,62.91 142.8,62.91 146.23,59.49 147.16,59.49 147.3,59.62 147.68,59.62 147.81,59.49 148.19,59.49 148.33,59.62 148.71,59.62 148.85,59.49 149.23,59.49 149.37,59.62 149.75,59.62 149.89,59.49 150.27,59.49 150.4,59.62 150.79,59.62 150.92,59.49 151.3,59.49 151.44,59.62 151.82,59.62 151.96,59.49 153.88,59.49 154.52,60.12 168.77,60.12 170.25,61.6 170.25,70.59 175.88,76.22 175.88,80.82 182.7,87.64 182.7,88.78 v2(182.26,89.21)
USB3_TX2_EMI_DN: length 6
  TOP w0.102: C349.2 182.79,91.78 182.79,94.32 184.11,95.64 184.6,95.64 184.83,95.4 L17.1
USB3_TX2_EMI_DP: length 6.3
  TOP w0.102: C350.2 182.57,91.75 182.57,94.4 184.02,95.85 184.6,95.85 184.83,96.08 L17.4
USB_EN: length 6
  TOP w0.102: v2(83.84,54.77) 83.38,55.23 82.99,55.23 R508.2 82.82,55.4 C373.1 82.76,56.54 C372.1
  BOTTOM w0.102: v2(83.84,54.77) 84.07,54.54 v3(84.75,54.54) 84.75,55.51 Q29.4
USB_EN1: length 12
  TOP w0.102: Q30.G 78.16,55.12 78.45,55.41 78.45,56.32 78.48,56.35 78.48,57.52 79.27,58.3 79.27,58.88 R512.1 79.52,59.79 79.52,61.69 78.99,62.22 78.85,62.22 Q31.D 78.59,63.02 78.94,63.36 v1(80.21,63.36) 80.21,62.36 R509.2
USB_EN2: length 10.6
  TOP w0.102: R508.1 R510.1 81.58,54.41 81.31,54.14 79.39,54.14 79.08,54.45 79.08,56.96 Q30.D 79.14,57.67 79.62,58.16 79.62,58.72 R507.2 81.13,59.18 v1(81.37,58.94)
USB_OC0_R_N: length 11.3
  TOP w0.102: R1812.1 144.2,95.53 v1(144.2,95.26) 144.2,94.5 142.86,93.15 142.75,93.15 142.49,92.89 142.49,91.54 142.94,91.09 142.94,90.51 142.49,90.06 142.49,89.35 142.06,88.92 142.06,88.2 141.67,87.81 U2.AD43
USB_OC4_R_N: length 10.7
  TOP w0.102: R1817.1 139.77,97.08 139.77,95.62 139.67,95.52 139.67,93.53 v1(139.45,93.32) 139.01,92.87 139.01,90 139.44,89.57 139.44,89.04 139.21,88.81 139.21,88.43 139.17,88.39 139.17,87.96 139.39,87.74 U2.Y43
USB_OC5_R_N: length 7.5
  TOP w0.102: U2.Y41 139.33,86.73 v2(138.78,86.18)
  BOTTOM w0.102: R1815.1 139.62,92.02 v3(139.62,90.84) 139.44,90.66 139.44,89.69 139.24,89.48 139.24,89.12 139.03,88.92 139.03,87.41 139.26,87.19 139.26,86.83 138.78,86.35 v2(138.78,86.18)
USB_OC6_R_N: length 8.9
  TOP w0.102: R1816.1 139.12,96.18 139.12,95.23 v1(139.11,95.21) 139.11,93.97 138.78,93.64 138.78,89.94 139.24,89.48 139.24,89.12 139.01,88.9 139.01,88.52 138.88,88.39 U2.W44
USB_OC7_R_N: length 7.5
  TOP w0.102: U2.W43 138.88,87.59 138.63,87.84 138.63,88.44 138.37,88.69 138.37,88.98 138.37,88.98 138.37,91.09 v1(138.2,91.26) 138.55,91.6 138.55,93.29 138.03,93.81 R1820.1
USB_PCH_DN1: length 78
  TOP w0.102: U2.AF5 142.78,69.13 142.59,69.33 v2(142.18,69.33) ; 180.26,110.33 177.09,110.33 v2(176.79,110.63) ; 180.26,110.33 181.05,110.33 181.29,110.56 TR1.4 ; 180.26,110.33 v1(180.26,110.68)
  L4 w0.127: v2(176.79,110.63) 177.06,110.36 177.5,110.36 178.01,109.85 178.01,99.69 173.73,95.41 173.73,87.8 168.66,82.73 168.66,75.97 167.44,74.75 163.22,74.75 161.89,73.42 161.89,71.77 160.48,70.36 155.35,70.36 155.09,70.09 154.26,70.09 151.47,67.31 146.28,67.31 145.84,67.75 145.84,68.1 144.61,69.33 143.34,69.33 143.08,69.59 142.44,69.59 v2(142.18,69.33)
USB_PCH_DN2: length 68.4
  TOP w0.102: v2(180.41,101.31) 180.33,101.31 179.88,101.76 179.88,101.98 R80050.1 ; U2.AD5 141.53,69.11 141.25,69.11 v2(141.17,69.02)
  L4 w0.127: v2(180.41,101.31) 180.19,101.09 180.19,99.77 178.08,97.66 178.08,97.46 177.81,97.19 177.62,97.19 177.35,96.92 177.35,96.73 177.08,96.46 176.88,96.46 175.06,94.64 175.06,88.14 173.19,86.27 169.36,82.44 169.36,75.68 167.73,74.05 163.73,74.05 162.65,72.98 162.65,71.54 160.4,69.28 155.27,69.28 152.8,66.81 151.38,66.81 146.05,66.81 145.32,67.54 145.32,67.92 144.74,68.5 144.23,68.5 143.79,68.07 143.1,68.07 142.57,68.6 141.77,68.6 141.35,69.02 v2(141.17,69.02)
  BOTTOM w0.102: v2(180.41,101.31) 180.36,101.31 180.1,101.56 180.1,101.92 180.28,102.09 U9625.2 ; v3(141.25,68.43) v2(141.17,69.02)
USB_PCH_DN2_M: length 2.3
  TOP w0.102: R80051.1 179.55,104.49 179.55,103.45 R80050.2
USB_PCH_DN3: length 44.5
  TOP w0.102: U2.AG8 143.24,70.43 v2(143.44,70.23) ; TR3.4 126.52,37.97 126.29,38.2 126.29,38.96 v2(126.59,39.26)
  L3 w0.127: v2(126.59,39.26) 126.57,39.26 126.31,39.52 126.31,42.64 131.69,48.01 131.69,58.12 133.61,60.04 133.61,60.88 133.61,61.24 135.36,62.99 137.17,62.99 137.69,63.51 137.69,65.72 137.96,65.99 138.21,65.99 139.41,67.19 142.36,67.19 142.94,67.78 142.94,69.73 v2(143.44,70.23)
  BOTTOM w0.102: v3(126.38,39.84) v2(126.59,39.26)
USB_PCH_DN4: length 40.9
  TOP w0.102: TR4.1 128,37.97 128.23,38.2 128.23,38.96 v2(127.93,39.26) ; v2(142.25,65.72) 142.05,65.92 142.05,66.98 U2.AE1
  L3 w0.127: v2(127.93,39.26) 128.21,39.54 128.21,43.92 132.12,47.84 132.12,51.27 133.43,52.58 133.43,56.94 133.44,56.95 133.44,58.44 134.04,59.04 134.04,61.06 135.54,62.56 138.33,62.56 139.35,63.57 139.35,65.52 140.68,66.85 141.66,66.85 142.03,66.48 142.03,66 142.25,65.78 v2(142.25,65.72)
  BOTTOM w0.102: v3(128.03,39.86) v2(127.93,39.26)
USB_PCH_DN5: length 38.9
  TOP w0.089: 140.77,66.51 140.81,66.55 140.84,66.58 140.84,67.18 140.93,67.27 140.93,67.58 U2.AC2
  TOP w0.102: v2(137.05,61.43) 136.73,61.75 136.73,62.65 ; 136.73,62.65 136.73,63.5 137.44,64.21 139.25,64.21 140.15,65.11 140.15,65.89 140.77,66.51 ; 136.73,62.65 v1(137.1,62.65) ; v2(140.05,39.26) 139.75,38.96 139.75,38.2 139.98,37.97 TR5.4
  L3 w0.127: v2(137.05,61.43) 137.05,61.43 136.78,61.16 136.78,59.53 137.51,58.8 140.95,58.8 141.68,58.07 141.68,47.36 141.68,47.35 141.68,45.33 139.78,43.43 139.78,40.68 139.9,40.56 139.9,40.22 139.78,40.1 139.78,39.54 v2(140.05,39.26)
USB_PCH_DN6: length 35.5
  TOP w0.102: U2.AF2 142.57,67.3 142.57,66.48 142.9,66.15 142.9,65.45 142.46,65.01 141.42,65.01 141.25,64.84 141.25,64.74 v2(141.62,64.37) ; TR6.4 142.14,37.97 141.91,38.2 141.91,39.06 v2(142.21,39.36)
  L3 w0.127: v2(142.21,39.36) 142.19,39.36 141.93,39.61 141.93,40.27 142.07,40.41 142.07,40.79 141.93,40.93 141.93,41.31 142.07,41.45 142.07,41.83 141.93,41.97 141.93,42.35 142.07,42.48 142.07,42.86 141.93,43 141.93,44.24 142.7,45.01 142.7,55.24 144.35,56.89 144.35,59.58 143.66,60.28 143.66,62.01 142.31,63.36 141.82,63.36 141.47,63.71 141.47,64.22 v2(141.62,64.37)
  BOTTOM w0.102: v3(142.25,39.95) v2(142.21,39.36)
USB_PCH_DN8: length 201.3
  TOP w0.102: U2.AL8 145.49,70.9 145.58,70.9 145.6,70.92 v2(145.61,70.92) ; v2(19.17,127.29) 19.17,127.49 18.78,127.89 18.67,127.89 18.38,128.18 18.38,129.17 18.27,129.28 TR13.4
  L3 w0.127: v2(71.47,132.29) 71.79,132.61 71.79,132.78 71.61,132.96 70.81,132.96 68.93,131.08 63.8,131.08 62.3,132.57 50.26,132.57 49.32,133.52 49.32,134.33 49.07,134.58 47.31,134.58 46.47,133.74 44.09,133.74 42.97,134.86 39.18,134.86 33.58,129.26 25.76,129.26 24.46,130.57 22.39,130.57 21.87,130.05 21.13,130.05 20.14,129.05 20.14,128.19 19.24,127.29 v2(19.17,127.29)
  L4 w0.127: v2(145.61,70.92) 145.51,70.92 145.07,71.36 145.07,72.03 144.51,72.59 141.96,72.59 141.68,72.87 140.92,72.87 140.73,73.06 140.73,73.49 139.15,75.08 139.15,75.46 138.51,76.1 138.28,76.1 137.85,76.53 137.85,81.2 136.06,82.99 136.06,86.05 135.96,86.15 135.96,86.52 136.06,86.61 136.06,88.84 134.69,90.21 134.69,92.18 133.35,93.52 133.35,94.34 133.24,94.45 133.24,94.45 132.83,94.86 132.83,99.76 135.53,102.45 135.53,118.38 132.58,121.32 132.58,127.9 131.67,128.81 131.67,132.12 127.05,136.73 92.21,136.73 90.81,135.33 80.71,135.33 78.88,133.5 72.25,133.5 71.77,133.03 71.77,132.59 v2(71.47,132.29)
  BOTTOM w0.102: v3(19.65,126.94) v2(19.17,127.29)
USB_PCH_DN8_NN: length 6.6
  TOP w0.102: TOUCH2.4 15.63,133.1 16.02,133.49 16.36,133.49 C522.1 17.49,133.42 18.1,133.42 18.5,133.01 18.5,132.4 ; 18.5,132.4 18.5,131.5 18.27,131.27 TR13.3 ; 18.5,132.4 v1(18.15,132.4)
USB_PCH_DN9: length 194.2
  TOP w0.102: TR7.4 179.81,202.16 180.05,201.93 180.05,201.3 ; v2(138.82,64.87) 138.82,65.07 139.31,65.57 139.31,65.9 139.73,66.32 139.73,66.9 139.84,67 U2.AA1 ; 180.05,201.3 180.05,200.88 180.44,200.48 180.84,200.48 181.06,200.26 v2(181.06,200.08) ; 180.05,201.3 v1(179.66,201.3)
  L4 w0.127: v2(181.06,200.08) 180.79,200.35 180.24,200.35 179.93,200.04 179.93,154.49 182.12,152.3 183.21,152.3 188.05,147.45 188.05,132.78 184.5,129.22 184.5,128.58 178.72,122.81 178.72,115.26 184.47,109.51 184.47,95.34 179.01,89.88 179.01,86.04 174.74,81.78 174.74,76.68 169.08,71.02 169.08,62.24 168.19,61.35 146.29,61.35 142.78,64.87 138.82,64.87 v2(138.82,64.87)
USB_PCH_DN9_NN: length 8.1
  TOP w0.102: WEBCM1.2 176.4,209.73 176.92,209.21 176.92,208.76 178.18,207.5 178.63,207.05 179.68,205.99 ; TR7.3 179.81,204.35 180.05,204.58 180.05,205.63 179.68,205.99 ; 179.68,205.99 v1(179.44,205.75)
USB_PCH_DN10: length 182
  TOP w0.102: U2.AJ8 144.14,70.54 144.41,70.8 144.57,70.8 v2(144.6,70.83) ; v2(130.85,128.46) 131.13,128.18 131.37,128.18 131.53,128.34 131.53,135.1 117.63,148.99 117.63,225.72 ; TR12.4 118.72,230.6 118.49,230.37 118.01,230.37 117.63,229.99 117.63,225.72 ; 117.63,225.72 v1(117.24,225.72)
  L4 w0.127: v2(144.6,70.83) 144.37,70.83 144.16,71.04 144.16,71.32 143.59,71.88 143.09,71.88 142.58,71.37 141.69,71.37 141.18,70.86 139.88,70.86 139.48,71.27 139.48,71.85 138.76,72.57 137.47,72.57 137.11,72.93 137.11,74.98 137.2,75.07 137.2,80.77 135.76,82.21 135.09,82.21 134.75,82.54 134.75,85.02 135.36,85.63 135.36,86.94 134.86,87.44 134.86,88.84 133.57,90.13 133.54,90.13 132.65,91.02 132.65,94.05 132.54,94.16 132.54,94.16 132.12,94.58 132.12,101.61 134.74,104.23 134.74,117.76 131.77,120.74 131.77,127.6 131.45,127.91 131.4,127.91 v2(130.85,128.46)
USB_PCH_DN10_NN: length 5.5
  TOP w0.102: NGFF1.5 124.04,229.75 123.89,229.6 122.54,229.6 121.77,230.37 121.63,230.37 ; 121.63,230.37 120.98,230.37 120.74,230.6 TR12.3 ; 121.63,230.37 v1(121.63,230.78)
USB_PCH_DP1: length 78
  TOP w0.102: v2(142.18,70.09) 142.54,69.73 142.63,69.73 142.69,69.67 U2.AG7 ; TR1.1 181.29,109.88 181.05,110.11 178.22,110.11 ; 178.22,110.11 v1(178.22,109.76) ; 178.22,110.11 177.09,110.11 v2(176.79,109.82)
  L4 w0.127: v2(142.18,70.09) 142.42,69.85 143.19,69.85 143.45,69.59 144.72,69.59 146.1,68.22 146.1,67.86 146.39,67.58 151.36,67.58 151.63,67.84 151.63,68.04 151.9,68.31 152.1,68.31 152.37,68.58 152.37,68.77 152.64,69.04 152.83,69.04 154.14,70.36 154.98,70.36 155.24,70.62 155.62,70.62 155.76,70.76 156.14,70.76 156.28,70.62 156.66,70.62 156.8,70.76 157.18,70.76 157.31,70.62 160.37,70.62 161.63,71.88 161.63,73.53 163.11,75.02 167.33,75.02 168.39,76.08 168.39,82.84 173.46,87.91 173.46,95.52 175.46,97.52 175.46,97.72 175.73,97.99 175.93,97.99 177.74,99.8 177.74,105.97 177.6,106.1 177.6,106.49 177.74,106.62 177.74,107 177.6,107.14 177.6,107.52 177.74,107.66 177.74,108.04 177.6,108.18 177.6,108.56 177.74,108.7 177.74,109.74 177.39,110.09 177.06,110.09 v2(176.79,109.82)
USB_PCH_DP2: length 68
  TOP w0.102: v2(179.65,101.31) 178.86,102.09 R80052.1 ; U2.AD7 141.68,69.67 141.6,69.76 141.19,69.76 v2(141.17,69.79)
  L4 w0.127: v2(141.17,69.79) 141.17,69.66 141.65,69.18 141.65,69.1 141.88,68.87 142.68,68.87 143.21,68.33 143.68,68.33 144.12,68.77 144.85,68.77 145.59,68.03 145.59,67.65 146.16,67.08 151.49,67.08 152.69,67.08 155.16,69.55 160.28,69.55 162.39,71.65 162.39,73.09 163.62,74.32 167.62,74.32 169.09,75.79 169.09,82.55 173.45,86.91 174.8,88.25 174.8,94.75 179.93,99.88 179.93,101.03 v2(179.65,101.31)
  BOTTOM w0.102: U9625.3 179.78,102.1 179.89,101.99 179.89,101.52 179.67,101.31 v2(179.65,101.31) ; v3(141.03,70.38) v2(141.17,69.79)
USB_PCH_DP2_M: length 2.7
  TOP w0.102: R80053.1 179.33,104.48 179.33,103.95 ; 179.33,103.95 179.33,103.47 R80052.2 ; 179.33,103.95 v1(178.96,103.95)
USB_PCH_DP3: length 45.5
  TOP w0.102: TR3.1 125.84,37.97 126.07,38.2 126.07,38.96 v2(125.77,39.26) ; U2.AG10 143.24,71.2 v2(143.44,70.99)
  L3 w0.127: v2(143.44,70.99) 143.35,70.99 143.26,70.9 143.26,70.67 143,70.41 143,70.16 142.68,69.84 142.68,69.73 142.68,67.89 142.25,67.46 139.3,67.46 138.1,66.26 137.85,66.26 137.42,65.83 137.42,63.63 137.06,63.26 135.25,63.26 133.34,61.35 133.34,60.77 133.34,60.77 133.34,60.15 131.43,58.23 131.43,48.13 126.78,43.48 126.59,43.48 126.32,43.21 126.32,43.02 126.05,42.75 126.05,39.54 v2(125.77,39.26)
  BOTTOM w0.102: v3(125.52,38.71) v2(125.77,39.26)
USB_PCH_DP4: length 40.8
  TOP w0.102: U2.AE2 141.84,67.27 141.84,66.01 v2(141.49,65.67) ; TR4.4 128.68,37.97 128.45,38.2 128.45,38.96 v2(128.75,39.26)
  L3 w0.127: v2(128.75,39.26) 128.73,39.26 128.47,39.52 128.47,43.81 132.39,47.73 132.39,51.16 133.7,52.47 133.7,56.83 133.71,56.84 133.71,58.33 134.31,58.93 134.31,60.95 135.65,62.29 138.44,62.29 139.62,63.46 139.62,65.41 140.79,66.58 141.55,66.58 141.76,66.37 141.76,65.94 v2(141.49,65.67)
  BOTTOM w0.102: v3(129.02,38.72) v2(128.75,39.26)
USB_PCH_DP5: length 39.3
  TOP w0.089: U2.AC3 140.96,67.98 140.74,67.76 140.74,67.35 140.65,67.26 140.65,66.7 140.62,66.66
  TOP w0.102: 137.71,64.43 137.36,64.43 136.52,63.59 136.52,61.65 v2(136.29,61.43) ; 137.71,64.43 139.16,64.43 139.93,65.2 139.93,65.98 140.62,66.66 ; 137.71,64.43 v1(137.71,64.78) ; v2(139.24,39.26) 139.53,38.96 139.53,38.2 139.3,37.97 TR5.1
  L3 w0.127: v2(139.24,39.26) 139.51,39.54 139.51,43.54 141.41,45.44 141.41,47.46 141.41,47.47 141.41,57.96 140.84,58.53 137.4,58.53 136.52,59.42 136.52,61.2 v2(136.29,61.43)
USB_PCH_DP6: length 35.7
  TOP w0.102: TR6.1 141.46,37.97 141.69,38.2 141.69,39.06 v2(141.39,39.36) ; U2.AF3 142.35,67.59 142.35,66.39 142.69,66.06 142.69,65.54 142.37,65.23 141.33,65.23 141.04,64.93 141.04,64.55 v2(140.86,64.38)
  L3 w0.127: v2(140.86,64.38) 141.19,64.04 141.19,63.61 141.71,63.09 142.19,63.09 143.39,61.9 143.39,60.17 144.09,59.47 144.09,57 142.44,55.35 142.44,45.12 141.67,44.35 141.67,39.63 v2(141.39,39.36)
  BOTTOM w0.102: v3(141.61,38.78) v2(141.39,39.36)
USB_PCH_DP8: length 201.1
  TOP w0.102: v2(19.22,128.1) 18.76,128.1 18.6,128.27 18.6,129.21 18.95,129.56 TR13.1 ; v2(145.61,70.07) 145.61,70.06 145.32,69.77 U2.AL7
  L3 w0.127: v2(19.22,128.1) 19.67,128.1 19.87,128.3 19.87,129.16 21.02,130.31 21.76,130.31 22.28,130.84 24.57,130.84 25.88,129.53 33.47,129.53 39.07,135.13 43.08,135.13 44.2,134.01 46.36,134.01 47.2,134.85 49.18,134.85 49.59,134.44 49.59,133.63 50.37,132.84 62.41,132.84 63.91,131.34 68.82,131.34 70.7,133.22 71.72,133.22 72.05,132.89 72.05,132.35 v2(72.25,132.15)
  L4 w0.127: v2(72.25,132.15) 72.04,132.36 72.04,132.92 72.36,133.23 78.99,133.23 80.82,135.06 90.92,135.06 92.32,136.47 126.94,136.47 131.4,132.01 131.4,128.7 132.31,127.79 132.31,121.21 135.26,118.26 135.26,102.56 132.57,99.87 132.57,94.74 132.97,94.34 132.97,94.34 133.08,94.23 133.08,93.4 134.42,92.06 134.42,90.1 135.79,88.72 135.79,86.72 135.7,86.63 135.7,86.04 135.79,85.94 135.79,82.88 137.58,81.09 137.58,76.41 138.17,75.83 138.4,75.83 138.88,75.35 138.88,74.97 140.47,73.38 140.47,72.95 140.81,72.6 141.57,72.6 141.85,72.33 144.4,72.33 144.8,71.92 144.8,71.25 145.17,70.88 145.17,70.73 145.32,70.58 145.32,70.36 v2(145.61,70.07)
  BOTTOM w0.102: v3(19.75,128.38) v2(19.22,128.1)
USB_PCH_DP8_PP: length 6.9
  TOP w0.102: v1(17.98,134) 17.98,133.63 ; 17.98,133.63 17.49,133.63 C523.1 16.5,133.71 16.01,133.71 15.61,134.1 TOUCH2.3 ; 17.98,133.63 18.19,133.63 18.72,133.1 18.72,131.58 18.95,131.34 TR13.2
USB_PCH_DP9: length 194.4
  TOP w0.102: v2(181.06,200.89) 180.87,200.7 180.53,200.7 180.26,200.97 180.26,201.93 180.5,202.16 TR7.1 ; v2(138.88,65.77) 139.52,66.41 139.52,67.1 139.84,67.42 U2.AA2
  L4 w0.127: v2(138.88,65.77) 139.52,65.14 142.89,65.14 146.4,61.62 168.08,61.62 168.81,62.35 168.81,71.13 174.48,76.79 174.48,81.89 178.75,86.15 178.75,89.99 184.21,95.45 184.21,109.4 178.45,115.15 178.45,122.92 184.23,128.7 184.23,129.33 187.79,132.89 187.79,147.34 183.1,152.03 182.01,152.03 179.66,154.38 179.66,188 179.52,188.14 179.52,188.52 179.66,188.65 179.66,189.03 179.52,189.17 179.52,189.55 179.66,189.69 179.66,190.07 179.52,190.21 179.52,190.59 179.66,190.73 179.66,195.81 179.52,195.94 179.52,196.32 179.66,196.46 179.66,196.84 179.52,196.98 179.52,197.36 179.66,197.5 179.66,197.88 179.52,198.02 179.52,198.4 179.66,198.53 179.66,200.15 180.13,200.62 180.79,200.62 v2(181.06,200.89)
  BOTTOM w0.102: v3(139.49,65.67) v2(138.88,65.77)
USB_PCH_DP9_PP: length 8.1
  TOP w0.102: WEBCM1.1 177.65,209.73 177.66,209.72 177.14,209.21 177.14,208.85 178.4,207.58 ; 178.4,207.58 180.26,205.72 180.26,204.58 180.5,204.35 TR7.2 ; 178.4,207.58 v1(178.66,207.83)
USB_PCH_DP10: length 182.1
  TOP w0.102: v2(144.57,70.06) 144.57,70.04 144.31,69.77 U2.AJ7 ; v1(118.28,228.22) 117.85,228.22 ; 117.85,228.22 117.85,229.9 118.1,230.15 118.49,230.15 118.72,229.92 TR12.1 ; 117.85,228.22 117.85,149.08 131.74,135.19 131.74,128.25 131.45,127.95 131.16,127.95 v2(130.85,127.65)
  L4 w0.127: v2(144.57,70.06) 144.15,70.48 144.15,70.66 143.89,70.93 143.89,71.21 143.48,71.61 143.2,71.61 142.69,71.11 141.8,71.11 141.29,70.6 139.77,70.6 139.21,71.16 139.21,71.74 138.65,72.3 137.36,72.3 136.84,72.82 136.84,75.09 136.93,75.18 136.93,80.66 135.65,81.94 134.98,81.94 134.49,82.43 134.49,85.13 135.1,85.74 135.1,86.83 134.6,87.33 134.6,88.73 133.46,89.86 133.43,89.86 132.38,90.91 132.38,93.94 132.28,94.05 132.28,94.05 131.86,94.47 131.86,101.72 134.47,104.34 134.47,117.65 131.5,120.63 131.5,127.49 131.34,127.65 v2(130.85,127.65)
USB_PCH_DP10_PP: length 5.5
  TOP w0.102: 122.6,229.39 123.94,229.39 124.08,229.25 NGFF1.3 ; 122.6,229.39 v1(122.6,228.98) ; 122.6,229.39 122.45,229.39 121.68,230.15 120.98,230.15 120.74,229.92 TR12.2
USBDN2_CHAR: length 5.9
  TOP w0.102: TR2.1 181.64,107.6 181.4,107.83 180.42,107.83 180.09,107.5 180.09,107.01 v2(180.43,106.67) ; R80051.2 180,106.23 v2(180.43,106.67) ; v2(180.43,106.67) 180.48,106.62 v1(181.04,106.41)
  BOTTOM w0.102: U9625.11 180.28,105.93 180.13,106.08 180.13,106.36 v2(180.43,106.67)
USBDP2_CHAR: length 6
  TOP w0.102: v1(179.88,108.14) 180.16,107.88 ; 180.16,107.88 179.88,107.59 179.88,106.92 v2(179.57,106.62) 178.86,105.9 R80053.2 ; 180.16,107.88 180.33,108.05 181.25,108.05 181.48,108.28 TR2.4
  BOTTOM w0.102: v2(179.57,106.62) 179.91,106.27 179.91,106.09 179.78,105.96 U9625.10
USBOC01*: length 87
  TOP w0.102: v1(135.83,24.73) 135.81,24.75 R467.2 134.75,24.88 C338.1 R469.1 135.41,27.32 139.18,27.32 139.92,28.05 v2(140.48,28.05) ; v2(141.55,91.06) 141.55,89.73 141.6,89.68 141.6,88.55 141.49,88.43 141.49,88.43 141.44,88.39 141.44,87.35 U2.AD42
  L3 w0.127: v2(140.48,28.05) 143.41,30.99 143.41,50.29 146.22,53.1 146.22,58.71 144.34,60.59 144.34,62.32 143.84,62.82 143.84,68.3 144.26,68.71 145.32,68.71 145.33,68.71 145.89,68.71 146.1,68.92 146.88,68.92 147.14,69.18 147.14,70.37 146.81,70.69 146.8,70.69 146.4,71.1 146.4,71.87 145.44,72.83 145.44,73.32 144.07,74.69 142.83,74.69 142.55,74.97 142.55,75.93 142.03,76.45 142.03,80.1 141.77,80.36 141.77,85.05 141.63,85.2 141.63,86.82 140.24,88.21 140.24,90.2 141.08,91.05 141.53,91.05 v2(141.55,91.06)
USBOC89*: length 88.1
  TOP w0.102: R463.2 v1(125.49,24.87) 125.35,25.01 C334.1 R464.1 124.76,27.29 v2(124.28,27.77) ; U2.AD39 141.73,85.79 141.18,85.25 v2(141.12,85.25)
  L3 w0.127: v2(141.12,85.25) 141.48,84.89 141.48,81.02 141,80.54 141,76.41 142,75.4 142,75.19 142.81,74.38 143.53,74.38 144.01,73.9 144.54,73.9 145.18,73.26 145.18,72.63 146.06,71.76 146.06,69.2 145.8,68.94 145.43,68.94 145.31,69.05 144.22,69.05 143.43,68.25 143.43,66.94 143.53,66.84 143.53,62.75 144.09,62.19 144.09,60.46 144.8,59.75 144.8,57.44 145.53,56.71 145.53,56.32 145.25,56.05 144.77,56.05 143.15,54.42 143.15,38.87 143.16,38.86 143.16,31.16 140.54,28.54 140.07,28.54 139.64,28.1 124.61,28.1 v2(124.28,27.77)
USBOC1011*: length 75.9
  TOP w0.102: v2(180.05,109.54) 177.74,107.22 177.74,101.97 174.95,99.17 174.95,97.71 R472.1 175.39,97.14 R470.2 176.09,96.44 176.09,95.02 175.04,93.97 174.54,93.97 v2(174.31,94.19) ; U2.AC44 141.16,88.39 141.28,88.52 141.28,88.52 141.39,88.63 141.39,89.6 141.1,89.89 v2(141.1,90.04) 140.99,90.15 140.99,92.62 v1(141.34,92.98) 141.34,93.46 141.92,94.03 C12164.1
  L3 w0.127: v2(141.1,90.04) 141.19,90.04 141.79,89.43 143.62,89.43 144.6,90.41 146.22,90.41 147.9,92.09 147.9,94.25 148.96,95.31 149.35,95.31 149.62,95.03 149.62,93.25 154.22,88.64 160.33,88.64 162.26,90.58 170.55,90.58 170.97,91 170.97,91.67 173.49,94.19 v2(174.31,94.19)
  BOTTOM w0.102: v2(180.05,109.54) 180.84,109.54 183.39,106.98 R452.2
USBP1N_EXT: length 15.9
  TOP w0.102: v2(189.64,110.99) 189.29,110.64 186.77,110.64 186.03,109.9 185.41,109.9 D9.4 184.9,109.9 184.61,109.9 184.17,110.34 183.51,110.34 183.29,110.56 TR1.3
  L3 w0.127: SSUSB1.2 192.62,116.3 192.49,116.17 192.08,116.17 190.68,114.78 190.68,110.99 190.39,110.7 189.94,110.7 v2(189.64,110.99)
USBP1P_EXT: length 15.9
  TOP w0.102: v2(189.68,110.1) 189.68,110.13 189.38,110.43 188.12,110.43 D9.3 187.59,110.42 186.85,110.42 186.12,109.69 184.52,109.69 184.08,110.13 183.54,110.13 183.3,109.88 TR1.2
  L3 w0.127: v2(189.68,110.1) 190.01,110.43 190.5,110.43 190.95,110.88 190.95,114.67 192.19,115.91 192.49,115.91 192.62,115.78 SSUSB1.3
USBP2N_EXT: length 26.7
  TOP w0.102: v2(189.71,107.43) 189.36,107.77 186.85,107.77 186.11,108.5 185.41,108.5 D9.6 184.9,108.51 184.48,108.51 183.82,107.85 183.49,107.85 183.24,107.6 TR2.2
  L3 w0.127: SSUSB2.2 192.62,94.8 192.49,94.67 190.31,94.67 189.22,95.77 189.22,95.96 188.95,96.23 188.75,96.23 188.42,96.56 188.42,98.38 188.56,98.52 188.56,98.9 188.42,99.04 188.42,100.9 188.56,101.04 188.56,101.42 188.42,101.55 188.42,101.93 188.56,102.07 188.56,102.45 188.42,102.59 188.42,102.97 188.56,103.11 188.56,103.49 188.42,103.63 188.42,104.12 188.56,104.26 188.56,104.64 188.42,104.77 188.42,105.16 188.56,105.29 188.56,105.67 188.42,105.81 188.42,106.19 188.56,106.33 188.56,106.71 188.42,106.85 188.42,107.45 188.65,107.67 189.46,107.67 v2(189.71,107.43)
USBP2P_EXT: length 26.7
  TOP w0.102: v2(189.71,108.3) 189.4,107.99 188.12,107.99 D9.1 187.58,107.99 186.94,107.99 186.2,108.72 184.39,108.72 183.73,108.06 183.47,108.06 183.26,108.28 TR2.3
  L3 w0.127: SSUSB2.3 192.62,94.28 192.49,94.41 190.2,94.41 188.16,96.45 188.16,107.56 188.54,107.94 189.35,107.94 v2(189.71,108.3)
USBP3N_EXT: length 21.6
  TOP w0.102: USB1.2 120.11,36.34 119.53,36.34 118.76,35.56 118.76,32.63 121.4,29.98 126.28,29.98 126.84,30.54 126.84,32.31 126.12,33.03 126.12,33.84 D10.3 126.12,34.35 126.12,35 126.28,35.16 126.28,35.72 126.52,35.96 TR3.3
USBP3P_EXT: length 20.5
  TOP w0.102: TR3.2 125.84,35.97 126.06,35.74 126.06,35.25 125.9,35.09 125.9,32.95 126.62,32.22 126.62,31.66 D10.4 126.62,31.15 126.62,30.63 126.19,30.2 121.49,30.2 118.97,32.72 118.97,35.47 119.62,36.12 120.11,36.12 USB1.3
USBP4N_EXT: length 31.1
  TOP w0.102: USB2.2 121.89,13.34 123.03,13.34 123.14,13.45 123.45,13.45 123.56,13.34 123.87,13.34 123.98,13.45 124.28,13.45 124.39,13.34 124.7,13.34 124.81,13.45 125.11,13.45 125.23,13.34 126.37,13.34 127.02,13.98 127.02,14.14 127.23,14.35 127.39,14.35 128.76,15.72 128.76,29.74 127.81,30.69 127.81,32.52 128.53,33.25 128.53,33.84 D10.1 128.53,34.35 128.53,34.84 128.22,35.15 128.22,35.76 128,35.99 TR4.2
USBP4P_EXT: length 31.1
  TOP w0.102: TR4.3 128.68,35.96 128.44,35.72 128.44,35.24 128.75,34.93 128.75,33.16 128.02,32.43 128.02,31.66 D10.6 128.02,31.15 128.02,30.78 128.97,29.83 128.97,15.63 126.46,13.12 121.89,13.12 USB2.3
USBP5N_EXT: length 22.4
  TOP w0.102: TR5.3 139.98,35.98 139.77,35.77 139.77,34.22 140.18,33.8 140.18,31.87 139.44,31.13 139.44,30.4 D11.4 139.44,29.87 139.44,29.65 138.98,29.2 135.31,29.2 132.13,32.38 132.13,35.56 132.93,36.37 133.64,36.37 USB3.2
USBP5P_EXT: length 22
  TOP w0.102: TR5.2 139.3,36.02 139.55,35.77 139.55,34.13 139.96,33.71 139.96,33.08 D11.3 139.96,32.57 139.96,31.96 139.22,31.22 139.22,29.74 138.9,29.41 137.76,29.41 137.65,29.53 137.34,29.53 137.23,29.41 136.92,29.41 136.81,29.53 136.51,29.53 136.4,29.41 135.4,29.41 134.89,29.92 134.89,30.08 134.67,30.3 134.51,30.3 134.3,30.51 134.3,30.67 134.08,30.89 133.92,30.89 133.71,31.1 133.71,31.26 133.49,31.48 133.33,31.48 132.34,32.47 132.34,32.77 132.46,32.88 132.46,33.19 132.34,33.3 132.34,33.6 132.46,33.71 132.46,34.02 132.34,34.13 132.34,35.47 133.02,36.15 133.58,36.15 USB3.3
USBP6N_EXT: length 31.2
  TOP w0.102: USB4.2 133.61,13.34 132.67,13.34 132.4,13.61 132.4,14.08 132.51,14.19 132.51,14.49 132.4,14.61 132.4,14.91 132.51,15.02 132.51,15.33 132.4,15.44 132.4,16.85 132.63,17.08 132.79,17.08 133.01,17.3 133.01,17.45 133.22,17.67 133.38,17.67 133.59,17.88 133.59,18.04 133.81,18.26 133.97,18.26 134.18,18.47 134.18,18.63 134.82,19.27 135.19,19.64 135.41,19.86 135.57,19.86 135.78,20.07 135.78,20.23 136.11,20.56 137.87,20.56 138.39,21.08 139.57,22.26 139.57,25.23 140.48,26.15 140.64,26.15 140.85,26.36 140.85,26.52 141.36,27.02 141.36,29.88 D11.6 141.36,30.39 141.36,31.21 142.09,31.95 142.09,34.37 141.92,34.54 141.92,35.74 142.14,35.97 TR6.3
USBP6P_EXT: length 31
  TOP w0.102: TR6.2 141.46,35.98 141.7,35.74 141.7,34.45 141.88,34.28 141.88,33.09 D11.1 141.88,32.56 141.88,32.04 141.14,31.3 141.14,27.11 139.35,25.32 139.35,22.35 137.78,20.78 136.02,20.78 135.32,20.07 132.19,16.94 132.19,13.52 132.58,13.12 133.61,13.12 USB4.3
USBVCC01: length 26.2
  TOP w0.508: v2(186.66,106.67) 183.2,106.67 v2(182.7,106.16) ; D9.5 186.63,109.21 v2(186.76,109.08) ; R470.1 177.04,97.97 177.11,98.03
  TOP w0.635: 192.62,98.93 SSUSB2.1 191.73,98.04 ; TC4.1 180.03,97.81 ; TC4.1 181.08,96.76 ; TC4.1 178.97,96.76 ; TC4.1 180.03,95.71 ; 191.73,119.54 SSUSB1.1 191.94,120.22
  BOTTOM w0.305: v2(182.7,106.16) 182.26,106.16 181.66,105.55 U9625.12
  BOTTOM w0.635: 178.97,96.76 TC4.1 ; TC4.1 180.03,95.71 ; TC4.1 181.08,96.76 ; TC4.1 180.03,97.81 ; 192.62,118.65 SSUSB1.1 ; SSUSB1.1 192.62,120.43 ; SSUSB1.1 191.73,119.54 ; 192.62,98.93 SSUSB2.1 191.73,98.04
  vias: v3(186.73,100.29) v3(187.65,120.13) v3(187.7,110.68) v4(186.76,117.67) v4(188.66,117.59) v4(189.3,98.18)
USBVCC89: length 27.4
  TOP w0.508: C331.1 121.02,27.6 122.24,28.82 126.69,28.82 127.32,29.45 ; 127.32,29.45 127.96,28.82 127.96,25.07 R463.1 ; 127.32,29.45 D10.5
  TOP w0.635: 121,15.7 USB2.1 ; USB2.1 122.03,16.73 ; USB2.1 119.97,16.73 ; USB2.1 121,17.76
  BOTTOM w0.635: 134.5,15.7 USB4.1 ; USB4.1 135.53,16.73 ; USB4.1 133.47,16.73 ; USB4.1 134.5,17.76 ; 119.97,16.73 USB2.1 ; USB2.1 121,15.7 ; USB2.1 121,17.76 ; USB2.1 122.03,16.73
  vias: v3(117.16,14.87) v3(127.81,16.7) v4(115.77,17.39) v4(115.77,16.24)
USBVCC1011: length 35.8
  TOP w0.508: v2(137.1,31.28) 137.1,38.47 136.59,38.98 ; D11.5 140.66,29.32 v2(140.34,29.01) 140.19,29.01 139.36,28.18 135.12,28.18 133.17,26.22 133.17,25.32 R467.1
  TOP w0.635: 133.47,39.73 USB3.1 ; USB3.1 134.5,38.7 ; USB3.1 135.53,39.73 ; USB3.1 134.5,40.76 ; TC2.1 111.11,34.15 ; TC2.1 110.05,35.2 ; TC2.1 109,34.15 ; TC2.1 110.05,33.09 ; 121,38.7 USB1.1 ; USB1.1 119.97,39.73 ; USB1.1 122.03,39.73 ; USB1.1 121,40.76
  L3 w0.508: v2(137.1,31.28) 139.38,29.01 v2(140.34,29.01)
USBVCCTP: length 2.7
  TOP w0.381: v4(14.6,131.18) 15.62,130.16 v1(16.83,130.16)
  vias: v3(14.5,136.89)
V_1P5_HDMI: length 19.9
  TOP w0.203: v2(163.87,48.12) 163.87,47.68 163.67,47.48 U118.40 ; U118.12 157.7,47.08 157.37,47.41 v2(157.37,47.74) ; U118.20 158.38,43.49 158.06,43.17 v2(157.42,43.17) 157.42,43.93 157.77,44.28 U118.19 ; U118.31 163.46,43.48
  TOP w0.508: C12202.1 C12203.1 156.66,42.4 v2(157.42,43.17)
  BOTTOM w0.508: v2(164.76,43.19) 164.92,43.04 C12204.1 ; C12204.1 165.61,43.69 165.27,44.04 165.27,45.73 165.68,46.13 C12206.1 164.95,47.04 v2(163.87,48.12) ; C12204.1 C3366.1 ; v2(157.37,47.74) 156.67,47.04 C12207.1
  vias: v3(153.21,45.63) v4(148,46.26) v4(149.01,46.26)
V_1P05_LAN: length 5.2
  TOP w0.203: v2(61.07,30.82) 61.06,30.81 U9623.22 ; v2(59.39,30.21) 59.98,29.63 U9623.24 ; U9623.30 58.91,26.95 58.62,26.66 58.36,26.66 ; U9623.3 61.06,24.41 v2(61.03,24.37) ; U9623.8 63.14,25.46
  TOP w0.508: v2(57.98,26.66) 58.36,26.66
  vias: v2(63.87,24.47) v3(62.17,24.12)
V_3_CARD: length 16.7
  TOP w0.813: v2(182.19,142.02) 184.4,142.02 187.39,145.02 188.41,145.02 190.19,146.8 v2(190.39,146.8) ; v2(179.04,140.93) 179.05,140.94 MEMCD1.4
  BOTTOM w0.203: v2(190.39,146.8) 190.39,145.91 190.79,145.51 U14.12
  BOTTOM w0.508: v2(190.39,146.8) 189.86,147.33 189.86,147.53 189.25,148.14 C12161.2
  vias: v3(182.62,141.03)
V_3P0_BAT_VREG: length 146.2
  TOP w0.254: v5(149.95,76.65) 149.95,77.14 U2.BA22
  TOP w0.508: v2(167.99,84.42) 167.99,84.11 168.54,83.55 172.8,83.55 v2(173.81,82.55) ; R138.1 147.77,120.45 R146.1 148.91,119.98 v2(149.65,119.24) ; R408.2 180.28,78.09 180.41,77.96 180.54,77.96 v2(181.3,77.2)
  TOP w0.762: D2.3 127.58,100.95 129.66,103.03 130.96,103.03 130.98,103.01 v4(137.21,103.01)
  L3 w0.508: v2(157.8,71.84) 157.8,72.95 154.39,76.36 153,76.36 152.74,76.1 150.5,76.1 v5(149.95,76.65) 150.21,76.9 150.21,76.97 152.75,79.51 160.54,79.51 164.6,83.58 165.83,83.58 166.67,84.42 v2(167.99,84.42) ; v4(137.21,103.01) 137.72,103.52 148.32,103.52 148.32,103.52 149.77,103.52 152.49,103.52 152.82,103.85 v2(153.49,103.85)
  L4 w0.508: v2(153.49,103.85) 149.65,107.68 v2(149.65,119.24) ; v2(173.81,82.55) 178.1,86.84 178.1,90.26 179.27,91.43 v2(179.27,91.68)
  BOTTOM w0.508: v2(157.8,71.84) 157.8,71.82 158.3,71.33 R1835.1 ; v2(181.3,77.2) 175.95,82.55 v2(173.81,82.55) ; v2(153.49,103.85) 154.4,103.85 157.42,100.82 170.76,100.82 v3(173.04,98.54) 179.27,92.32 v2(179.27,91.68)
V_3P3_A: length 623.2
  TOP w0.203: v2(120.69,64.27) 120.69,64.01 119.89,63.21 U109.32 ; U109.64 103.96,64.76 v2(103.83,64.63) ; v2(117.92,51.3) 118.41,50.81 U109.1
  TOP w0.254: v5(149.57,77.85) 149.57,78 150,78.43 U2.BA24 ; U2.W15 139.29,74.02 138.78,73.51 v2(138.78,73.13)
  TOP w0.508: v2(90.62,61.33) 90.01,60.72 90.01,55.25 90.75,54.51 90.75,53.58 89.81,52.64 89.81,48.42 L1.2 90.75,46.21 88.13,43.6 88.13,42.17 87.09,41.13 v2(85.79,41.13) ; R1793.1 41.6,124.57 40.68,123.66 40.68,118.86 40.86,118.68 40.86,116.09 36.98,112.2 36.98,110.5 35.58,109.1 35.58,107.1 34.89,106.41 33.79,106.41 33.44,106.06 33.44,96.56 34.31,95.69 34.31,94.91 v2(36.39,92.82) ; PR8626.1 67.32,39.1 v2(66.87,38.66) 67.44,38.09 PR8625.1 ; R116.2 165.17,74.54 165.63,74.99 v2(165.63,75.49) ; R116.2 165.8,74.22 R123.2 R119.2 166.52,71.97 168.65,71.97 170.62,70 v2(172.7,70) 172.51,70.19 172.51,71.29 176.32,75.1 176.32,77.02 176.82,77.52 R407.1 ; R116.2 164.22,74.22 163.19,73.19 R79780.2 R876.2 ; v2(25.47,16.37) 25.41,16.43 R745.1 ; R320.1 107.16,71.58 v2(107.16,72.1) ; R319.1 114.76,70.42 114.33,70.85 v2(114.24,70.85) 114.69,71.3 R79687.2 R79975.2 ; R389.1 178.24,34.33 178.69,34.78 R79934.1 v2(179.27,33.9) ; v2(160.77,55.55) 160.77,55.52 160.44,55.86 160.1,55.86 159.58,56.38 R120.2 ; R305.1 91.68,65.39 v2(91.14,64.84) ; PR5291.1 72.59,44.75 v2(72.59,44.18) 72.59,43.03 PR5279.1 72.17,42.87 71.95,42.66 v2(71.95,42.1) ; R390.1 182.94,34.8 v2(182.92,34.78) ; v2(108.98,73.04) 108.98,75.12 111.45,77.58 112.85,77.58 114.62,79.36 115.98,79.36 117.54,80.92 117.54,82.83 119.98,85.27 125.16,85.27 127.32,87.43 127.32,91.81 126.56,92.57 126.56,94.79 R80217.1 ; R310.2 92.23,68.72 R309.2 92.72,69.39 93.29,69.96 93.55,69.96 v2(93.6,70.01) R308.2 93.6,71.07 94.04,71.51 94.58,71.51 95.32,72.25 96.87,72.25 98,73.38 v2(98,73.39)
  L3 w0.508: v2(107.16,72.1) 107.64,71.61 107.64,69.8 105.75,67.91 105.75,66.55 v2(103.83,64.63) ; 126.05,62.81 125.36,62.11 125.32,62.11 123.51,60.31 123.51,52.59 121.56,50.63 119.73,50.63 119.06,51.3 v2(117.92,51.3) 117.92,51.03 117.93,51.02 117.93,47.18 120.03,45.08 120.03,40.25 119.95,40.17 119.95,34.39 116.55,31 116.55,14.23 v2(116.02,13.7) ; 126.05,62.81 124.07,62.81 122.61,64.27 v2(120.69,64.27) ; 126.05,62.81 133.92,62.81 134.99,63.88 135.87,63.88 136.8,64.81 136.8,66.09 137.3,66.58 v2(137.31,66.58) 137.31,68.08 138.27,69.05 138.27,69.06 138.5,69.29 138.5,69.67 139.29,70.46 139.29,71.78 139.01,72.06 139.01,72.9 v2(138.78,73.13) ; v2(71.95,42.1) 70.91,42.1 70.17,41.36 70.17,40.45 68.38,38.66 v2(66.87,38.66) 66.76,38.54 65.19,38.54 62.55,35.9 60.93,35.9 60.27,36.56 58.26,36.56 54.03,32.33 54.03,24.95 54.3,24.69 54.3,23.4 53.64,22.74 53.64,18.17 54.16,17.65 54.16,15.84 53.67,15.35 51.63,15.35 51.25,15.73 49.22,15.73 46.93,13.45 44.93,13.45 v2(44.29,12.81) ; v2(91.14,64.84) 92.78,66.49 92.78,68.95 92.84,69.02 92.84,69.25 v2(93.6,70.01) ; v2(137.86,12.43) 138.22,12.79 138.52,12.79 138.91,13.17 138.91,18.14 140.36,19.59 143.63,19.59 145.73,21.69 149.92,21.69 v4(150.56,22.34) 150.56,38.06 151.13,38.63 151.13,47.17 v2(147.92,50.38) ; v2(171.9,16.62) 174.88,19.61 174.88,29.51 v2(179.27,33.9) ; v5(63.82,79.77) 63.82,81.21 57.41,87.62 56.15,87.62 52.34,91.43 50.05,91.43 49.82,91.65 37.76,91.65 36.59,92.82 v2(36.39,92.82)
  L4 w0.508: v2(172.7,70) 172.7,69.74 172.63,69.67 172.63,59.45 171.69,58.51 170.58,58.51 167.59,55.52 160.77,55.52 v2(160.77,55.55) 160.64,55.69 155.78,55.69 155.39,55.3 155.39,54.47 154.55,53.63 153.31,53.63 150.85,51.17 148.71,51.17 v2(147.92,50.38) ; v2(171.9,16.62) 168.83,16.62 162.96,22.49 150.72,22.49 v4(150.56,22.34) ; v2(179.27,33.9) 179.86,33.3 182.4,33.3 183.2,34.1 183.2,34.5 v2(182.92,34.78) ; v2(90.62,61.33) 89.3,61.33 89.12,61.15 84.41,61.15 83.21,62.34 81.7,62.34 79.44,64.6 v4(79.44,68.44) ; v2(116.02,13.7) 118.04,13.7 120.56,11.18 136.61,11.18 v2(137.86,12.43) ; v2(107.16,72.1) 108.1,73.04 v2(108.98,73.04) 112.06,73.04 v2(114.24,70.85) 116.25,68.85 116.25,68.56 117.66,67.15 118.93,65.87 119.2,65.87 120.48,64.59 120.48,64.49 v2(120.69,64.27)
  BOTTOM w0.381: v2(165.63,75.49) 165.63,76.9 163.63,78.89 163.14,78.89 162.6,79.44 153.98,79.44 C11835.1 153.12,79.55 151.97,78.4 150.64,78.4 150.59,78.45 150.05,78.45 149.57,77.97 v5(149.57,77.85)
  BOTTOM w0.508: R313.2 R312.2 102.75,67.04 102.97,67.04 104.09,65.92 104.09,65.37 ; v2(90.62,61.33) 90.62,62.47 91.14,62.99 v2(91.14,64.84) ; C194.1 120.69,63.19 v2(120.69,64.27) ; R122.2 138.38,67.37 138.2,67.37 137.49,66.66 137.38,66.66 v2(137.31,66.58) ; v2(44.29,12.81) 43.27,11.8 41.09,11.8 37.15,15.73 32.84,15.73 32.15,16.42 29.79,16.42 29.36,15.99 25.85,15.99 v2(25.47,16.37) ; U6.8 101.24,64.5 101.68,64.06 R311.2 ; v2(107.16,72.1) 106.16,73.09 102.45,73.09 101.87,73.67 98.28,73.67 v2(98,73.39) ; v2(117.92,51.3) 117.93,51.29 C193.1 118.8,51.61 C195.1 ; v2(85.79,41.13) 85.79,43.29 83.89,45.2 76.65,45.2 76.6,45.15 76.6,43.88 75.76,43.04 73.73,43.04 v2(72.59,44.18)
  vias: v1(77.06,69.81) v4(77.92,69.33) v4(78.17,68.31) v4(79.42,69.35)
V_3P3_A_B: length 4.3
  TOP w0.508: R80217.2 v1(126.69,96.76) 126.69,97.84 R894.1 126.75,99.7 D2.1
V_3P3_PCIVAUX: length 47
  TOP w0.305: NGFF1.74 134.16,247 134.16,246.74 133.93,246.5 NGFF1.72
  TOP w0.508: v4(134.44,249.67) R725.1 135.9,248.59 134.31,247 134.16,247
  TOP w0.635: 132.13,255.04 124.63,255.04 Q57.G ; 132.13,255.04 133.38,255.04 v2(134.18,254.24) ; 132.13,255.04 R728.1
  L4 w0.508: v2(134.18,254.24) 134.18,249.92 v4(134.44,249.67)
  BOTTOM w1.27: v4(134.44,249.67) 132.53,247.76 v3(132.53,238.64) 132.53,228.84 133.17,228.21 134.31,228.21 134.69,227.82
  vias: v2(135.83,228.08) v2(140.35,227.12) v3(138.8,227.34)
V_5_CODEC: length 11.1
  TOP w0.203: v2(180.66,63.61) 179.9,62.85 U9.39
  TOP w0.508: L4.1 180.03,69.2 179.32,68.49 179.11,68.49 v2(178.99,68.36)
  BOTTOM w0.508: v2(180.66,63.61) 180.92,63.36 C211.1 181.62,63.98 181.49,63.98 C212.1 C226.1 180.17,67.34 179.26,67.34 v3(179.05,67.55) 178.99,67.61 v2(178.99,68.36)
V_5_LCD1:
  vias: v3(17.72,53.33)
V_5_LCD2:
  vias: v3(18.8,57.96)
V_5HDD: length 10.6
  TOP w0.635: SATAP1.1 22.35,124.5 ; SATAP1.1 21.28,123.43 ; SATAP1.1 21.28,125.57 ; 26.99,121.02 28.05,121.02 ; 26.99,121.02 25.94,121.02 ; 26.99,121.02 26.99,119.96 ; 26.99,121.02 26.99,122.07 ; SATAP1.3 22.35,119.5 ; SATAP1.3 21.28,118.43 ; SATAP1.3 21.28,120.57
V_5P0_A: length 292.7
  TOP w0.508: v2(77.74,51.12) 77.74,51.6 77.54,51.8 76.52,51.8 v2(75.89,51.17) ; v2(78.22,64.65) 79.15,64.65 C362.1 79.25,65.58 v2(78.43,66.41) ; v4(178.05,68.21) 178.05,68.87 L4.2 178.25,69.58 D5.K
  L3 w0.762: v4(126.05,18.93) 131.01,23.89 138.35,23.89 v4(142.72,28.26) ; v4(177.87,27.67) 179.14,28.94 179.14,31.83 180.05,32.75 180.05,35.39 176.24,39.2 176.24,47.13 177.89,48.78 v4(177.89,50.18)
  L4 w0.508: v4(152.47,100.44) 152.47,100.82 146.25,107.05 146.25,119.49 142.46,123.28 142.46,125.78 v4(142.56,125.88)
  L4 w0.762: v4(142.72,28.26) 144.8,30.34 150.02,30.34 151.93,28.43 158.18,28.43 161.51,25.11 174.67,25.11 177.23,27.67 v4(177.87,27.67) ; v4(109.29,22.72) 109.75,23.18 112.06,23.18 117.31,17.93 122.28,17.93 123.28,18.93 v4(126.05,18.93)
  BOTTOM w0.203: U21.4 v2(78.43,66.41) ; U22.4 v2(75.89,51.17)
  BOTTOM w0.305: 157.42,125.34 157.03,124.95 PU44.7
  BOTTOM w0.508: R80219.2 77.74,50.65 v2(77.74,51.12) ; v4(142.56,125.88) 142.56,126.86 143.78,128.08 157.09,128.08 158.82,126.35 158.82,125.4 PC104.1 157.42,125.34 ; 83.51,46.47 82.24,47.74 82.24,49.65 81.61,50.28 81.1,50.28 79.89,51.48 R80221.2
  BOTTOM w0.635: v4(178.05,68.21) 178.05,70.42 176.47,72 176.47,78.47 173.08,81.86 173.08,85.11 174.99,87.02 174.99,91.92 173.97,92.95 171.77,92.95 170.63,94.09 166.69,94.09 163.8,96.99 157.57,96.99 154.12,100.44 v4(152.47,100.44)
  BOTTOM w0.762: 83.51,46.47 84.9,46.47 89.01,42.35 89.01,33.83 v3(88.82,33.64) 88.82,31.91 91.15,29.58 102.5,29.58 103.83,28.25 103.83,28.18 v4(109.29,22.72) ; v4(177.89,50.18) 178.76,51.04 178.76,53.65 181.68,56.57 v3(181.68,59.68) 181.68,61.04 179.42,63.3 179.42,64.83 177.47,66.78 177.47,67.7 177.98,68.21 v4(178.05,68.21)
  vias: v1(77.54,58.91) v3(77.41,54.72) v4(76.9,60.06) v4(76.9,57.14) v4(77.82,60.06) v4(77.87,57.19)
V_5P0_HDMI_CONN: length 6
  TOP w0.305: v4(149.42,40.59) 149.49,40.52 HDMI1.18
  BOTTOM w0.508: L25.1 150.88,37.82 C419.1 v3(149.68,39.36) 149.45,39.58 149.45,40.56 v4(149.42,40.59)
V_5P0_HDMI_CONN_L: length 3.6
  BOTTOM w1.016: v3(154.37,35.55) F7.2 152.9,37.68 L25.2
V_19_INV: length 6.3
  TOP w0.508: v1(11.37,14.72) 11.31,14.78 R79706.1
  TOP w1.016: v1(11.37,14.72) 11.37,9.53 L61.1
V_CPU_CORE: length 335.4
  TOP w0.356: CPU1.AJ21 82.81,189.45 ; CPU1.AJ20 v2(82.81,188.54)
  TOP w0.508: v2(91,56.7) 91,55.36 91.86,54.49 G1.1 ; v2(62.81,141.21) 61.79,142.23 58.81,142.23 R1823.1
  TOP w0.635: 41.85,218.13 PT2.1 ; PT2.1 42.91,219.19 ; PT2.1 41.85,220.24 ; PT2.1 40.8,219.19 ; PT4.1 41.73,196.62 ; PT4.1 40.67,195.57 ; PT4.1 42.78,195.57 ; PT4.1 41.73,194.51 ; 41.73,186.64 PT3.1 ; PT3.1 41.73,188.75 ; PT3.1 42.78,187.69 ; PT3.1 40.67,187.69 ; 41.73,202.39 PT5.1 ; PT5.1 41.73,204.49 ; PT5.1 42.78,203.44 ; PT5.1 40.67,203.44 ; 40.8,211.31 PT6.1 ; PT6.1 41.85,212.37 ; PT6.1 42.91,211.31 ; PT6.1 41.85,210.26
  L3 w0.508: v2(34.46,100.82) 29.06,100.82 v2(27.97,101.92)
  L3 w0.635: PT5.1 41.73,204.49 ; PT5.1 40.67,203.44 ; PT5.1 41.73,202.39 ; PT5.1 42.78,203.44 ; PT4.1 41.73,196.62 ; PT4.1 40.67,195.57 ; PT4.1 42.78,195.57 ; PT4.1 41.73,194.51 ; PT6.1 41.85,212.37 ; PT6.1 41.85,210.26 ; PT6.1 40.8,211.31 ; PT6.1 42.91,211.31 ; 41.73,186.64 PT3.1 ; PT3.1 40.67,187.69 ; PT3.1 42.78,187.69 ; PT3.1 41.73,188.75 ; 41.85,218.13 PT2.1 ; PT2.1 40.8,219.19 ; PT2.1 41.85,220.24 ; PT2.1 42.91,219.19
  L4 w0.508: v2(91,56.7) 86.3,56.7 85.71,57.3 81.61,57.3 80.99,57.92 62.78,57.92 62.46,57.61 53.78,57.61 53.05,58.33 35.99,58.33 23.16,71.16 23.16,83.02 27.97,87.84 v2(27.97,101.92) ; v2(34.46,100.82) 34.97,101.33 34.97,105.96 35.25,106.24 35.25,108.59 36.54,109.89 36.54,110.81 38.98,113.24 40.3,113.24 43.96,116.9 44.33,116.9 47.12,119.7 47.12,122.27 54.49,129.64 54.99,129.64 57.18,131.83 57.18,133.1 62.1,138.01 62.77,138.01 63.35,138.58 63.35,140.67 v2(62.81,141.21) 62.81,142.35 63.49,143.04 63.49,161.32 69.41,167.24 69.41,167.5 71.53,169.63 71.53,171.06 71.17,171.43 71.17,173.75 71.56,174.14 71.56,175.03 71.13,175.45 71.13,180.68 v2(71.11,180.71) ; v2(29.38,250.46) 30.14,250.46 36.37,244.23 36.37,242.33 38.83,239.86 38.83,237.03 37.83,236.03 37.14,236.03 35.25,234.14 35.25,228.03 v4(35.78,227.49)
  L4 w0.635: PT2.1 42.91,219.19 ; PT2.1 41.85,218.13 ; PT2.1 40.8,219.19 ; PT2.1 41.85,220.24 ; 40.67,187.69 PT3.1 ; PT3.1 42.78,187.69 ; PT3.1 41.73,186.64 ; PT3.1 41.73,188.75 ; 41.85,210.26 PT6.1 ; PT6.1 42.91,211.31 ; PT6.1 41.85,212.37 ; PT6.1 40.8,211.31 ; PT4.1 41.73,196.62 ; PT4.1 41.73,194.51 ; PT4.1 42.78,195.57 ; PT4.1 40.67,195.57 ; 40.67,203.44 PT5.1 ; PT5.1 42.78,203.44 ; PT5.1 41.73,204.49 ; PT5.1 41.73,202.39
  BOTTOM w0.508: v2(29.38,250.46) 29.42,250.49 R79759.1
  BOTTOM w0.635: PT5.1 42.78,203.44 ; PT5.1 40.67,203.44 ; PT5.1 41.73,204.49 ; PT5.1 41.73,202.39 ; PT3.1 42.78,187.69 ; PT3.1 40.67,187.69 ; PT3.1 41.73,186.64 ; PT3.1 41.73,188.75 ; PT4.1 41.73,196.62 ; PT4.1 41.73,194.51 ; PT4.1 42.78,195.57 ; PT4.1 40.67,195.57 ; 40.8,219.19 PT2.1 ; PT2.1 41.85,220.24 ; PT2.1 41.85,218.13 ; PT2.1 42.91,219.19 ; 40.8,211.31 PT6.1 ; PT6.1 42.91,211.31 ; PT6.1 41.85,210.26 ; PT6.1 41.85,212.37
  vias: v2(46.6,186.78) v2(56.29,195.48) v2(56.29,193.66) v2(56.29,191.83) v2(57.21,195.48) v2(57.21,193.66) v2(57.21,191.83) v2(58.12,202.26) v2(58.12,200.43) v2(58.12,198.6) v2(59.04,202.26) v2(59.04,200.43) v2(59.04,198.6) v2(59.04,195.48) v2(59.04,193.66) v2(59.04,191.83) v2(60.87,202.26) v2(60.87,200.43) v2(60.87,198.6) v2(60.87,195.48) v2(60.87,193.66) v2(60.87,191.83) v2(60.87,190) v2(62.7,200.43) v2(62.7,198.6) v2(62.7,195.48) v2(62.7,193.66) v2(62.7,191.83) v2(62.7,190) v2(63.61,188.17) v2(64.52,198.6) v2(64.52,195.48) v2(64.52,193.66) v2(64.52,191.83) v2(64.52,190) v2(64.52,188.17) v2(64.52,186.34) v2(65.44,197.68) v2(65.45,181.77) v2(66.35,195.48) v2(66.35,193.66) v2(66.35,191.83) v2(66.35,190) v2(66.35,188.17) v2(66.35,186.34) v2(66.35,185.43) v2(66.36,183.63) v2(66.35,181.84) v2(67.43,179.9) v2(67.64,194.73) v2(70.07,180.99) v2(72.05,180.73) v2(73.22,180.71) v2(74.16,180.76) v2(82.49,181.22) v2(82.62,184.9) v2(82.62,182.1) v2(82.81,187.63) v2(82.75,186.55) v2(82.75,185.66) v2(82.75,184.01) v2(82.75,182.99) v3(36.29,224.14) v3(37.23,211.26) v3(37.25,194.25) v3(54.12,185.96) v3(55.03,204.99) v3(63.01,187.39) v3(80.08,181.22) v4(35.63,220.08) v4(35.63,216.78) v4(35.63,212.97) v4(35.63,206.62) v4(35.63,201.92) v4(35.63,197.09) v4(35.63,190.87) v4(35.65,221.14) v4(35.65,217.84) v4(35.65,214.03) v4(35.65,207.68) v4(35.65,202.98) v4(35.65,198.16) v4(35.65,191.93) v4(35.76,226.43) v4(36.77,221.09) v4(36.77,220.08) v4(36.77,217.79) v4(36.77,216.78) v4(36.77,213.98) v4(36.77,212.97) v4(36.77,207.63) v4(36.77,206.62) v4(36.77,202.93) v4(36.77,201.92) v4(36.77,198.11) v4(36.77,197.09) v4(36.77,191.88) v4(36.77,190.87) v4(36.9,227.44) v4(36.9,226.43) v4(37.92,221.09) v4(37.92,220.08) v4(37.92,217.79) v4(37.92,216.78) v4(37.92,213.98) v4(37.92,212.97) v4(37.92,207.63) v4(37.92,206.62) v4(37.92,202.93) v4(37.92,201.92) v4(37.92,198.11) v4(37.92,197.09) v4(37.92,191.88) v4(37.92,190.87) v4(38.04,227.44) v4(38.04,226.43) v4(38.07,189.14) v4(38.04,188.07) v4(39.19,189.09) v4(39.19,188.07) v4(40.48,199.93) v4(40.46,198.87) v4(40.86,227.49) v4(40.84,226.43) v4(40.86,215.94) v4(40.84,214.87) v4(41.22,222.11) v4(41.22,206.62) v4(41.24,223.18) v4(41.24,207.68) v4(41.6,199.88) v4(41.6,198.87) v4(41.62,192.06) v4(41.6,190.99) v4(41.98,227.44) v4(41.98,226.43) v4(41.98,215.89) v4(41.98,214.87) v4(42.36,223.13) v4(42.36,222.11) v4(42.36,207.63) v4(42.36,206.62) v4(42.74,199.88) v4(42.74,198.87) v4(42.74,192.01) v4(42.74,190.99) v4(43.12,227.44) v4(43.12,226.43) v4(43.12,215.89) v4(43.12,214.87) v4(43.5,223.13) v4(43.5,222.11) v4(43.5,207.63) v4(43.5,206.62) v4(43.88,192.01) v4(43.88,190.99) v4(45.81,222.79) v4(45.79,221.73) v4(46.58,202.86) v4(46.55,201.79) v4(46.58,194.85) v4(46.55,193.79) v4(46.93,222.74) v4(46.93,221.73) v4(46.96,218.6) v4(46.93,217.54) v4(47.08,210.73) v4(47.06,209.66) v4(47.69,202.81) v4(47.69,201.79) v4(47.69,194.8) v4(47.69,193.79) v4(48.08,222.74) v4(48.08,221.73) v4(48.08,218.55) v4(48.08,217.54) v4(48.2,210.68) v4(48.2,209.66) v4(48.84,202.81) v4(48.84,201.79) v4(48.84,194.8) v4(48.84,193.79) v4(49.22,218.55) v4(49.22,217.54) v4(49.35,210.68) v4(49.35,209.66) v4(50.18,193.82) v4(50.81,205.13) v4(50.94,202.71) v4(50.94,200.3) v4(50.94,197.63) v4(51.83,193.82) v4(52.34,205.13) v4(52.59,202.71) v4(52.59,200.3) v4(52.59,197.63) v4(53.74,193.82) v4(54.37,202.71) v4(54.5,200.3) v4(54.5,197.63) v4(55.39,193.82) v4(56.15,200.3) v4(56.15,197.63) v4(58.05,196.49) v4(59.7,196.49) v4(61.61,196.49) v4(63.26,196.49) v4(68.09,191.92) v4(68.09,190.01) v4(68.09,188.11) v4(68.09,186.33) v4(69.1,191.92) v4(69.1,190.01) v4(69.1,188.11) v4(69.1,186.33) v4(70,189.5) v4(70.05,188.4) v4(70.78,189.01) v4(71.93,188.99) v4(72.94,189.04) v4(73.93,188.96) v4(74.9,189.01) v4(75.91,188.96) v4(77.44,188.38) v4(78.99,188.15) v4(80.18,188.2)
