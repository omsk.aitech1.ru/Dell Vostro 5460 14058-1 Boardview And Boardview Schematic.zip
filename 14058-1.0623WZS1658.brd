# Allegro board 14058-1.0623WZS1658.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_MAA_B13: length 95.1
  TOP w0.216: CPU1.AR15 88.76,183.5 v5(88.27,183.01) ; v5(163.59,160.26) 163,160.85 DIMM2.119
  L3 w0.102: 94.76,182.05 94.18,181.47 93.41,181.47 93.31,181.57 90.23,181.57 89.53,182.27 89.01,182.27 v5(88.27,183.01)
  L3 w0.292: v5(163.59,160.26) 163.07,160.78 160.55,160.78 154.53,154.75 150.04,154.75 149.89,154.9 142.39,154.9 131.49,165.8 116.35,165.8 100.09,182.05 94.76,182.05
  BOTTOM w0.216: v3(163.37,159.5) 163.59,159.72 v5(163.59,160.26)
M_MAA_B14: length 89.1
  TOP w0.216: v5(165.17,174.87) 165.17,174.23 166.85,172.55 DIMM2.80 ; v5(95.37,196.46) 95.09,196.18 94.11,196.18 CPU1.AY28
  L3 w0.292: v5(165.17,174.87) 165.17,176.62 164.47,177.31 154.59,177.31 153.13,178.77 142.75,178.77 139.44,182.08 128.92,182.08 128.63,182.37 128.63,182.43 128.34,182.73 127.76,182.73 127.46,182.43 127.46,182.37 127.17,182.08 126.59,182.08 126.3,182.37 126.3,182.43 126,182.73 125.42,182.73 125.13,182.43 125.13,182.37 124.84,182.08 123.76,182.08 109.38,196.46 v5(95.37,196.46)
  BOTTOM w0.216: v3(165.19,175.68) 165.17,175.65 v5(165.17,174.87)
M_MAA_B15: length 91.8
  TOP w0.216: v5(91.02,194.85) 90.58,195.29 CPU1.AU28 ; DIMM2.78 167.38,173.15 166.64,173.89 v5(166.64,174.84)
  L3 w0.292: v5(166.64,174.84) 166.64,174.85 165.93,175.56 165.93,176.59 164.77,177.76 154.99,177.76 153.53,179.22 143.16,179.22 139.86,182.52 132.78,182.52 132.49,182.82 132.49,182.88 132.2,183.17 131.61,183.17 131.32,182.88 131.32,182.82 131.03,182.52 130.45,182.52 130.15,182.82 130.15,182.88 129.86,183.17 123.3,183.17 109.51,196.96 95.16,196.96 94.64,196.44 92.61,196.44 v5(91.02,194.85)
  BOTTOM w0.216: v5(166.64,174.84) 166.64,174.3 v3(166.39,174.05)
M_ODT_A0: length 74.6
  TOP w0.165: v5(151.8,161.75) 151.81,161.75 DIMM1.116 ; CPU1.AW11 92.41,179.88 92.81,180.28 v5(92.88,180.28)
  L4 w0.229: v5(92.88,180.28) 93.37,180.28 93.93,179.72 95.82,179.72 105.7,169.84 118.61,169.84 125.72,162.73 130.53,162.73 145.89,162.73 145.98,162.82 152.83,162.82 153.1,162.55 153.1,161.02 152.88,160.79 152.03,160.79 151.8,161.02 v5(151.8,161.75)
  BOTTOM w0.165: v3(152.06,160.97) 151.8,161.23 v5(151.8,161.75)
M_ODT_A1: length 77.5
  TOP w0.165: v5(91.05,182.99) 90.66,182.6 CPU1.AU14 ; DIMM1.120 152.34,160.55 152.26,160.47 150.78,160.47 v5(150.36,160.89)
  L4 w0.102: 90.54,181.8 90.54,182.48 v5(91.05,182.99)
  L4 w0.229: v5(150.36,160.89) 149.86,160.38 122.3,160.38 115.81,166.87 105.34,166.87 95.98,176.23 95.98,176.34 94.63,177.68 91.86,177.68 89.71,179.84 89.71,180.96 90.54,181.8
  BOTTOM w0.165: v3(90.8,183.76) 91.03,183.53 91.03,183.02 v5(91.05,182.99)
M_ODT_B0: length 101.3
  TOP w0.165: DIMM2.116 166.75,161.75 v5(166.23,161.23) ; CPU1.AM16 86.03,184.43 86.4,184.8 86.44,184.8 86.45,184.81 v2(86.47,184.81)
  L3 w0.102: 94.98,182.66 94.9,182.58 90.88,182.58 90.81,182.66 89.43,182.66 89.38,182.61 89.04,182.61 88.72,182.93 88.72,183.14 88.41,183.45 87.83,183.45 v2(86.47,184.81)
  L3 w0.229: v5(166.23,161.23) 164.91,161.23 164.9,161.23 160.3,161.23 155.28,156.21 147.87,156.21 147.65,155.98 147.65,155.76 147.42,155.54 146.96,155.54 146.73,155.76 146.73,155.98 146.5,156.21 146.05,156.21 145.82,155.98 145.82,155.76 145.59,155.54 145.13,155.54 144.9,155.76 144.9,155.98 144.67,156.21 144.22,156.21 143.99,155.98 143.99,155.76 143.76,155.54 143.3,155.54 143.07,155.76 143.07,155.98 142.85,156.21 141.84,156.21 131.77,166.28 116.81,166.28 100.42,182.66 94.98,182.66
  BOTTOM w0.165: v3(167.66,161.56) 167.56,161.66 166.69,161.66 166.26,161.23 v5(166.23,161.23)
M_ODT_B1: length 101.7
  TOP w0.165: v5(84.67,183.98) 85.1,184.41 CPU1.AL16 ; DIMM2.120 167.33,160.55 v5(166.46,159.68)
  L3 w0.102: 94.93,181.11 94.63,181.11 94.58,181.06 93.25,181.06 93.15,181.16 90.06,181.16 89.45,181.77 86.7,181.77 86.67,181.75 86.3,181.75 86.03,182.01 86.03,182.61 v5(84.67,183.98)
  L3 w0.229: 94.93,181.11 99.48,181.11 115.82,164.77 130.07,164.77 141.64,153.21 154.22,153.21 160.53,159.52 166.3,159.52 v5(166.46,159.68)
  BOTTOM w0.165: v5(84.67,183.98) 84.38,184.26 v3(83.86,184.26)
M_RAS_A_N: length 74.5
  TOP w0.216: CPU1.AW13 92.41,181.72 v5(91.98,182.15) ; v5(151.71,163.54) 151.71,163.55 DIMM1.110
  L4 w0.292: v5(151.71,163.54) 151.29,163.96 149.76,163.96 149.49,163.69 145.62,163.69 145.53,163.6 128.68,163.6 126.48,165.8 126.07,165.8 125.82,165.56 125.4,165.56 124.99,165.97 124.99,166.38 125.24,166.63 125.24,167.04 124.83,167.46 124.41,167.46 124.17,167.21 123.75,167.21 123.34,167.62 123.34,168.04 123.59,168.28 123.59,168.7 123.17,169.11 122.76,169.11 122.51,168.86 122.1,168.86 121.69,169.27 121.69,169.69 121.93,169.94 121.93,170.35 121.56,170.72 106.04,170.72 95.8,180.96 93.17,180.96 v5(91.98,182.15)
  BOTTOM w0.216: v5(91.98,182.15) v3(91.98,181.34)
M_RAS_B_N: length 99.1
  TOP w0.216: DIMM2.110 166.2,163.55 164.88,162.23 v5(164.88,162.14) ; v5(86.45,185.89) 86.56,185.89 CPU1.AN18
  L3 w0.102: 95.73,184.24 95.42,184.24 94.38,185.28 93.92,185.28 93.06,184.42 92.55,184.42 92.25,184.72 91.61,184.72 91.36,184.47 89.81,184.47 89.46,184.82 88.61,184.82 87.55,185.89 v5(86.45,185.89)
  L3 w0.292: 95.73,184.24 101.31,184.24 116.91,168.64 131.46,168.64 141.84,158.26 152.47,158.26 155.69,161.49 158.57,161.49 160.14,163.06 163.99,163.06 164.88,162.17 v5(164.88,162.14)
  BOTTOM w0.216: v5(164.88,162.14) v3(164.88,161.28)
M_SBS_A0: length 74
  TOP w0.216: DIMM1.109 146.42,163.85 146.55,163.71 147.87,163.71 v5(148.38,164.22) ; CPU1.AY13 93.3,181.68 v2(92.86,182.13)
  L4 w0.292: v5(148.38,164.22) 148.38,164.25 147.88,164.75 145.42,164.75 145.16,164.49 129.11,164.49 120.8,172.81 107.11,172.81 104.02,175.9 103.6,175.9 103.28,175.57 102.86,175.57 102.45,175.99 102.45,176.4 102.78,176.73 102.78,177.14 102.36,177.55 101.95,177.55 101.63,177.23 101.21,177.23 100.8,177.64 100.8,178.05 101.13,178.38 101.13,178.79 100.71,179.21 100.3,179.21 99.97,178.88 99.56,178.88 99.15,179.29 99.15,179.71 99.47,180.03 99.47,180.45 99.06,180.86 98.65,180.86 98.32,180.53 97.91,180.53 97.49,180.95 97.49,181.36 97.82,181.68 97.82,182.1 97.54,182.38 93.56,182.38 93.31,182.13 v2(92.86,182.13)
  BOTTOM w0.216: v5(148.38,164.22) 148.38,163.51 v3(148.23,163.36)
M_SBS_A1: length 76.6
  TOP w0.165: v5(92.01,183.06) 91.55,183.51 CPU1.AV15
  TOP w0.216: DIMM1.108 152.06,164.15 v5(151.25,164.96)
  L4 w0.292: v5(151.25,164.96) 151.02,165.19 145.24,165.19 144.98,164.93 129.36,164.93 127.75,166.53 127.75,166.95 128.42,167.61 128.42,168.03 128.01,168.44 127.6,168.44 126.93,167.77 126.52,167.77 126.1,168.19 126.1,168.6 126.23,168.73 126.23,169.14 125.82,169.56 125.41,169.56 125.28,169.43 124.86,169.43 124.45,169.84 124.45,170.25 124.58,170.38 124.58,170.8 124.17,171.21 123.75,171.21 123.62,171.08 123.21,171.08 122.8,171.49 122.8,171.9 122.93,172.04 122.93,172.45 122.51,172.86 122.1,172.86 121.97,172.73 121.56,172.73 121,173.29 107.26,173.29 98.62,181.93 97.69,182.85 93.98,182.85 93.34,183.49 92.44,183.49 v5(92.01,183.06)
  BOTTOM w0.216: v3(151.83,165.8) 151.25,165.22 v5(151.25,164.96)
M_SBS_A2: length 75.4
  TOP w0.102: CPU1.AW23 92.81,191.22 v5(92.91,191.22)
  TOP w0.216: v5(147.47,174.88) 147.47,174.18 146.14,172.85 DIMM1.79
  L4 w0.292: v5(92.91,191.22) 93.21,191.22 93.62,191.63 93.69,191.7 96.14,191.7 96.21,191.63 102.84,191.63 105.97,188.5 105.97,188.08 105.59,187.71 105.59,187.3 106.01,186.88 106.42,186.88 107.47,187.93 107.88,187.93 108.29,187.52 108.29,187.11 107.25,186.06 107.25,185.64 107.66,185.23 108.07,185.23 109.17,186.33 109.58,186.33 110,185.92 110,185.5 108.9,184.41 108.9,183.99 109.31,183.58 109.73,183.58 110.1,183.95 110.51,183.95 111.35,183.12 130.23,183.12 138.48,174.88 v5(147.47,174.88)
  BOTTOM w0.216: v5(147.47,174.88) 147.47,174.23 v3(147.24,174)
M_SBS_B0: length 100.6
  TOP w0.216: CPU1.AL18 85.15,186.25 v5(85.59,186.7) ; v5(163.47,165.17) 162.15,163.85 DIMM2.109
  L3 w0.102: v5(85.59,186.7) 86.05,187.15 87.18,187.15 88.03,187.99 88.49,187.99 88.77,187.71 90.56,187.71 90.85,188 91.71,188 92.47,187.23 94.79,187.23
  L3 w0.292: 94.79,187.23 95.97,186.05 103.45,186.05 103.96,185.53 103.96,185.11 103.7,184.85 103.7,184.43 104.11,184.02 104.52,184.02 104.79,184.29 105.2,184.29 105.62,183.87 105.62,183.46 105.35,183.19 105.35,182.78 105.76,182.37 106.18,182.37 106.44,182.63 106.86,182.63 107.27,182.22 107.27,181.81 107,181.54 107,181.13 107.42,180.71 107.83,180.71 108.1,180.98 108.51,180.98 118.96,170.53 132.16,170.53 139.78,162.91 152.55,162.91 152.97,163.32 157.87,163.32 160.22,165.68 162.97,165.68 v5(163.47,165.17)
  BOTTOM w0.216: v3(87.49,187.57) 86.47,187.57 v5(85.59,186.7)
M_SBS_B1: length 99.2
  TOP w0.216: DIMM2.108 166.18,164.15 v2(165.63,164.71) ; v5(86.44,186.67) 86.43,186.67 CPU1.AM18
  L3 w0.102: v5(86.44,186.67) 86.86,186.25 88.44,186.25 88.77,186.58 88.77,186.79 89.09,187.1 90.37,187.1 90.86,186.61 91.59,186.61 91.84,186.36 92.19,186.36 92.2,186.38 94.51,186.38 95.7,185.19
  L3 w0.292: v2(165.63,164.71) 165.22,164.3 160.1,164.3 158.24,162.43 154.35,162.43 152.27,160.35 143.75,160.35 143.46,160.64 143.46,161.24 143.16,161.53 142.58,161.53 142.29,161.24 142.29,160.64 142,160.35 141.08,160.35 131.88,169.56 117.29,169.56 101.71,185.14 95.75,185.14 95.7,185.19
  BOTTOM w0.216: v3(164.92,164.27) 165.19,164.27 v2(165.63,164.71)
M_SBS_B2: length 90.5
  TOP w0.216: CPU1.AW28 92.8,195.01 93.68,195.01 94.41,195.74 95,195.74 v5(95.4,195.35) ; v5(162.65,176.77) 162.65,175.14 161.79,174.29 161.79,173.07 161.57,172.85 DIMM2.79
  L3 w0.292: v5(162.65,176.77) 162.09,176.22 160.66,176.22 160.46,176.41 153.7,176.41 153.2,176.91 152.94,177.17 141.71,177.17 139.29,179.59 133.6,179.59 133.24,179.95 133.24,180.57 132.95,180.86 132.46,180.86 132.16,180.57 132.16,179.81 131.87,179.51 131.29,179.51 131,179.81 131,180.82 130.7,181.11 130.12,181.11 129.83,180.82 129.83,179.81 129.53,179.51 128.95,179.51 128.66,179.81 128.66,180.82 128.37,181.11 123.45,181.11 109.08,195.48 108.34,195.48 108.34,195.48 95.68,195.48 95.55,195.35 v5(95.4,195.35)
  BOTTOM w0.216: v5(162.65,176.77) 162.65,177.34 v3(162.45,177.53)
M_SCKE_A0: length 74
  TOP w0.165: CPU1.AY24 94.74,193.15 v5(96.11,193.15) ; DIMM1.73 146.23,174.65 146.51,174.93 146.51,175.7 v5(146.85,176.04)
  L4 w0.229: v5(96.11,193.15) 96.72,192.54 105,192.54 105.8,191.74 106.12,191.74 106.58,192.21 106.91,192.21 107.23,191.88 107.23,191.56 106.77,191.1 106.77,190.77 107.09,190.45 107.41,190.45 107.88,190.91 108.2,190.91 108.52,190.59 108.52,190.27 108.06,189.8 108.06,189.48 108.38,189.16 108.71,189.16 109.17,189.62 109.49,189.62 109.82,189.3 109.82,188.97 109.35,188.51 109.35,188.19 109.68,187.86 110,187.86 110.46,188.33 110.79,188.33 111.11,188 111.11,187.68 110.65,187.22 110.65,186.89 110.97,186.57 111.29,186.57 111.76,187.03 112.08,187.03 112.4,186.71 112.4,186.39 111.94,185.92 111.94,185.6 112.29,185.25 112.67,185.25 112.9,185.48 113.3,185.48 113.58,185.2 113.58,184.8 113.48,184.69 113.48,184.36 113.76,184.09 130.63,184.09 138.67,176.04 v5(146.85,176.04)
  BOTTOM w0.165: v3(146.3,176.69) 146.3,176.54 146.8,176.04 v5(146.85,176.04)
M_SCKE_A1: length 75.1
  TOP w0.165: v5(151.55,176.11) 151.55,175.3 152.5,174.35 DIMM1.74 ; v2(92.88,193.1) 92.88,192.21 CPU1.AW24
  L4 w0.229: v2(92.88,193.1) 93.06,193.28 94.43,193.28 96.39,195.24 97.2,195.24 97.43,195.01 97.43,194.36 97.7,194.09 98.08,194.09 98.35,194.36 98.35,195.01 98.57,195.24 105.23,195.24 115.41,185.05 130.94,185.05 138.94,177.04 150.62,177.04 v5(151.55,176.11)
  BOTTOM w0.165: v3(152.27,175.14) 152.27,175.17 151.55,175.89 v5(151.55,176.11)
M_SCKE_B0: length 89.7
  TOP w0.165: v5(161.12,176.75) 161.73,176.14 161.73,174.92 161.46,174.65 DIMM2.73 ; v5(92.88,195.82) 92.88,195.86 CPU1.AY29
  L3 w0.229: v5(92.88,195.82) 92.99,195.93 108.16,195.93 109.27,195.93 123.6,181.6 133.73,181.6 133.96,181.37 133.96,180.33 134.18,180.1 134.64,180.1 134.87,180.33 134.87,181.37 135.1,181.6 135.56,181.6 135.78,181.37 135.78,180.33 136.01,180.1 136.47,180.1 136.7,180.33 136.7,181.37 136.93,181.6 137.38,181.6 137.61,181.37 137.61,180.33 137.84,180.1 138.3,180.1 138.53,180.33 138.53,181.37 138.76,181.6 139.29,181.6 140.43,180.45 140.43,180.13 140.22,179.92 140.22,179.59 140.54,179.27 140.87,179.27 141.08,179.48 141.4,179.48 143.26,177.62 153.13,177.62 153.89,176.86 161.01,176.86 v5(161.12,176.75)
  BOTTOM w0.165: v3(160.29,177.1) 160.65,176.75 v5(161.12,176.75)
M_SCKE_B1: length 92
  TOP w0.165: CPU1.AV29 91.91,196.73 v5(91.91,196.8) ; DIMM2.74 167.61,174.35 167.32,174.64 v5(167.32,176.01)
  L3 w0.229: v5(91.91,196.8) 93.43,196.8 94.04,197.41 109.7,197.41 123.48,183.62 133.9,183.62 134.13,183.39 134.13,183.2 134.36,182.97 134.82,182.97 135.05,183.2 135.05,183.39 135.28,183.62 135.73,183.62 135.96,183.39 135.96,183.2 136.19,182.97 136.65,182.97 136.88,183.2 136.88,183.39 137.1,183.62 137.56,183.62 137.79,183.39 137.79,183.2 138.02,182.97 138.48,182.97 138.7,183.2 138.7,183.39 138.93,183.62 140,183.62 142.8,180.82 144.02,180.82 144.25,180.59 144.25,180.35 144.48,180.12 144.94,180.12 145.17,180.35 145.17,180.59 145.4,180.82 152.79,180.82 155.4,178.21 165.12,178.21 v5(167.32,176.01)
  BOTTOM w0.165: v5(91.91,196.8) v3(91.91,197.7)
M_SCS_A_N0: length 75
  TOP w0.102: v5(94.64,180.32) 93.76,181.2 92.84,181.2 CPU1.AW12
  TOP w0.165: DIMM1.114 151.27,162.35 v5(150.18,163.44)
  L4 w0.229: v5(94.64,180.32) 95.81,180.32 105.85,170.27 105.86,170.27 119.91,170.27 120.33,169.85 120.33,169.53 120.12,169.31 120.12,168.99 120.44,168.67 120.76,168.67 120.97,168.88 121.3,168.88 121.62,168.55 121.62,168.23 121.41,168.02 121.41,167.7 121.73,167.37 122.06,167.37 122.27,167.59 122.59,167.59 122.91,167.26 122.91,166.94 122.7,166.73 122.7,166.41 123.03,166.08 123.35,166.08 123.63,166.37 124.01,166.37 124.28,166.1 124.28,165.72 124.05,165.49 124.05,165.08 124.63,164.5 125.04,164.5 125.42,164.88 125.83,164.88 126.21,164.49 126.21,163.6 126.47,163.35 126.98,163.35 127.3,163.66 127.93,163.66 128.45,163.15 145.72,163.15 145.81,163.24 149.99,163.24 v5(150.18,163.44)
  BOTTOM w0.165: v5(150.18,163.44) v3(150.18,164.22)
M_SCS_A_N1: length 76.4
  TOP w0.165: v5(148.82,160.88) 148.19,160.25 147.59,160.25 147.37,160.47 146.86,160.47 146.64,160.25 DIMM1.121 ; CPU1.AU11 90.18,180.26 v5(90.18,180.3)
  L4 w0.229: v5(148.82,160.88) 148.81,160.87 123.55,160.87 123.09,161.33 122.77,161.33 122.56,161.12 122.24,161.12 121.92,161.45 121.92,161.77 122.12,161.97 122.12,162.3 121.8,162.62 121.47,162.62 121.27,162.42 120.95,162.42 120.62,162.74 120.62,163.06 120.83,163.27 120.83,163.59 120.5,163.91 120.18,163.91 119.98,163.71 119.65,163.71 119.33,164.03 119.33,164.36 119.53,164.56 119.53,164.88 119.21,165.21 118.89,165.21 118.68,165 118.36,165 118.04,165.33 118.04,165.65 118.24,165.85 118.24,166.18 117.13,167.29 105.51,167.29 94.79,178.01 92.02,178.01 90.18,179.86 v5(90.18,180.3)
  BOTTOM w0.165: v3(89.65,179.56) 89.68,179.56 90.16,180.05 90.16,180.29 v5(90.18,180.3)
M_SCS_B_N0: length 98
  TOP w0.165: v2(88.3,185.77) 87.88,185.34 CPU1.AP17 ; v5(166.39,162.95) 166.99,162.35 DIMM2.114
  L3 w0.102: v2(88.3,185.77) 88.74,185.33 93.11,185.33 93.54,185.76 94.45,185.76 95.39,184.82
  L3 w0.229: v5(166.39,162.95) 165.83,163.51 159.95,163.51 158.38,161.94 154.75,161.94 152.71,159.9 146.13,159.9 145.9,159.67 145.9,159.27 145.68,159.04 145.22,159.04 144.99,159.27 144.99,159.67 144.76,159.9 144.3,159.9 144.08,159.67 144.08,159.27 143.85,159.04 143.39,159.04 143.16,159.27 143.16,159.67 142.93,159.9 140.84,159.9 131.63,169.11 117.11,169.11 101.52,184.69 95.52,184.69 95.39,184.82
  BOTTOM w0.165: v5(166.39,162.95) 166.39,163.16 166.87,163.64 v3(167.58,163.64)
M_SCS_B_N1: length 99.4
  TOP w0.165: DIMM2.121 v5(162.08,160.25) ; CPU1.AN15 86.93,183.44 v5(86.49,183)
  L3 w0.102: v5(86.49,183) 87.43,182.07 89.44,182.07 90.15,181.37 93.23,181.37 93.33,181.27 94.45,181.27 94.57,181.39
  L3 w0.229: v5(162.08,160.25) 160.66,160.25 154.72,154.3 151.35,154.3 149.85,154.3 149.73,154.42 142.23,154.42 140.56,156.09 140.23,156.09 140.06,155.92 139.74,155.92 139.42,156.25 139.42,156.57 139.59,156.74 139.59,157.06 139.26,157.39 138.94,157.39 138.77,157.22 138.45,157.22 138.12,157.54 138.12,157.86 138.29,158.03 138.29,158.36 137.97,158.68 137.65,158.68 137.48,158.51 137.15,158.51 136.83,158.83 136.83,159.16 137,159.33 137,159.65 136.68,159.97 136.35,159.97 136.18,159.8 135.86,159.8 135.54,160.13 135.54,160.45 135.71,160.62 135.71,160.94 135.38,161.27 135.06,161.27 134.89,161.1 134.57,161.1 134.24,161.42 134.24,161.74 134.41,161.91 134.41,162.24 134.09,162.56 133.77,162.56 133.6,162.39 133.27,162.39 132.95,162.71 132.95,163.04 133.12,163.21 133.12,163.53 132.8,163.85 132.47,163.85 132.3,163.68 131.98,163.68 131.66,164.01 131.66,164.33 131.83,164.5 131.83,164.82 131.44,165.21 116,165.21 99.67,181.53 94.71,181.53 94.57,181.39
  BOTTOM w0.165: v5(162.08,160.25) 161.68,160.25 v3(161.32,159.89)
M_WE_A_N: length 75.4
  TOP w0.216: v5(150.28,161.87) 149.5,162.65 DIMM1.113 ; v2(91,182.15) 91,182.15 91.44,182.6 CPU1.AV14
  L4 w0.102: 93.34,179.79 92.3,179.79 91,181.09 v2(91,182.15)
  L4 w0.292: 93.34,179.79 93.78,179.35 95.55,179.35 105.51,169.38 118.42,169.38 125.53,162.28 130.34,162.28 146.08,162.28 146.17,162.37 150.05,162.37 150.28,162.14 v5(150.28,161.87)
  BOTTOM w0.216: v2(91,182.15) 91,181.93 v3(90.54,181.47)
M_WE_B_N: length 98.8
  TOP w0.216: v5(163.43,162.14) 162.92,162.65 DIMM2.113 ; CPU1.AL17 85.55,185.79 v5(85.55,185.8)
  L3 w0.102: v5(85.55,185.8) 86.11,185.24 86.65,185.24 87.42,184.47 89.5,184.47 89.71,184.26 91.46,184.26 91.66,184.47 92.02,184.47 92.3,184.19 93.24,184.19 93.8,183.63
  L3 w0.292: v5(163.43,162.14) 162.96,162.62 160.32,162.62 158.12,160.41 155.39,160.41 152.08,157.11 145.41,157.11 145,157.52 144.06,157.52 143.65,157.11 142.26,157.11 131.23,168.13 119.19,168.13 118.9,167.84 118.9,167.47 118.61,167.18 118.03,167.18 117.73,167.47 117.73,167.84 117.44,168.13 116.57,168.13 101.07,183.62 93.8,183.62 93.8,183.63
  BOTTOM w0.216: v5(163.43,162.14) v3(163.43,163.08)
MAA0: length 121.5
  TOP w0.102: VRAM6.N3 55.03,119.27 v5(55.03,118.78) ; VRAM2.N3 68.3,84.69 v5(68.29,84.69) ; v5(51.61,111.14) 51.65,111.14 51.75,111.03 52.8,111.03 52.92,110.92 52.92,110.63 53.04,110.5 53.25,110.5 53.38,110.63 53.38,110.91 53.51,111.03 53.71,111.03 53.84,110.91 53.84,110.1 54.27,109.67 54.27,109.21 54.78,108.7 54.78,105.32 54.59,105.13 54.59,104.92 v5(54.48,104.81) 54.81,104.81 55.24,105.24 VRAM5.N3 ; v5(69.2,104.02) 69.25,103.97 70.62,103.97 70.96,104.32 GPU1.F26 ; v5(75.96,81.17) 75.99,81.14 76.12,81.14 76.33,80.93 v1(77.86,80.93) 82.31,80.93 83.57,82.2 83.57,84.24 v5(83.17,84.64) 83.15,84.64 VRAM1.N3
  L4 w0.127: v5(51.61,111.14) 51.65,111.09 51.65,110.55 51.16,110.05 51.16,110 51.14,109.99 51.14,109.64 51.16,109.63 51.16,107.18 51.05,107.07 51.05,101.32 51.77,100.6 51.77,99.85 52.53,99.09 52.87,99.09 53.83,98.13 53.83,97.96 53.93,97.87 53.93,97.08 54.19,96.82 54.97,96.82 56,95.79 56,94.17 56.36,93.81 56.36,93.66 56.49,93.53 56.8,93.53 56.93,93.66 56.93,94.42 57.05,94.55 57.24,94.55 57.49,94.31 57.49,93.12 57.32,92.95 v5(56.99,92.95) 56.99,92.62 58.79,90.82 58.79,90.39 61.04,88.14 61.45,88.14 63.1,86.49 63.61,86.49 65.83,84.27 65.89,84.21 65.89,83.23 66.13,82.99 66.27,82.99 68.4,80.86 73.7,80.86 74.01,81.16 75.96,81.16 v5(75.96,81.17)
  BOTTOM w0.102: v5(51.61,111.14) 51.65,111.14 52.06,111.54 52.06,112.46 52.03,112.48 52.03,114.58 52.43,114.98 52.43,115.93 52.31,116.06 52.31,116.5 53.16,117.36 53.3,117.36 54.62,118.68 54.93,118.68 v5(55.03,118.78) 55.03,119.26 55.24,119.47 VRAM6.N3 ; 55.54,93.15 55.38,93.15 55.16,93.37 RN7510.2 ; 55.54,93.15 56.21,93.15 56.41,92.95 v5(56.99,92.95) ; 55.54,93.15 55.81,93.43 RN7510.1 ; v5(75.96,81.17) 75.91,81.17 75.91,81.17 75.86,81.17 74.9,82.13 74.1,82.13 73.39,81.42 72.43,81.42 71.97,81.88 71.44,81.88 70.22,83.11 70.22,84.06 69.6,84.68 68.31,84.68 v5(68.29,84.69) 68.3,84.69 VRAM2.N3 ; v5(83.17,84.64) 83.15,84.64 VRAM1.N3 ; v5(54.48,104.81) 54.54,104.87 54.73,104.87 55.24,105.38 VRAM5.N3
  BOTTOM w0.127: v5(69.2,104.02) 69.15,103.97 69.15,103.39 67.9,102.14 67.9,100.69 65.37,98.15 65.37,95.5 63.77,93.9 62.9,93.9 62.8,93.8 60.84,93.8 60.37,94.27 59.55,94.27 59.02,93.74 57.65,93.74 56.99,93.08 v5(56.99,92.95)
MAA1: length 111.1
  TOP w0.102: v5(85.4,83.84) 85.48,83.84 VRAM1.P7 ; v5(54.84,115.88) 54.83,115.89 54.83,115.9 54.45,116.28 54.44,116.28 VRAM6.P7 ; VRAM5.P7 54.44,102.31 53.92,102.83 v5(53.87,102.83) ; GPU1.G23 73.95,104.75 v5(74,104.75) ; v5(71.37,83.8) 71.46,83.88 71.49,83.88 VRAM2.P7
  L3 w0.127: v5(78.75,84.01) 78.69,84.07 75.8,84.07 74.46,82.73 73.81,82.73 73.14,83.39 73.14,83.62 72.5,84.26 72.47,84.26 72.46,84.28 72.11,84.28 72.09,84.26 71.84,84.26 v5(71.37,83.8) ; v5(54.78,109.54) 54.78,108.29 54.65,108.16 54.65,107.6 54.69,107.56 54.69,105.57 54.31,105.2 54.27,105.2 53.92,104.84 53.92,102.88 v5(53.87,102.83)
  L4 w0.127: v5(85.4,83.84) 84.79,83.84 84.7,83.74 84.55,83.59 83.47,83.59 83.32,83.44 82.98,83.44 82.74,83.68 82.74,84.22 81.47,85.49 80.72,85.49 80.71,85.5 80.36,85.5 80.12,85.25 80.12,85.24 78.88,84.01 v5(78.75,84.01) 78.41,84.01 77.68,84.73 75.03,84.73 74.49,85.28 73.91,85.28 73.12,86.07 72.38,86.07 71.42,87.03 70.7,87.03 70.21,87.51 70.13,87.51 70.12,87.53 70.01,87.53 69.67,87.87 69.02,87.87 68.57,87.42 67.17,87.42 65.75,88.85 65.75,88.86 v5(62.45,92.16) 62.15,92.46 62.14,92.46 61.88,92.72 61.88,92.73 61.82,92.79 61.82,95.85 57.63,100.04 57.63,100.39 56.52,101.5 56.52,103.76 56.1,104.18 56.1,107.3 55.75,107.66 55.75,108.57 v5(54.78,109.54) 54.73,109.59 54.73,113.19 54.14,113.78 54.14,114.51 54.84,115.21 v5(54.84,115.88)
  BOTTOM w0.102: VRAM6.P7 54.44,116.28 v5(54.84,115.88) ; v5(53.87,102.83) 53.92,102.83 54.44,102.31 VRAM5.P7 ; v5(85.4,83.84) 85.84,84.28 VRAM1.P7 ; v5(71.37,83.8) 71.85,84.28 VRAM2.P7 ; RN7508.1 52.77,91.57 52.81,91.57 52.93,91.45 52.93,91.45 52.97,91.41 52.97,91.35 53.03,91.29 53.03,91.27 53.1,91.2 52.83,90.92 52.83,90.92 RN7508.2
  BOTTOM w0.127: v5(74,104.75) 73.53,104.28 72.68,104.28 72.35,103.95 70.25,103.95 69.9,103.6 69.9,103.46 70.05,103.31 70.05,103.17 69.91,103.03 69.76,103.03 69.62,103.17 69.47,103.17 68.97,102.67 68.97,102.52 69.23,102.26 69.23,102.12 69.08,101.97 68.94,101.97 68.68,102.24 68.54,102.24 68.38,102.08 68.38,100.66 65.91,98.18 v3(65.91,97.62) 65.91,95.22 62.85,92.16 v5(62.45,92.16) 62.32,92.29 60.85,92.29 60.48,92.66 58.88,92.66 57.52,91.3 56.1,91.3 55.88,91.08 53.21,91.08 53.1,91.2
MAA2: length 125.8
  TOP w0.102: VRAM2.P3 68.88,84.28 69.18,83.98 v5(69.18,83.88) ; v5(53.71,118.84) 54.35,119.48 VRAM6.P3 ; v5(74.04,107.21) 74.04,107.22 GPU1.K22 ; VRAM1.P3 v5(82.32,83.88) ; v5(50.26,110.63) 50.29,110.63 50.81,110.11 50.81,107.12 50.65,106.96 50.65,105.44 51.18,104.91 51.77,104.32 52.97,104.32 54.04,105.38 v5(54.04,105.84) 54.43,105.45 VRAM5.P3
  TOP w0.127: v1(49.4,110.54) 49.46,110.48 50.1,110.48 v5(50.26,110.63)
  L3 w0.102: 73.6,106.78 72.55,106.78 72.54,106.8 71.8,106.8
  L3 w0.127: v5(50.26,110.63) 50.26,110.79 50.01,111.03 50.01,111.62 50.39,112.01 50.39,116.05 53.19,118.84 v5(53.71,118.84) ; v5(69.18,83.88) 69.18,83.84 69.63,83.4 69.63,83.05 69.5,82.92 69.5,81.96 71.26,80.2 v5(75.43,80.2) 75.6,80.38 76.47,80.38 76.89,80.8 77.68,80.8 78.03,81.15 78.7,81.15 78.81,81.04 79.49,81.04 81.47,83.02 81.47,83.03 v5(82.32,83.88)
  L3 w0.165: v5(74.04,107.21) 74.03,107.21 73.6,106.78 ; 71.8,106.8 71.59,106.59 69.81,106.59 68.92,105.71 68.92,105.24 67.94,104.25 67.94,102.92 67.29,102.27 67.29,100.97 66.97,100.65 66.97,100.65 64.81,98.49 64.81,98.49 62.75,96.43 60.42,96.43 57.4,93.41 56.8,93.41 56.53,93.14 56.53,90.8 v5(56.56,90.77)
  L4 w0.127: v5(50.26,110.63) 50.26,110.4 49.66,109.8 49.66,98.34 50.73,97.28 50.96,97.28 51.31,96.93 51.31,96.69 54.13,93.88 54.13,93.7 53.94,93.51 53.94,93.28 54.15,93.07 54.33,93.07 54.56,93.29 54.71,93.29 54.88,93.13 54.88,92.98 54.67,92.77 54.67,92.64 56.52,90.79 56.54,90.79 v5(56.56,90.77) 56.66,90.67 56.66,90.31 57.58,89.39 57.58,88.33 62.95,82.97 62.95,82.91 65.1,80.76 66.62,80.76 67.34,80.03 67.34,80.03 67.72,79.65 67.72,79.65 67.77,79.6 74.83,79.6 v5(75.43,80.2)
  BOTTOM w0.102: v5(53.71,118.84) 53.72,118.85 53.81,118.85 VRAM6.P3 ; VRAM5.P3 54.43,105.45 v5(54.04,105.84) ; VRAM1.P3 v5(82.32,83.88) ; v5(69.18,83.88) 69.18,83.98 68.88,84.28 VRAM2.P3
  BOTTOM w0.127: RN7507.2 54.51,88.92 54.81,89.22 54.81,89.22 54.95,89.36 54.95,89.52 ; RN7507.1 54.9,89.57 54.95,89.52 ; v5(56.56,90.77) 56.54,90.79 56.2,90.79 55.94,90.54 55.06,90.54 54.95,90.42 54.95,89.52
MAA3: length 121.6
  TOP w0.102: v5(68.29,85.48) 68.29,85.48 VRAM2.N2 ; GPU1.F25 71.96,104.32 71.51,103.87 70.91,103.87 70.73,103.69 70.35,103.69 69.76,103.11 v5(69.76,102.45) ; VRAM6.N2 55.25,120.28 v5(55.66,119.87) ; VRAM5.N2 55.62,106.64 55.62,106.64 v5(55.64,106.65) 55.64,106.68 55.71,106.74 55.71,107.45 55.72,107.46 55.72,109.28 54.7,110.3 54.7,110.58 54.26,111.02 54.26,111.8 54.14,111.92 53.97,111.92 53.85,111.8 53.85,111.42 53.75,111.31 53.54,111.31 53.44,111.42 53.44,111.8 53.32,111.92 53.16,111.92 53.04,111.8 53.04,111.42 52.93,111.31 52.13,111.31 51.65,111.8 v5(51.61,111.8) ; v5(81.52,84.68) VRAM1.N2
  TOP w0.127: RN7501.1 54.97,88.54 55.34,88.91 ; 55.34,88.91 55.62,89.19 55.62,89.5 55.7,89.57 55.7,89.67 55.92,89.9 55.92,90.18 55.76,90.34 55.76,91.09 56.89,92.21 v1(57.85,92.21) 57.9,92.16 58.62,92.16 v5(58.84,91.93) ; 55.34,88.91 55.05,89.19 RN7501.2
  L3 w0.127: v5(76.04,82.52) 77.32,82.52 78.01,81.84 79.15,81.84 79.57,82.26 79.57,83.15 79.87,83.45 79.87,83.68 79.98,83.78 79.98,84.34 80.23,84.59 80.76,84.59 81.44,85.28 81.98,85.28 82.11,85.15 82.11,84.81 81.98,84.68 v5(81.52,84.68)
  L4 w0.127: v5(51.61,111.8) 52.02,111.38 52.02,109.5 51.66,109.13 51.66,107.58 52.27,106.97 52.27,105.5 52.62,105.14 52.62,104.61 52.47,104.46 52.47,103.47 51.9,102.89 51.9,101.73 53.22,100.4 53.22,99.83 58.18,94.87 58.18,93.39 58.84,92.73 v5(58.84,91.93) 58.9,91.88 58.9,91.7 59.81,90.79 59.81,90.63 59.82,90.62 59.82,90.33 61.32,88.84 61.97,88.84 63.63,87.17 63.97,87.17 64.88,86.26 64.88,86.22 66.35,84.75 66.56,84.75 67.05,84.26 67.05,82.92 67.41,82.56 68.76,82.56 69.94,81.38 73.48,81.38 73.95,81.85 74.97,81.85 75.65,82.52 v5(76.04,82.52)
  BOTTOM w0.102: VRAM6.N2 55.25,120.28 v5(55.66,119.87) 55.61,119.83 55.12,119.83 54.83,119.54 54.83,119.24 53.15,117.56 53.08,117.56 52.1,116.58 52.1,115.67 52.1,115.12 51.7,114.72 51.7,111.89 v5(51.61,111.8) ; v5(55.64,106.65) 55.62,106.64 55.62,106.64 VRAM5.N2 ; v5(76.04,82.52) 74.21,82.52 73.31,81.62 72.52,81.62 72,82.14 71.47,82.14 70.43,83.19 70.43,83.57 70.42,83.57 70.42,84.16 70.07,84.52 70.05,84.52 69.08,85.48 v5(68.29,85.48) 68.29,85.48 VRAM2.N2 ; VRAM1.N2 v5(81.52,84.68)
  BOTTOM w0.127: v5(69.76,102.45) 69.76,101.84 69.67,101.75 69.67,101.37 66.44,98.13 66.44,95.27 62.55,91.38 60.79,91.38 60.39,91.77 59.8,91.77 59.77,91.81 58.97,91.81 v5(58.84,91.93)
MAA4: length 108.1
  TOP w0.102: VRAM5.P8 54.06,101.83 v5(54.06,101.87) ; v5(73.09,84.64) 73.05,84.64 VRAM2.P8 ; VRAM1.P8 86.71,84.28 v5(86.31,83.88) ; v5(54.06,115.89) 54.06,115.87 54.44,115.49 VRAM6.P8
  TOP w0.127: GPU1.M25 71.57,108.87 70.52,108.87 69.98,108.32 69.16,108.32 66.43,105.6 66.43,100.03 65.23,98.82 63.6,98.82 61.99,97.21 v1(61.99,96.35) 61.99,96.23 61.88,96.11 RN7502.2 61.46,94.39 61.33,94.27 61.33,93.87 61.46,93.74 RN7502.1 61.88,93.52 61.53,93.18 61.53,92.12 61.81,91.84 v5(61.81,91.84)
  L3 w0.127: v5(54.06,101.87) 54.02,101.91 54.02,101.96 53.45,102.53 53.45,103.12 53.68,103.36 53.68,105.06 54.04,105.42 54.21,105.42 54.46,105.67 54.46,106.83 54.19,107.1 53.41,107.1 53.26,107.25 53.26,107.91 53.28,107.94 53.28,108.11 54.29,109.13 v5(54.29,110.22) 54.29,111.2 54.4,111.3 55.22,111.3 55.34,111.42 55.34,111.59 55.22,111.71 54.4,111.71 54.29,111.81 54.29,112.01 54.4,112.12 55.22,112.12 55.34,112.24 55.34,112.4 55.22,112.52 54.4,112.52 54.29,112.62 54.29,113.51 54.19,113.61 54.19,115.74 54.06,115.87 v5(54.06,115.89) ; v5(79.54,83.96) 79.07,84.43 75.67,84.43 74.82,83.58 73.7,83.58 73.09,84.19 v5(73.09,84.64)
  L4 w0.127: v5(86.31,83.88) 85.86,83.43 85.58,83.43 85.57,83.42 85.22,83.42 85.21,83.43 85.16,83.43 85.12,83.48 84.75,83.48 84.64,83.36 84.61,83.36 84.59,83.35 83.69,83.35 83.02,82.67 81.61,82.67 81.24,83.04 80.23,83.04 79.54,83.73 v5(79.54,83.96) 79.17,83.59 78.28,83.59 77.48,84.39 74.26,84.39 74.21,84.44 73.99,84.44 73.75,84.69 73.75,85.11 73.07,85.79 71.36,85.79 70.92,86.23 70.92,86.35 70.6,86.68 69.66,86.68 69.21,87.13 66.98,87.13 62.91,91.2 62.46,91.2 v5(61.81,91.84) 61.81,92.3 61.47,92.64 61.47,95.7 57.27,99.91 57.27,100.39 56.18,101.48 56.18,102.73 55.67,103.24 55.67,103.77 55.16,104.28 55.16,107.47 54.89,107.74 54.89,108.03 54.91,108.04 54.91,108.81 54.36,109.36 54.36,109.53 54.29,109.59 v5(54.29,110.22)
  BOTTOM w0.102: v5(73.09,84.64) 73.05,84.64 VRAM2.P8 ; VRAM6.P8 54.44,115.49 54.06,115.87 v5(54.06,115.89) ; v5(86.31,83.88) 86.32,83.88 VRAM1.P8
  BOTTOM w0.127: VRAM5.P8 54.44,101.46 54.06,101.84 v5(54.06,101.87)
MAA5: length 125.7
  TOP w0.102: v5(54.03,119.88) 54.09,119.88 54.44,120.23 VRAM6.P2 ; VRAM1.P2 v5(81.52,83.88) ; v5(51.25,112.33) 51.15,112.23 51.15,111 51.49,110.67 52.33,110.67 53.15,109.84 53.15,109.53 53.13,109.51 53.13,109.49 52.89,109.26 52.88,109.26 52.85,109.23 52.06,109.23 51.7,108.88 51.7,108.75 51.83,108.62 52.85,108.62 53.07,108.39 53.58,108.39 54.08,107.89 54.08,106.7 v5(54.04,106.66) 54.05,106.65 54.05,106.63 54.43,106.25 VRAM5.P2 ; v5(68.31,83.88) 67.92,84.28 VRAM2.P2
  TOP w0.127: GPU1.J25 71.62,106.44 70.05,106.44 68.16,104.55 68.16,98.48 66.14,96.46 66.14,96.15 64.69,94.7 64.69,94.27 63.87,93.45 63.87,93.13 63.79,93.06 63.79,90.51 62.88,89.6 60.22,89.6 v1(59.97,89.84) 59.91,89.84 59.9,89.84 59.34,89.84 58.43,90.74 58.18,90.74 v5(58.01,90.92)
  L3 w0.127: v5(68.31,83.88) 68.73,84.3 69.96,84.3 70.23,84.03 70.23,82.98 69.72,82.47 69.72,82.06 71.09,80.69 v5(74.24,80.69) 74.25,80.69 74.28,80.72 76.31,80.72 76.73,81.14 77.51,81.14 77.87,81.49 79.34,81.49 79.95,82.1 79.95,82.73 80.26,83.04 80.63,83.04 81.46,83.88 v5(81.52,83.88) ; v5(54.03,119.88) 54.17,119.74 54.17,118.51 51.63,115.96 51.4,115.96 51.12,115.68 51.12,112.45 v5(51.25,112.33)
  L4 w0.127: v5(51.25,112.33) 51.19,112.27 51.19,110.54 50.85,110.21 50.85,107.35 50.82,107.32 50.82,101.05 51.4,100.46 51.4,99.85 53.58,97.67 53.58,96.94 53.59,96.94 53.59,96.89 55.59,94.88 55.59,93.97 56.02,93.54 56.02,92.91 58.01,90.92 v5(58.01,90.92) 58.01,90.86 58.44,90.42 58.44,90.26 58.74,89.95 58.74,89.95 59.55,89.14 59.55,88.58 59.73,88.4 60.29,88.4 60.54,88.15 60.54,87.34 60.67,87.21 60.85,87.21 60.97,87.34 60.97,87.67 61.1,87.79 61.18,87.79 61.31,87.79 61.69,87.42 61.69,86.85 61.81,86.73 62.32,86.73 62.49,86.56 62.49,86.1 62.78,85.81 63.03,85.81 63.34,86.12 63.49,86.12 65.6,84.01 65.6,82.41 66.39,81.62 67.25,81.62 68.24,80.63 74.13,80.63 74.18,80.68 74.22,80.68 v5(74.24,80.69)
  BOTTOM w0.102: v5(54.04,106.66) 54.44,106.26 VRAM5.P2 ; VRAM1.P2 v5(81.52,83.88) ; VRAM6.P2 v5(54.03,119.88) ; v5(68.31,83.88) 67.92,84.28 VRAM2.P2
  BOTTOM w0.127: RN7505.1 52.76,87.58 53.41,88.23 ; 53.41,88.23 53.58,88.4 54.48,88.4 55.15,89.07 55.15,89.08 55.29,89.22 55.29,89.26 56.25,90.22 57.13,90.22 57.83,90.92 v5(58.01,90.92) ; 53.41,88.23 RN7505.2
MAA6: length 106.8
  TOP w0.102: v5(53.2,101.84) 53.25,101.84 VRAM5.R8 ; GPU1.D26 71.15,102.62 v5(70.78,102.25) ; v5(53.23,115.09) 53.46,115.31 53.47,115.31 VRAM6.R8 ; VRAM2.R8 72.69,83.48 72.32,83.86 v5(72.28,83.86) ; VRAM1.R8 v5(86.32,83.08)
  L3 w0.127: v5(53.28,109.05) 53.15,108.93 52.85,108.93 52.2,108.27 52.2,107.6 52.62,107.18 52.62,106.15 52.49,106.03 52.49,105.55 52.85,105.2 52.85,104.36 52.73,104.24 52.73,102.8 53.2,102.33 v5(53.2,101.84) ; v5(72.28,83.86) 72.32,83.86 73.77,82.41 74.47,82.41 75.79,83.73 78.23,83.73 78.37,83.59 78.73,83.59 78.75,83.58 78.96,83.58 79.25,83.29 79.25,82.93 v5(78.96,82.64)
  L3 w0.165: v5(61.69,90.54) 61.69,90.85 62.37,91.53 62.55,91.53 71.02,100 71.02,102 v5(70.78,102.25)
  L4 w0.127: v5(53.23,115.09) 52.67,115.09 52.02,114.44 52.02,114.42 51.86,114.25 51.86,113.96 53.33,112.48 53.33,109.1 v5(53.28,109.05) 53.26,109.03 53.26,108.7 53.77,108.19 53.82,108.19 54.32,107.68 54.32,106.97 54.67,106.62 54.67,105.82 54.06,105.21 54.06,103.25 54.29,103.02 54.29,102.67 54.67,102.28 55.01,102.28 55.28,102.01 55.28,100.96 56.51,99.73 56.51,99.5 59.96,96.05 59.96,95.06 60.79,94.23 60.79,92.35 60.85,92.29 60.85,91.47 61.69,90.63 v5(61.69,90.54) 62.24,89.99 63.1,89.99 66.44,86.65 68.04,86.65 69.43,85.25 69.43,85.18 70.47,84.14 70.47,83.15 71.11,82.51 72.33,82.51 72.5,82.68 74.73,82.68 75.72,83.67 77.15,83.67 78.07,82.74 78.33,82.74 78.37,82.7 78.89,82.7 v5(78.96,82.64) 80.66,80.93 82.44,80.93 84.14,82.64 85.23,82.64 85.27,82.68 85.92,82.68 v5(86.32,83.08)
  BOTTOM w0.102: VRAM2.R8 72.69,83.48 72.32,83.86 v5(72.28,83.86) ; VRAM5.R8 53.25,101.84 v5(53.2,101.84) ; VRAM6.R8 53.64,115.48 53.62,115.48 v5(53.23,115.09) ; v5(86.32,83.08) VRAM1.R8
  BOTTOM w0.127: v5(61.69,90.54) 61.08,89.93 61.08,87.51 60.95,87.39 ; 60.95,87.39 60.75,87.39 60.47,87.11 60.42,87.11 60.38,87.07 60.38,87.07 60.27,86.96 RN7517.1 ; 60.95,87.39 60.92,87.35 RN7517.2 ; v5(78.96,82.64) 78.96,82.28 78.48,81.8 v3(78.48,81.55)
MAA7: length 128.5
  TOP w0.102: v5(67.48,83.07) VRAM2.R2 ; v5(51.48,106.61) 53.28,106.61 VRAM5.R2 ; v5(53.24,119.87) 53.24,119.9 53.64,120.28 VRAM6.R2 ; v5(81.5,81.68) 81.5,83.06 VRAM1.R2
  TOP w0.127: RN7501.4 54.74,90.35 55.09,90 v5(55.39,90) ; v5(55.39,90) 55.34,90.05 55.34,90.46 55.19,90.61 55.19,91.35 55.31,91.48 v1(55.31,91.83) 55.31,92.32 56.58,93.58 57.29,93.58 63.25,99.54 63.82,99.54 63.85,99.58 64.39,99.58 65.77,100.97 65.77,106.48 68.33,109.04 69.64,109.04 70.23,109.64 70.82,109.64 GPU1.M26 ; v5(55.39,90) 55.08,89.7 RN7501.3
  L3 w0.127: v5(67.48,83.07) 67.81,82.75 67.81,81.06 70.33,78.55 74,78.55 v5(74.13,78.42) 74.3,78.26 76.59,78.26 78.34,80.01 79.61,80.01 81.28,81.68 v5(81.5,81.68) ; v5(53.24,119.87) 52.82,119.46 52.23,119.46 51.99,119.21 51.99,119.1 49.28,116.39 49.28,112.59 49.24,112.56 49.24,112.2 48.94,111.9 v5(48.94,111.37) 48.94,111.08 49.29,110.73 49.29,108.16 49.42,108.04 49.97,108.04 50.09,108.16 50.09,109.33 50.22,109.46 50.77,109.46 50.89,109.33 50.89,107.19 v5(51.48,106.61)
  L4 w0.127: v5(74.13,78.42) 65.98,78.42 61.92,82.49 61.92,82.54 55.46,89 55.46,89.93 55.39,90 v5(55.39,90) 55.39,90.2 50.56,95.03 48.63,97.92 48.63,110.23 v5(48.94,111.37)
  BOTTOM w0.102: v5(67.48,83.07) VRAM2.R2 ; VRAM6.R2 53.64,120.28 v5(53.24,119.87) ; v5(81.5,81.68) 81.5,83.06 VRAM1.R2
  BOTTOM w0.127: VRAM5.R2 53.57,106.25 53.22,106.61 v5(51.48,106.61)
MAA8: length 128.2
  TOP w0.102: v5(70.14,82.23) 70.18,82.27 72.08,82.27 72.49,82.68 VRAM2.T8 ; VRAM6.T8 51.72,115.48 v5(51.7,115.5) ; GPU1.F23 73.2,103.94 v5(73.2,103.85) ; VRAM5.T8 51.91,102.38 51.91,103.37 51.98,103.44 v5(51.98,103.58) ; VRAM1.T8 85.74,81.7 84.8,81.7 v5(84.67,81.82)
  L3 w0.127: v5(51.7,115.5) 51.58,115.39 51.58,113.07 52.06,112.59 52.06,110.31 v5(51.56,109.82) 51.39,109.64 51.39,107.39 51.94,106.84 51.94,106.46 51.38,105.9 51.38,105.07 51.98,104.46 v5(51.98,103.58) ; v5(76.72,81.62) 76.63,81.71 75.86,81.71 75.57,81.42 75.3,81.42 75.1,81.22 74.04,81.22 73.86,81.03 72.2,81.03 72.2,81.04 71.27,81.04 71.06,81.24 71.06,81.42 71.26,81.62 71.26,81.8 71.08,81.98 70.39,81.98 v5(70.14,82.23)
  L4 w0.127: v5(51.56,109.82) 51.56,109.8 51.4,109.64 51.4,107.43 51.91,106.92 51.91,106.36 51.4,105.85 51.4,101.61 52.04,100.98 52.04,100.04 52.62,99.45 52.82,99.45 57.83,94.45 57.83,92.89 57.98,92.74 57.98,92.13 59.37,90.74 v5(59.37,90.44) 59.37,90.29 61.19,88.48 61.59,88.48 63.24,86.83 63.82,86.83 66.13,84.52 66.46,84.52 66.74,84.24 66.74,82.84 68.5,81.09 73.53,81.09 74.06,81.62 75.25,81.62 75.71,82.08 76.26,82.08 v5(76.72,81.62) 76.78,81.62 78.14,80.26 83.1,80.26 v5(84.67,81.82)
  BOTTOM w0.102: v5(59.37,90.44) 58.66,89.72 58.66,88.78 58.33,88.45 ; v5(70.14,82.23) 69.79,82.59 69.26,82.59 68.84,83.01 68.22,83.01 VRAM4.T8 ; VRAM7.T8 51.7,106.25 51.43,105.98 51.43,103.68 51.53,103.58 v5(51.98,103.58) ; 58.33,88.45 58.48,88.31 RN7514.2 ; 58.33,88.45 58.12,88.45 57.83,88.17 RN7514.1 ; v5(51.7,115.5) 51.7,119.14 VRAM8.T8 ; VRAM3.T8 81.92,81.81 82.42,81.32 83.49,81.32 84,81.82 v5(84.67,81.82)
  BOTTOM w0.127: v5(73.2,103.85) 72.76,103.85 72.53,103.62 71.51,103.62 71.13,103.24 71.13,103.03 70.78,102.68 70.6,102.68 70.19,102.27 v3(70.19,101.54) 70.19,101.3 66.83,97.94 66.83,95.08 62.77,91.02 60.47,91.02 60.17,90.71 59.65,90.71 v5(59.37,90.44)
MAA9: length 118.3
  TOP w0.102: VRAM6.R3 53,118.84 v5(53,117.99) ; RN7504.1 61.27,88.55 60.95,88.87 60.62,88.55 RN7504.2 ; v5(50.43,111.39) 50.51,111.31 50.51,111.06 51.15,110.42 51.15,107.18 50.85,106.88 50.85,105.53 51.86,104.52 52.38,104.52 53.23,105.37 v5(53.23,105.85)
  TOP w0.127: VRAM2.R3 68.95,83.48 v5(69.21,83.22) ; v5(57.09,88.89) 57.54,89.33 58.82,89.33 59.27,88.87 63.19,88.87 63.89,89.57 v1(64.28,89.57) 64.31,89.57 64.64,89.9 64.64,93 65.34,93.71 65.34,94.44 68.9,98 68.9,101.14 69.79,102.03 69.94,102.03 70.38,102.47 GPU1.D27 ; VRAM5.R3 53.64,105.45 v5(53.23,105.85) ; v5(82.31,83.09) 82.33,83.09 VRAM1.R3
  L3 w0.127: v5(69.21,83.22) 69.21,81.82 71.25,79.78 75.97,79.78 v5(76.06,79.87) 76.47,79.87 76.73,79.62 76.98,79.62 78.17,80.81 79.69,80.81 81.97,83.09 v5(82.31,83.09) ; v5(50.43,111.39) 50.75,111.71 50.75,115.74 v5(53,117.99)
  L4 w0.127: v5(76.06,79.87) 75.69,79.87 75.6,79.78 75.49,79.78 74.97,79.26 67.3,79.26 67.15,79.41 67.15,79.72 67,79.87 66.78,79.87 66.64,79.72 66.64,79.39 66.51,79.26 66.12,79.26 65.83,79.55 65.83,79.73 66.1,80 66.1,80.18 65.92,80.36 65.74,80.36 65.47,80.09 65.29,80.09 62.6,82.77 62.6,82.83 57.09,88.34 v5(57.09,88.89) 56.94,89.04 56.94,89.52 56.29,90.17 56.29,90.37 53.66,93 51.92,95.6 49.32,98.2 49.32,109.95 49.81,110.44 49.81,110.81 50.07,111.07 50.12,111.07 v5(50.43,111.39)
  BOTTOM w0.102: v5(53,117.99) 53,118.84 VRAM6.R3
  BOTTOM w0.127: v5(69.21,83.22) 68.95,83.48 VRAM2.R3 ; VRAM5.R3 53.64,105.45 v5(53.23,105.85) ; VRAM1.R3 82.33,83.09 v5(82.31,83.09)
MAA10: length 98.8
  TOP w0.102: v5(56.1,103.54) 56.27,103.38 56.27,103.09 56.84,102.52 VRAM5.L7 ; v5(85.14,86.04) 85.78,86.68 VRAM1.L7 ; VRAM2.L7 71.62,86.41 v5(71.34,86.41) ; v5(73.18,106.36) 73.18,106.4 GPU1.J23 ; v5(56.57,116.84) 56.57,116.55 VRAM6.L7
  L3 w0.102: 71.82,105.96 72.78,105.96 v5(73.18,106.36)
  L3 w0.127: v5(56.57,116.84) 56.57,115.59 56.63,115.52 56.63,112.18 56.56,112.1 56.56,110.36 v5(56.57,110.35) 56.49,110.27 56.49,109.02 56.91,108.59 56.91,105.93 56.15,105.17 56.15,103.59 v5(56.1,103.54) ; v5(71.34,86.41) 71.34,86.4 71.54,86.19 73.63,86.19 74.24,86.8 77.59,86.8 77.82,86.57 v5(78.22,86.57) 78.3,86.65 78.48,86.65 78.53,86.7 78.58,86.7 78.78,86.9 82.77,86.9 82.92,87.06 83.74,87.06 84.5,86.3 84.89,86.3 v5(85.14,86.04)
  L3 w0.165: v5(63.74,94.5) 63.74,94.64 68.75,99.65 68.75,101.92 69.05,102.22 69.05,102.74 69.47,103.16 69.5,103.16 69.62,103.28 70.33,104 70.33,105.75 70.6,106.02 71.77,106.02 71.82,105.96
  L4 w0.127: v5(56.57,110.35) 57.35,109.57 57.35,107.94 58.64,106.64 58.64,104.89 59.17,104.37 59.17,104.21 59.18,104.19 59.18,103.8 58.77,103.38 58.77,102.76 59,102.53 59,102.34 60.29,101.06 60.29,100.3 60.3,100.29 60.3,99.94 60.29,99.93 60.29,99.89 60.25,99.85 60.25,99.36 63.3,96.31 63.3,95.22 63.74,94.78 v5(63.74,94.5) 64.69,93.56 64.69,91.94 65.34,91.28 66.15,91.28 66.48,90.96 68.56,90.96 68.9,90.61 69.28,90.61 69.34,90.56 69.35,90.56 70.35,89.57 70.37,89.57 70.89,89.06 70.89,89.01 71.52,88.38 73.27,88.38 74.17,87.48 74.38,87.48 75.4,86.45 77.79,86.45 77.92,86.57 v5(78.22,86.57)
  BOTTOM w0.102: v5(56.1,103.54) 56.27,103.38 56.27,103.3 56.84,102.72 VRAM5.L7 ; v5(71.34,86.41) 71.34,86.42 71.6,86.68 VRAM2.L7 ; v5(56.57,116.84) 56.57,116.55 VRAM6.L7 ; VRAM1.L7 85.78,86.68 v5(85.14,86.04)
  BOTTOM w0.127: v5(63.74,94.5) 63.64,94.4 63.42,94.4 63.33,94.31 62.16,94.31 v3(62.05,94.42) 61.85,94.62 59.39,94.62 59.37,94.64 ; 59.37,94.64 59.08,94.93 RN7511.1 ; 59.37,94.64 59,94.28 RN7511.2
MAA11: length 106.2
  TOP w0.102: VRAM6.R7 54.04,116.68 v5(54.04,116.71) ; VRAM1.R7 85.5,83.06 v5(84.95,83.06) ; v5(72.29,83.07) 72.28,83.08 72.28,83.08 VRAM2.R7 ; v5(53.15,103.41) 53.15,102.74 VRAM5.R7
  TOP w0.127: GPU1.K26 70.74,108.04 69.36,108.04 66.77,105.44 66.77,101.25 66.66,101.15 66.66,99.93 65.32,98.59 64.48,98.59 v1(63.52,97.62) 62.96,97.06 62.96,95.41 62.59,95.04 62.59,94.87 62.52,94.8 62.52,94.55 62.5,94.53 62.5,93.86 62.62,93.74 62.62,93.35 62.64,93.34 62.64,93.27 63.03,92.88 63.03,91.37 62.5,90.85 62.5,90.69 62.4,90.59 v5(62.4,90.58)
  L3 w0.127: v5(53.15,103.41) 53.15,104.02 53.32,104.19 53.32,105.08 52.72,105.68 52.72,105.93 53,106.21 53,107.89 53.03,107.91 53.03,108.01 53.03,108.01 53.03,108.2 53.75,108.91 53.75,109.42 v5(53.84,109.51) ; v5(72.29,83.07) 72.57,82.79 72.84,82.79 73.49,82.14 74.52,82.14 75.76,83.37 77.97,83.37 78.2,83.15 v5(78.55,83.15)
  L4 w0.127: v5(54.04,116.71) 53.64,116.31 53.64,115.6 53.89,115.35 53.89,114.33 53.91,114.31 53.91,113.97 53.89,113.95 53.89,113.56 53.84,113.5 v5(53.84,109.51) 54.67,108.67 54.67,108.13 54.67,108.13 54.67,107.52 54.9,107.29 54.9,104.27 54.73,104.1 54.73,103.44 55.21,102.96 55.21,102.45 55.95,101.71 55.95,101.39 56,101.34 56,101.18 56.94,100.24 56.94,99.55 60.31,96.19 60.31,95.56 60.32,95.55 60.32,95.19 61.13,94.37 61.13,92.49 61.19,92.43 61.19,91.82 62.39,90.63 62.39,90.59 v5(62.4,90.58) 62.51,90.58 62.6,90.49 63.14,90.49 66.74,86.88 68.22,86.88 69.66,85.43 69.66,85.27 70.66,84.28 71.71,84.28 71.82,84.39 71.82,85.28 72.11,85.57 72.91,85.57 73.52,84.95 73.52,84.59 73.53,84.59 73.53,83.73 73.67,83.59 74.55,83.59 74.97,84.01 77.31,84.01 78.17,83.15 v5(78.55,83.15) 79.31,83.15 80.25,82.21 80.25,82.21 80.28,82.18 80.63,82.18 80.92,82.46 81.5,82.46 81.51,82.44 83.12,82.44 83.73,83.06 v5(84.95,83.06)
  BOTTOM w0.102: v5(53.15,103.41) 53.15,102.74 VRAM5.R7 ; v5(84.95,83.06) 85.5,83.06 VRAM1.R7 ; VRAM6.R7 53.64,116.31 v5(54.04,116.71) ; RN7516.1 61.94,90.12 v5(62.4,90.58) 62.4,90.56 62.45,90.51 62.45,90.41 62.59,90.27 RN7516.2 ; v5(72.29,83.07) 72.28,83.08 72.28,83.08 VRAM2.R7
MAA12: length 107.8
  TOP w0.102: v5(71.27,84.81) 71.62,84.81 VRAM2.N7 ; GPU1.G22 74.42,105.12 v5(74,105.54) ; v5(54.76,116.75) 54.77,116.75 54.77,116.73 55.22,116.28 55.24,116.28 VRAM6.N7 ; VRAM5.N7 54.79,102.69 54.79,102.74 54.72,102.82 v5(54.72,102.83) ; v5(85.48,84.72) 85.58,84.72 85.92,85.06 VRAM1.N7
  L3 w0.102: 72.24,104.01 72.77,104.55 72.77,104.88 73.04,105.14 73.6,105.14 v5(74,105.54)
  L3 w0.127: v5(54.72,102.83) 54.72,102.84 54.79,102.92 54.79,104.2 55.19,104.59 55.19,104.62 55.24,104.67 55.24,105.35 56.12,106.24 56.12,106.97 55.75,107.35 55.75,110.16 v5(55.71,110.19) ; v5(78.7,85.28) 74.34,85.28 74.34,85.28 73.99,85.28 73.99,85.28 73.37,85.28 73.34,85.31 72.6,85.31 72.57,85.28 71.73,85.28 v5(71.27,84.81)
  L3 w0.165: 72.24,104.01 71.9,104.01 71.1,103.21 71.1,102.99 70.8,102.69 70.6,102.69 70.33,102.42 70.33,102.32 69.61,101.6 69.61,99.15 63.92,93.46 v5(63.08,93.46)
  L4 w0.127: v5(85.48,84.72) 84.82,85.38 84.37,85.38 84.32,85.43 84.31,85.43 84.06,85.68 84.06,85.69 83.68,86.08 82.93,86.08 82.26,86.75 80.22,86.75 78.75,85.28 v5(78.7,85.28) 78.5,85.48 75.54,85.48 74.21,86.8 72.34,86.8 71.52,87.62 71.52,87.72 71.13,88.11 71.11,88.11 70.43,88.79 70.43,88.87 70.19,89.11 69.51,89.11 68.73,89.89 68.12,89.89 68.1,89.9 66.97,89.9 66.72,90.16 65.5,90.16 64.04,91.61 64.04,92.5 v5(63.08,93.46) 62.56,93.98 62.56,96.08 60.67,97.96 60.67,98 58.91,99.77 58.62,99.77 58.37,100.02 58.37,100.55 56.98,101.94 56.98,103.56 57.32,103.9 57.32,105.35 56.83,105.84 56.83,108.83 55.71,109.95 v5(55.71,110.19) 55.71,111.21 55.68,111.24 55.68,111.59 55.71,111.62 55.71,111.69 56.9,112.88 56.9,114.62 v5(54.76,116.75)
  BOTTOM w0.102: VRAM2.N7 71.62,84.81 v5(71.27,84.81) ; RN7506.4 54.37,93.93 54.53,94.09 54.53,94.32 54.27,94.58 RN7506.3 ; VRAM5.N7 54.79,102.69 54.79,102.74 54.72,102.82 v5(54.72,102.83) ; v5(85.48,84.72) 85.56,84.72 VRAM1.N7 ; VRAM6.N7 55.24,116.28 v5(54.76,116.75)
  BOTTOM w0.127: 54.53,94.09 54.78,93.84 54.78,93.29 55.37,92.7 56.2,92.7 56.53,92.37 57.37,92.37 v3(58.03,93.03) 58.4,93.39 59.68,93.39 59.7,93.38 60.07,93.38 60.15,93.46 v5(63.08,93.46)
MAA13: length 124.2
  TOP w0.102: VRAM1.T3 83.15,83.11 83.15,83.9 83.17,83.92 v5(83.17,83.96) ; v5(49.59,111.8) 49.59,112.08 49.72,112.2 50.22,112.2 50.89,111.53 50.89,110.98 51.58,110.28 51.67,110.28 51.97,109.98 51.97,109.61 51.47,109.12 51.47,107.17 51.07,106.77 51.07,105.59 51.74,104.93 v5(52.2,104.93) 52.2,105.01 52.64,105.45 VRAM5.T3 ; v5(52.4,119.04) 52.84,119.47 VRAM6.T3 ; v5(68.62,82.05) 68.62,82.3 68.69,82.36 VRAM2.T3
  TOP w0.127: GPU1.F27 70.26,104.44 69.03,104.44 68.49,103.91 68.49,98.15 66.69,96.35 66.69,96.25 65.02,94.57 65.02,94.12 64.21,93.31 64.21,90.45 63.02,89.25 59.43,89.25 58.96,89.72 57.37,89.72 v1(57.09,90) 56.48,89.4 v5(56.48,89.34)
  L3 w0.127: v5(52.4,119.04) 49.75,116.39 49.75,111.95 v5(49.59,111.8) ; v5(83.17,83.96) 83.17,83.36 82.48,82.67 81.9,82.67 79.58,80.35 78.2,80.35 77.06,79.21 v5(76.55,79.21) 76.09,79.21 75.86,79.44 74.49,79.44 74.47,79.41 71.13,79.41 68.86,81.68 68.86,81.82 v5(68.62,82.05)
  L4 w0.127: v5(49.59,111.8) 49.59,111.08 49.42,110.91 49.42,110.53 48.98,110.09 48.98,98.06 51.42,95.61 53.39,92.68 55.92,90.15 55.92,89.91 v5(56.48,89.34) 56.56,89.26 56.56,88.38 62.26,82.68 62.26,82.63 65.97,78.92 75.11,78.92 75.41,79.21 v5(76.55,79.21)
  BOTTOM w0.102: v5(56.48,89.34) 56.47,89.33 ; 56.47,89.33 RN7513.2 ; 56.47,89.33 55.82,88.68 RN7513.1 ; VRAM2.T3 68.69,82.36 68.62,82.3 v5(68.62,82.05) ; v5(83.17,83.96) 83.17,83.92 83.15,83.9 83.15,83.11 VRAM1.T3 ; v5(52.2,104.93) 52.2,105.01 52.64,105.45 VRAM5.T3 ; v5(52.4,119.04) 52.84,119.47 VRAM6.T3
MAA14: length 107.2
  TOP w0.102: GPU1.G27 70.14,105.12 v5(69.74,105.52) ; VRAM1.T7 85.67,82.68 85.44,82.45 v5(85.44,82.26) ; VRAM6.T7 52.84,116.26 v5(53.21,115.88) ; v5(52.32,102.62) 52.33,102.6 52.33,102.56 52.64,102.25 VRAM5.T7 ; v5(71.47,83.02) 71.5,82.99 71.57,82.99 VRAM2.T7
  L3 w0.127: v5(52.72,109.66) 51.92,108.86 51.92,107.56 52.39,107.08 52.39,106.27 52.27,106.15 52.27,105.46 52.62,105.1 52.62,104.45 52.52,104.35 52.4,104.23 52.4,102.73 52.32,102.65 v5(52.32,102.62) ; v5(71.47,83.02) 71.5,82.99 71.5,82.32 72.27,81.55 73.58,81.55 73.91,81.88 74.8,81.88 75.94,83.02 77.43,83.02 78.17,82.28 v5(78.2,82.28)
  L3 w0.165: v5(69.74,105.52) 69.74,103.81 68.78,102.85 68.78,102.64 68.27,102.12 68.27,100.85 60.9,93.48 v5(60.9,90.56)
  L4 w0.127: v5(85.44,82.26) 85.38,82.26 85.27,82.37 84.38,82.37 82.61,80.6 79.85,80.6 78.53,81.92 78.53,81.93 78.2,82.26 v5(78.2,82.28) 77.92,82.28 77.68,82.52 77.37,82.52 77.09,82.8 77.09,83.11 76.88,83.32 75.71,83.32 74.72,82.33 73.5,82.33 73.39,82.45 72.62,82.45 72.41,82.23 71.07,82.23 70.23,83.07 70.23,84.03 69.87,84.39 69.49,84.39 68.9,84.97 68.9,85.46 67.97,86.4 66.21,86.4 62.95,89.65 61.83,89.65 61.53,89.65 60.9,90.27 v5(60.9,90.56) 60.87,90.59 60.87,90.8 60.51,91.16 60.51,92.15 60.44,92.21 60.44,92.42 58.9,93.97 58.9,95.41 55.86,98.45 55.86,100.03 55.32,100.57 55.16,100.57 54.29,101.45 53.89,101.45 53.64,101.69 53.64,102.18 53.45,102.37 53.45,103.12 53.57,103.24 53.57,103.59 53.08,104.08 53.08,105.34 52.82,105.59 52.82,105.67 52.82,105.68 52.82,106.02 53.05,106.26 53.05,108.58 52.75,108.88 52.75,109.63 v5(52.72,109.66) 53.03,109.97 53.03,112.17 51.54,113.66 51.54,114.4 53.02,115.88 v5(53.21,115.88)
  BOTTOM w0.102: v5(71.47,83.02) 71.5,82.99 71.57,82.99 VRAM2.T7 ; v5(53.21,115.88) 53.21,115.9 52.84,116.28 VRAM6.T7 ; VRAM1.T7 85.61,82.37 85.55,82.37 v5(85.44,82.26) ; v5(52.32,102.62) 52.33,102.6 52.33,102.56 52.64,102.25 VRAM5.T7
  BOTTOM w0.127: v3(77.69,83.02) 77.69,82.79 v5(78.2,82.28) ; RN7515.1 59.89,90.01 60.26,90.37 60.31,90.37 60.5,90.56 v5(60.9,90.56) 60.54,90.2 RN7515.2
MCLK: length 6
  TOP w0.102: U109.80 103.87,57.17 104.74,57.17 105.02,56.88 106.11,56.88 106.48,57.25 v2(106.48,57.61)
  BOTTOM w0.102: RN3.1 107.53,56.95 v3(107.03,56.45) 106.98,56.45 106.5,56.93 106.5,57.6 v2(106.48,57.61)
MCT_R:
  vias: v1(84.4,9.77)
MCT_R_1:
  vias: v2(87.29,11.34) v3(87.45,13.32)
MDA0: length 23.1
  TOP w0.127: v5(78.19,103.01) 78.18,103.02 78.16,103.02 GPU1.E18 ; v5(73.09,91.08) 72.7,90.68 VRAM2.F8
  L3 w0.165: v5(78.19,103.01) 77.94,103.01 77.84,102.9 77.84,101.51 77.56,101.23 77.56,100.75 77.84,100.47 77.84,100.19 77.71,100.06 77.23,100.06 77.03,99.86 77.03,97.62 77.16,97.49 77.16,96.89 77.03,96.75 77.03,96.25 77.15,96.12 77.81,96.12 77.93,96.01 77.93,95.53 77.81,95.41 77.29,95.41 77.16,95.29 77.16,94.8 77.02,94.66 77.02,92.56 76.85,92.4 75.75,92.4 75.58,92.23 75.58,91.9 75.75,91.74 76.85,91.74 77.02,91.57 77.02,91.24 76.85,91.08 73.94,91.08 73.57,90.71 73.22,90.71 73.09,90.84 v5(73.09,91.08)
  BOTTOM w0.127: VRAM2.F8 72.7,90.68 v5(73.09,91.08)
MDA1: length 23
  TOP w0.127: GPU1.F18 77.77,104.26 78.18,104.67 v5(78.18,104.69) ; v5(72.29,91.08) 71.89,90.68 VRAM2.F7
  L3 w0.102: 77.79,103.51 77.79,104.3 v5(78.18,104.69)
  L3 w0.165: v5(72.29,91.08) 72.29,91.73 72.88,92.32 73.5,92.32 73.86,91.96 74.4,91.96 74.57,92.12 74.57,92.61 74.73,92.78 76.47,92.78 76.64,92.94 76.64,93.27 76.47,93.44 75.19,93.44 75.02,93.6 75.02,93.94 75.19,94.1 76.43,94.1 76.6,94.27 76.6,95.46 76.65,95.5 76.65,98.27 76.65,98.27 76.65,100.02 77.06,100.43 77.06,101.21 77.57,101.71 77.57,103.3 77.79,103.51
  BOTTOM w0.127: VRAM4.E3 v5(72.29,91.08)
MDA2: length 25.2
  TOP w0.127: VRAM2.H7 71.46,89.08 v5(71.35,89.18) ; v5(79.02,103.01) 79.03,103.01 GPU1.E16
  L3 w0.165: v5(71.35,89.18) 71.52,89.01 71.54,89.01 71.64,88.91 75.05,88.91 76.13,89.99 78.15,89.99 78.75,90.59 79.25,90.59 79.42,90.76 79.42,91.11 79.25,91.27 77.98,91.27 77.82,91.44 77.82,93.31 78.71,94.19 78.73,94.19 78.74,94.21 78.74,98.33 78.61,98.46 78.61,100.59 78.32,100.88 78.32,102.1 79.02,102.8 v5(79.02,103.01)
  BOTTOM w0.127: v5(71.35,89.18) 71.46,89.08 VRAM2.H7
MDA3: length 23.8
  TOP w0.127: v5(72.29,89.48) 72.55,89.48 72.69,89.34 VRAM2.H8 ; GPU1.F17 78.23,103.89 78.23,103.87 v5(78.19,103.83)
  L3 w0.102: 78.25,100.46 78.08,100.63 78.08,102.31 78.6,102.83 78.6,103.43 v5(78.19,103.83)
  L3 w0.165: 78.25,100.46 78.3,100.41 78.3,98.64 78.17,98.51 77.69,98.51 77.57,98.39 77.57,96.71 77.69,96.58 78.21,96.58 78.34,96.45 78.34,94.98 78.21,94.85 77.75,94.85 77.41,94.52 77.41,91.25 77.69,90.97 77.69,90.6 77.53,90.44 75.82,90.44 75.66,90.27 75.66,90.07 75.66,90 74.89,89.23 74.43,89.23 74.41,89.22 72.55,89.22 v5(72.29,89.48)
  BOTTOM w0.127: VRAM4.G2 v5(72.29,89.48)
