# Allegro board 14058-1.0623WZS1658.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
OSD_DN_IC: length 3.3
  TOP w0.102: R79790.1 37.2,51.31 37.2,50.8 v1(36.81,50.41) 36.81,50.36 37.01,50.15 SCA1.50
OSD_DN_R: length 14
  TOP w0.102: 26.56,21.12 27.45,20.23 36.26,20.23 36.57,19.93 36.92,19.93 PWRCN1.2 ; 26.56,21.12 v2(26.61,21.12) ; 26.56,21.12 v1(25.6,21.12) 25.08,21.12 R750.2
  BOTTOM w0.102: D5212.2 26.56,21.07 v2(26.61,21.12)
OSD_MENU: length 314.1
  TOP w0.102: R79792.2 35.11,53 v2(35.91,53) ; v2(22.8,23.74) 22.29,24.24 21.28,24.24 20.77,23.74 20.77,23.1 21.02,22.85 21.02,21.7 21.21,21.51 R753.1 21.72,21.51 22.61,22.4 C12238.1 R754.1 ; v2(103.45,48.63) 103.45,48.06 100.84,45.45 R80206.1 ; R79793.1 145.78,95.81 144.87,96.72 144.87,100.26 v2(145.79,101.18)
  L3 w0.127: v2(35.91,53) 32.27,53 29.61,50.33 29.61,49.84 23.95,44.17 23.95,24.88 v2(22.8,23.74) ; v2(186.51,86.85) 186.1,86.85 179.24,79.99 179.24,77.19 173.42,71.37 173.42,69.7 172.05,68.33 172.05,59.58 172.14,59.49 172.14,55.08 170.15,53.09 170.15,52.11 165.38,47.34 165.38,42.11 161.24,37.97 161.24,28.65 v2(160.77,28.18)
  L4 w0.127: v2(35.91,53) 36.75,52.16 37.86,52.16 39.69,50.33 45.3,50.33 46.5,51.52 62.02,51.52 65.13,48.42 98.68,48.42 99.33,49.07 101.24,49.07 101.69,48.63 v2(103.45,48.63) 103.95,48.63 110.69,41.89 110.69,40.49 117.1,34.07 124.09,34.07 126.95,31.21 132.83,31.21 133.92,30.12 137.98,30.12 137.98,30.12 138.4,30.12 139.18,30.91 150.26,30.91 152.1,29.07 152.31,29.07 159.89,29.07 v2(160.77,28.18)
  BOTTOM w0.102: v2(186.51,86.85) 185.95,87.41 182.14,87.41 178.38,91.18 178.38,92.06 170.4,100.04 157.1,100.04 154.53,102.6 151.88,102.6 v3(151.22,101.95) 146.47,101.95 145.81,101.29 145.81,101.21 v2(145.79,101.18)
OSD_MENU_IC: length 5.6
  TOP w0.102: SCA1.52 36.01,49.11 35.61,49.52 35.25,49.52 34.87,49.9 R79792.1 34.17,51.87 v1(33.72,52.31)
OSD_MENU_R: length 15
  TOP w0.102: PWRCN1.1 36.88,20.46 28.11,20.46 v2(27.37,21.2) 25.6,22.97 v1(25.6,23.02) 25.08,23.02 R754.2
  BOTTOM w0.102: D5213.2 27.44,21.13 v2(27.37,21.2)
OSD_MENU_SIO: length 17.6
  TOP w0.102: U109.109 110.18,50.66 109.82,51.01 108.93,51.01 108.4,51.55 108.4,52.22 108.4,52.22 108.4,52.6 108.4,52.6 108.4,53.2 108.15,53.45 106.75,53.45 106.5,53.2 106.5,52.43 106.3,52.23 106.29,52.23 105.86,51.8 105.86,50.86 104.97,49.97 104.97,48.25 103.57,46.85 v1(103.07,46.85) 102.69,46.85 101.61,45.77 R80206.2
OSD_UP: length 310.9
  TOP w0.102: v2(22.55,17.19) 21.92,17.19 R740.2 ; R740.2 21.98,17.77 23.25,17.77 C524.1 R742.1 ; R740.2 21.02,16.81 21.02,15.29 20.9,15.16 R743.1 ; R79791.2 36.05,52.25 36.7,52.89 v2(36.7,53) ; v2(145.92,100.42) 145.1,99.6 145.1,96.81 146.7,95.21 R79794.1
  L3 w0.127: v2(160.77,29.07) 160.77,37.86 164.15,41.24 164.15,43.5 165.13,44.48 165.13,47.45 169.9,52.21 169.9,53.2 171.89,55.19 171.89,59.38 171.8,59.47 171.8,68.43 173.17,69.81 173.17,71.47 178.99,77.29 178.99,80.1 182.82,83.93 182.82,84.7 v2(184.47,86.35) ; v2(22.55,17.19) 22.08,17.67 22.08,22.35 23.27,23.54 23.27,23.82 24.2,24.75 24.2,44.06 29.87,49.73 29.87,50.23 32.38,52.74 35.25,52.74 35.46,52.53 36.23,52.53 v2(36.7,53)
  L4 w0.127: v2(36.7,53) 37.28,52.41 37.97,52.41 39.8,50.58 45.16,50.58 46.35,51.78 62.13,51.78 65.12,48.79 67.03,48.79 67.72,49.48 72.83,49.48 72.91,49.4 74.75,49.4 75.48,48.67 98.51,48.67 99.17,49.33 103.61,49.33 110.94,41.99 110.94,40.6 117.21,34.33 124.19,34.33 127.05,31.46 132.94,31.46 134.02,30.38 138.08,30.38 138.08,30.38 138.29,30.38 139.08,31.16 150.37,31.16 152.21,29.32 160.52,29.32 v2(160.77,29.07)
  BOTTOM w0.102: v2(184.47,86.35) v3(182.95,86.35) 182.88,86.35 178.15,91.08 178.15,91.97 172.34,97.78 165.63,97.78 164.84,98.56 158.25,98.56 154.44,102.37 153.26,102.37 152.32,101.44 147.27,101.44 147.05,101.66 146.67,101.66 146.25,101.24 146.25,100.75 v2(145.92,100.42)
OSD_UP_IC: length 3.5
  TOP w0.102: SCA1.51 36.51,49.29 35.61,50.19 v1(35.5,50.19) 35.5,50.85 R79791.1
OSD_UP_R: length 14.2
  TOP w0.102: R742.2 24.8,18.46 v1(25.55,19.21) 26,19.67 v2(26.61,19.67) 29.03,19.67 29.33,19.98 35.96,19.98 36.06,19.87 36.07,19.87 36.34,19.61 36.34,19.59 36.52,19.42 PWRCN1.3
  BOTTOM w0.102: D5211.2 26.23,20.05 v2(26.61,19.67)
OZ554_ENA: length 8.4
  TOP w0.102: R79704.1 8.64,16.12 R79707.1 C12227.1 9.34,13.96 9.44,14.06 v2(9.44,14.82)
  BOTTOM w0.102: v2(9.44,14.82) 9.72,15.1 v3(10.37,15.1) 10.51,15.1 11.15,14.46 12.01,14.46 12.29,14.75 U120.3
OZ554_PWM: length 9.5
  BOTTOM w0.254: U120.5 13.48,17.69 12.92,18.25 v3(12.9,18.25) 12.83,18.31 C12228.1 12.81,19.29 11.39,19.29 11.05,18.94 11.05,18.46 10.8,18.21 R79702.1 10.8,16.56 10.23,15.99 R79694.1
OZ554_VIN: length 5.3
  TOP w0.508: v2(11.3,15.86) 11.23,15.8 10.41,15.8 R79706.2 10.04,15.91 C3457.1
  BOTTOM w0.305: v2(11.3,15.86) 11.3,15.43 v3(11.7,15.02) 11.81,15.02 12.03,15.25 U120.4
P1P2V:
  vias: v3(28.69,34.91)
P3P3V: length 176.2
  TOP w0.305: C11358.1 176.35,48.25 U9615.1
  TOP w0.508: C11358.1 C11359.1 177.68,48.31 v2(178.25,47.74)
  L3 w0.508: v2(41.17,51.93) 41.17,51.2 40.25,50.29 40.25,49.01 37.47,46.23 37.47,38.68 35.98,37.2 v2(35.88,37.2)
  L4 w0.508: v2(41.17,51.93) 43.63,51.93 44.56,52.86 64.63,52.86 66.9,50.58 73.25,50.58 73.35,50.48 77.44,50.48 77.47,50.46 78.78,50.46 78.8,50.48 79.96,50.48 80.39,50.05 98.36,50.05 98.72,50.41 104.06,50.41 110.53,43.93 111.11,43.93 113.62,41.42 113.62,40.9 115.92,38.59 125.68,38.59 130.09,34.18 139.29,34.18 144.19,39.07 146.4,39.07 149.17,36.31 150.95,36.31 152.98,34.28 160.09,34.28 164.22,38.4 168.92,38.4 v2(178.25,47.74)
  vias: v3(33.7,38.44)
PANEL_OFF: length 168.4
  TOP w0.102: U2.AN41 146.32,86.6 146.64,86.28 v2(146.64,86.22)
  L3 w0.127: v2(45.55,32) 45.55,37.04 50.37,41.86 53.11,41.86 54.81,43.56 54.81,43.91 57.57,46.68 62.88,46.68 64.01,45.54 79.31,45.54 80.05,45.54 81.42,46.91 82.56,46.91 87.37,51.73 90.83,51.73 91.45,52.35 92,52.35 92.02,52.36 92.73,52.36 92.74,52.35 97.91,52.35 99.48,53.92 99.48,56.45 103.45,60.42 103.45,61.46 107.51,65.52 108.04,65.52 110.31,67.78 110.31,68.12 117.72,75.54 120.36,75.54 124.65,79.83 130.07,79.83 132.14,81.9 133.1,81.9 135.13,83.93 135.31,83.93 135.96,84.58 135.96,86.52 136.81,87.36 136.81,87.68 137.86,88.73 137.86,89.59 141.82,93.55 143.3,93.55 144.34,92.51 146.07,92.51 v2(146.24,92.67)
  BOTTOM w0.102: v2(45.55,32) 44.71,32 44.2,31.49 v3(44.2,31.48) 44.2,30.95 43.19,29.93 40.73,29.93 39.24,31.43 37.22,31.43 36.26,30.47 34.99,30.47 34.71,30.19 Q9619.D 34.59,27.67 R79867.2 30.68,27.35 30.68,25.51 31.18,25.01 R80232.2 ; R79941.1 145.1,94.68 145.1,93.99 146.24,92.86 v2(146.24,92.67) 146.24,92.49 146.12,92.37 146.12,91.35 146.45,91.02 146.45,89.75 146.12,89.43 146.12,88.97 145.97,88.82 145.97,86.9 146.64,86.23 v2(146.64,86.22)
PANEL_OFF_C: length 11.6
  TOP w0.102: SCA1.113 35.01,28.84 v2(35.25,29.07)
  BOTTOM w0.102: v2(35.25,29.07) 36.14,28.18 R79868.2 35.38,26.72 35.38,26.02 v3(34.87,25.51) 34.36,25.51 33.09,26.78 Q9619.G 32.07,26.38 R80232.1
PANEL_ON: length 39.2
  TOP w0.102: v2(37.92,17.77) 38.41,17.77 R9544.2 ; v2(35.25,29.83) 35.12,29.83 34.51,29.22 SCA1.112
  L3 w0.127: v2(37.92,17.77) 36.65,17.77 35.31,19.1 35.31,28.37 35.72,28.78 35.72,29.36 v2(35.25,29.83)
  BOTTOM w0.102: v2(37.92,17.77) 38.6,18.45 43.01,18.45 45.13,16.32 45.71,16.32 46.3,16.91 49.57,16.91 v3(52.75,13.73) 54.81,11.67 R9542.1
PANEL_ON1: length 2.9
  BOTTOM w0.102: Q9503.2 57.6,11.92 v3(57.44,11.76) 57.35,11.67 R9542.2
PANEL_ON2: length 4.2
  BOTTOM w0.102: R9543.2 57.6,16.18 Q9503.5 ; R9543.2 58.25,16.16 Q9503.6 ; R9543.2 57.92,17.07 v3(58.36,17.51)
PANEL_ON3: length 2.9
  BOTTOM w0.102: R9556.2 55.12,13.52 55.19,13.46 v3(55.19,12.94) 55.95,12.94 56.28,13.27 Q9503.3
PANEL_ON_1: length 4.6
  BOTTOM w0.102: R79737.2 18.55,30.85 R42.1 18.36,30.66 18.36,29.89 R79376.2 19.63,29.64 R79734.1 19.69,28.88 v3(19.88,28.69)
PANEL_ON_2: length 4.2
  BOTTOM w0.102: v3(20.64,31.99) 20.14,32.5 19.31,32.5 R42.2 18.39,31.58 Q1263.B
PANEL_ON_3: length 19.8
  BOTTOM w0.102: U1.3 19.13,52.18 C12114.1 R79727.2 17.66,49.33 v3(17.6,49.26) 16.45,48.12 16.45,39.86 17.46,38.85 Q1261.D 21.21,38.85 R19.1
PANEL_ON_4: length 11
  BOTTOM w0.102: Q1263.C 15.12,32.63 R79738.2 15.06,32.94 R79728.1 16.52,33.83 17.06,33.29 Q1262.G 17.63,33.29 18.36,34.02 18.36,36.31 v3(17.98,36.69) 17.98,37.67 Q1261.G
PANEL_ON_5: length 26.9
  BOTTOM w0.102: R79735.1 15.94,58.28 v3(15.94,42.28) 15.94,39.86 17.32,38.49 18.59,38.49 19.75,37.32 19.75,34.72 Q1262.D
PANEL_SEL1_CABLE: length 116.9
  TOP w0.102: R79814.2 92.1,44.82 89.95,42.67 89.95,42.37 89.95,42.37 89.95,39.78 87.94,37.76 v2(87.87,37.76) ; R79817.1 50.28,47.09 50.28,45.14 50.51,44.92 v2(50.51,44.92) ; R79711.1 26.74,13.45 28.99,15.7 v2(30.01,15.7)
  L3 w0.127: v2(30.01,15.7) 30.26,15.7 30.93,16.37 38.37,16.37 39.83,14.91 44.16,14.91 45.95,16.71 45.95,18.43 46.82,19.29 46.82,22.41 45.95,23.28 45.59,23.28 43.34,25.53 43.34,28.22 43.63,28.51 43.63,39.75 47.98,44.1 49.69,44.1 v2(50.51,44.92)
  L4 w0.127: v2(87.87,37.76) 86.81,38.82 86.81,40.78 85.81,41.78 83.14,41.78 78.68,37.32 72.59,37.32 70.68,39.23 64.02,39.23 62.89,38.1 57.56,38.1 50.73,44.92 v2(50.51,44.92)
  BOTTOM w0.102: v3(30.85,15.71) 30.85,15.7 v2(30.01,15.7)
PANEL_SEL1_CABLE_C: length 14.3
  TOP w0.102: CONVT1.7B v2(29.58,3.42) ; CONVT1.7A v2(29.58,8.75) 29.58,8.8 30.45,9.66 v1(30.45,10.02) 29.91,10.56 28.71,10.56 28.17,11.1 R79715.2 R79711.2
  L3 w0.127: v2(29.58,3.42) v2(29.58,8.75)
PANEL_SEL1_CABLE_EC: length 16.5
  TOP w0.102: U109.102 107.38,48.36 106.3,47.28 106.01,47.28 104.94,46.21 104.55,46.21 104.21,45.87 104.21,45.46 v1(103.57,44.83) 103.28,44.54 93.92,44.54 93.73,44.73 R79814.1
PANEL_SEL1_CABLE_S: length 7.7
  TOP w0.102: R79817.2 48.37,48.11 v1(48,48.11) 47.72,47.84 R79799.2 R79802.1 46.68,47.1 46.22,46.64 46.22,45.77 44.94,44.48 44.94,44.46 SCA1.33
PANEL_SEL2_CABLE: length 118.6
  TOP w0.102: v2(50.62,44.17) 50.6,44.17 50.4,44.37 49.85,44.37 R79818.1 ; v2(87.92,37.01) 88.27,37.01 v1(88.72,37.45) 90.31,39.05 90.31,42.52 91.97,44.18 104.15,44.18 R79815.2 ; v2(30.42,14.46) 30.17,14.21 R79712.1
  L3 w0.127: v2(50.62,44.17) 50.17,43.72 48.14,43.72 44.01,39.59 44.01,28.35 43.72,28.06 43.72,25.69 45.75,23.66 46.1,23.66 47.2,22.56 47.2,19.13 46.33,18.27 46.33,16.55 44.31,14.53 39.67,14.53 38.21,15.99 31.34,15.99 30.42,15.07 v2(30.42,14.46)
  L4 w0.127: v2(50.62,44.17) 57.06,37.72 63.55,37.72 63.83,38 71.31,38 72.36,36.94 77.6,36.94 78.2,36.35 86.85,36.35 87.51,37.01 v2(87.92,37.01)
PANEL_SEL2_CABLE_C: length 14.6
  TOP w0.102: CONVT1.8A v2(30.58,8.75) 31.37,9.54 31.87,9.54 v1(32.35,10.02) 31.72,10.65 30.61,10.65 R79712.2 R79714.2 ; CONVT1.8B v2(30.58,3.42)
  L3 w0.127: v2(30.58,3.42) v2(30.58,8.75)
PANEL_SEL2_CABLE_EC: length 5.1
  TOP w0.102: U109.103 107.78,48.38 106.88,47.48 106.88,47.36 v1(106.24,46.72) 105.16,45.64 R79815.1
PANEL_SEL2_CABLE_S: length 6.8
  TOP w0.102: v1(49.59,45.65) 49.49,45.65 48.9,45.06 R79818.2 48.84,44.37 R79800.2 R79801.1 46.26,43.95 SCA1.32
PANEL_SEL3_CABLE: length 116.2
  TOP w0.102: v2(87.78,36.26) 88.46,35.57 v1(88.46,35.55) 90.67,37.75 90.67,42.37 92.12,43.83 103.23,43.83 R79816.2 ; v2(31.28,14.43) 31.31,14.43 R79713.1 ; v2(50.75,42.73) 50.73,42.71 50.41,42.71 49.83,43.29 R79819.1
  L3 w0.127: v2(50.75,42.73) 50.36,42.73 50.16,42.94 47.89,42.94 44.7,39.74 44.7,25.25 45.91,24.04 46.26,24.04 47.58,22.72 47.58,18.97 46.72,18.11 46.72,16.4 44.47,14.15 44.16,14.15 39.51,14.15 38.06,15.61 32.07,15.61 31.28,14.81 v2(31.28,14.43)
  L4 w0.127: v2(50.75,42.73) 51.5,42.73 56.9,37.34 63.71,37.34 63.99,37.62 71.15,37.62 72.21,36.56 77.44,36.56 78.04,35.97 87.48,35.97 v2(87.78,36.26)
PANEL_SEL3_CABLE_C: length 14.8
  TOP w0.102: CONVT1.9B v2(31.58,3.42) ; CONVT1.9A v2(31.58,8.62) 32.34,9.38 32.76,9.38 33.6,10.22 33.6,11.47 v1(33.47,11.59) 32.95,11.59 R1733.2 R79713.2
  L3 w0.127: v2(31.58,3.42) v2(31.58,8.62)
PANEL_SEL3_CABLE_EC: length 7.4
  TOP w0.102: R79816.1 104.63,43.67 v1(105.86,44.91) 105.86,44.91 105.86,45.33 107.13,46.6 107.13,47.36 108.18,48.4 U109.104
PANEL_SEL3_CABLE_S: length 8.7
  TOP w0.102: SCA1.31 44.94,43.46 45.18,43.22 45.18,42.2 v1(45.84,41.54) 46.49,41.54 47.14,42.19 47.14,42.9 R79797.1 46.68,43.37 46.86,43.55 47.63,43.55 R79798.2 48.84,43.36 R79819.2
PB_IN_N_1: length 24.3
  TOP w0.102: v2(110.14,53.02) 110.14,57.17 107.51,59.8 107.51,61.89 106.96,62.44 105.82,62.44 105.55,62.17 105.55,61.8 105.66,61.69 105.66,60.74 105.32,60.41 U109.72 102.78,60.41 v2(102.5,60.69) 101.47,60.69 100.58,59.8 R332.2 100.46,60.44 R333.2
  BOTTOM w0.102: R79873.2 110.14,53.61 v2(110.14,53.02) ; C199.1 103.51,59.23 v3(103.32,59.42) 102.5,60.24 v2(102.5,60.69)
PB_IN_N_1_C: length 6
  TOP w0.102: U109.111 110.98,49.98 110.53,50.42 110.53,51.17 110.93,51.57 v2(111.67,51.57)
  BOTTOM w0.102: v2(111.67,51.57) 111.68,51.57 111.68,52.16 v3(111.02,52.82) 111.02,53.59 R79873.1
PB_IN_SW1: length 16.1
  TOP w0.254: R746.1 R745.2 25.02,15.54 25.3,15.27 v1(25.78,15.27) 25.83,15.27 v2(27.5,16.94) 29.22,16.94 30.9,18.63 33.44,18.63 33.49,18.68 34.84,18.68 35.6,17.92 PWRCN1.6
  BOTTOM w0.254: v2(27.5,16.94) 27.56,16.88 D5210.2
PC_MONITOR_SW: length 240.3
  TOP w0.102: v2(178.89,44.51) 178.81,44.59 ; 178.81,44.59 U9615.5 ; 178.81,44.59 179.31,45.09 U9615.7 ; v2(26.74,25.77) 26.55,25.77 R9521.1 26.04,26.53 28.01,26.53 29.63,28.15 30.33,28.15 30.51,27.97 SCA1.104 ; v2(183.65,49.9) R79830.1
  L3 w0.127: v2(178.89,44.51) 181.73,47.36 181.91,47.36 183.65,49.09 v2(183.65,49.9)
  L4 w0.127: v2(26.74,25.77) 26.74,25.69 31.37,21.05 31.37,19.58 34.11,16.84 34.65,16.84 42.4,9.09 43.13,9.09 43.84,8.38 48.69,8.38 50.16,9.85 53.48,9.85 55.61,7.72 59.58,7.72 69.16,17.3 79.46,17.3 83.27,21.11 104.78,21.11 106.28,19.61 106.28,18.4 114.33,10.35 114.33,6.78 117.25,3.86 163.43,3.86 187.29,27.72 187.29,44.59 183.65,48.23 v2(183.65,49.9)
  BOTTOM w0.102: v3(25.85,25.77) v2(26.74,25.77)
PC_MONITOR_SW_G: length 9.3
  TOP w0.102: R79827.2 185.45,50.68 184.64,50.68 R79830.2 184.4,50.93 C12127.1 184.81,52.44 186.48,54.11 v1(186.48,54.29) 186.48,54.8 186.12,55.15 186.12,55.53 185.09,56.56 Q7.G
PCH_2_CPU_TRIGGER: length 230.8
  TOP w0.102: v2(59.5,167.85) CPU1.D1 ; v2(109.8,74.41) 109.8,74.8 111.77,76.77 114.03,76.77 118.13,72.67 118.13,68.8 120.14,66.79 124,66.79 125.75,65.04 125.75,63.05 130.16,58.64 131.3,58.64 131.44,58.51 141.01,58.51 142.66,60.16 142.66,60.68 R1811.2
  L4 w0.127: v2(75.81,71.21) 75.49,70.89 75.49,70.58 75.22,70.31 73.29,70.31 72.62,70.98 65.25,70.98 57.66,78.57 55.1,78.57 51.45,82.22 51.45,83.32 49.02,85.75 37.63,85.75 37.63,85.75 36.68,85.75 31.32,91.1 31.32,102.3 31.86,102.83 31.86,107.25 32.14,107.53 32.14,109.88 32.26,110.01 32.26,111.99 32.31,112.04 32.31,113.33 35.83,116.85 37.45,116.85 38.35,117.75 40.4,117.75 40.67,118.03 40.67,118.25 42.14,119.72 42.14,122.61 43.08,123.55 43.08,126.27 44.26,127.44 46.53,127.44 52.91,133.83 54.53,133.83 59.04,138.33 59.04,145.19 60.08,146.23 60.08,167.26 v2(59.5,167.85)
  BOTTOM w0.102: v2(109.8,74.41) 108.12,74.41 107.87,74.15 103.7,74.15 v3(103.45,74.41) 103.12,74.74 94.7,74.74 92.05,72.1 78.05,72.1 76.83,70.88 76.14,70.88 v2(75.81,71.21)
PCH_2_CPU_TRIGGER_R: length 6.8
  TOP w0.102: U2.AL2 145,67.37 144.98,67.35 144.81,67.18 144.81,64.56 144,63.74 144,62.98 143.75,62.73 v1(143.7,62.73) 143.68,62.71 143.39,62.71 142.82,62.14 R1811.1
PCH_AUD_RST_N: length 104.3
  TOP w0.102: v2(124.66,57.77) 124.16,57.77 123.96,57.97 123.14,57.97 R314.1 121.23,57.52 120.74,58.01 U109.19
  L3 w0.127: v2(125.09,35.22) 125.09,41.41 121.79,44.72 121.79,49.44 124.02,51.68 124.02,52.65 124,52.67 124,53.06 124.02,53.09 124.02,57.14 v2(124.66,57.77)
  L4 w0.127: v2(125.09,35.22) 128.09,32.23 133.06,32.23 133.27,32.23 134.35,31.14 135.26,31.14 137.43,33.31 137.52,33.31 152.09,33.31 152.73,32.68 163.47,32.68 164.42,31.72 177.86,31.72 178.63,30.95 182.76,30.95 185.62,33.8 185.62,39.54 v2(185.65,39.58)
  BOTTOM w0.102: R392.1 184.35,39.41 184.85,38.9 v3(185.21,38.9) 185.62,39.31 185.62,39.54 v2(185.65,39.58)
PCH_AUD_RST_N_1: length 3.9
  TOP w0.102: Q13.2 v2(184.35,41.72)
  BOTTOM w0.102: R392.2 184.08,40.69 v3(183.28,41.49) 183.28,41.52 183.53,41.77 184.3,41.77 v2(184.35,41.72)
PCH_BKLT_PWM_1: length 9.8
  TOP w0.165: v2(28.26,25.08) 28.14,25.21 26.09,25.21 R79174.1
  BOTTOM w0.165: Q9614.3 28.66,28.31 29.19,27.78 v3(29.19,25.08) v2(28.26,25.08) 27.68,25.08 27.36,25.4 Q9614.6
PCH_CHAR_CTL3: length 67.4
  TOP w0.102: U2.R41 136.72,86.96 135.94,86.96 135.78,87.12 135.78,89.08 134.16,90.69 v2(133.65,90.69) ; R454.2 v2(174.06,106.92)
  L3 w0.127: v2(133.65,90.69) 133.65,90.84 133.33,91.16 133.33,93.62 133.83,94.12 133.83,97.96 138.81,102.94 159.36,102.94 161.38,100.93 168.63,100.93 169.4,100.15 173.52,100.15 174.08,100.72 v2(174.08,101.83) 174.08,101.92 173.59,102.41 173.59,106.45 v2(174.06,106.92)
  BOTTOM w0.102: v2(174.08,101.83) 174.08,101.21 174.21,101.08 v3(174.69,101.08) 174.88,101.27 R456.2
PCH_CLK_TO_LPC: length 6.7
  TOP w0.102: U2.AV19 v5(148.47,76.59)
  BOTTOM w0.102: R1983.1 153.83,76.16 153,76.16 152.57,75.73 v3(150.97,75.73) 150.95,75.73 150.64,76.04 149.03,76.04 v5(148.47,76.59)
PCH_CPU_BCLK_DN: length 121.9
  TOP w0.102: U2.H2 133.64,67.42 133.64,66.81 133.47,66.65 133.47,65.26 133.2,65 v2(133.2,64.62)
  BOTTOM w0.102: v2(133.2,64.62) 133.05,64.77 132.89,64.77 132.58,64.46 131.81,64.46 130.21,66.06 128.69,66.06 125.82,68.93 125.82,73.57 125.99,73.73 125.99,76 122.75,79.23 122.75,83.9 126.49,87.64 126.49,87.64 126.94,88.1 126.94,92.01 125.85,93.1 125.85,117.25 109.37,133.73 88.78,133.73 81.81,140.7 81.81,142.38 ; R7.1 81.81,143.48 81.81,142.38 ; 81.81,142.38 v3(81.5,142.38)
PCH_CPU_BCLK_DP: length 121.8
  TOP w0.102: v2(132.75,65.23) 133.13,65.23 133.25,65.35 133.25,66.74 133.42,66.9 133.42,67.24 U2.G2
  BOTTOM w0.102: 122.97,80.05 v3(123.28,80.05) ; 122.97,80.05 122.97,79.32 124.49,77.8 124.65,77.8 124.86,77.59 124.86,77.43 125.08,77.21 125.24,77.21 125.45,77 125.45,76.84 125.67,76.62 125.83,76.62 126.04,76.41 126.04,76.25 126.21,76.09 126.21,73.65 126.04,73.48 126.04,69.02 127.05,68.01 127.21,68.01 127.43,67.79 127.43,67.64 128.78,66.28 130.29,66.28 131.9,64.68 132.49,64.68 132.75,64.93 v2(132.75,65.23) ; 122.97,80.05 122.97,80.84 123.08,80.95 123.08,81.26 122.97,81.37 122.97,81.67 123.08,81.79 123.08,82.09 122.97,82.2 122.97,82.51 123.08,82.62 123.08,82.92 122.97,83.04 122.97,83.81 126.7,87.55 126.7,87.55 127.16,88.01 127.16,92.1 126.07,93.19 126.07,117.34 109.46,133.95 88.87,133.95 82.03,140.78 82.03,143.48 R6.1
PCH_CPU_BCLK_R_DN: length 33
  TOP w0.102: v2(73.65,171.66) 73.24,171.25 CPU1.W4
  BOTTOM w0.102: v3(81.5,154.55) 81.81,154.55 ; 81.81,154.55 81.81,156.27 74.2,163.88 74.2,170 74.63,170.43 74.63,171.73 74.34,172.02 74.01,172.02 v2(73.65,171.66) ; 81.81,154.55 81.81,152.52 81.69,152.41 81.69,152.1 81.81,151.99 81.81,151.69 81.69,151.57 81.69,151.27 81.81,151.16 81.81,149.89 81.69,149.78 81.69,149.48 81.81,149.36 81.81,149.06 81.69,148.95 81.69,148.64 81.81,148.53 81.81,145.29 R7.2
PCH_CPU_BCLK_R_DP: length 32.9
  TOP w0.102: v2(73.63,172.59) 73.21,172.17 CPU1.W5
  BOTTOM w0.102: R6.2 82.02,145.3 82.02,150.76 ; 82.02,150.76 82.02,156.36 74.41,163.97 74.41,169.91 74.85,170.34 74.85,171.82 74.43,172.24 74.01,172.24 73.65,172.59 v2(73.63,172.59) ; 82.02,150.76 v3(82.31,150.76)
PCH_CPU_NSSC_CLK_DN: length 116.2
  TOP w0.102: v2(131.64,65.9) 132.23,66.49 132.32,66.49 132.6,66.78 U2.F1
  BOTTOM w0.102: 84.18,142.84 84.18,144.16 R15.1 ; 84.18,142.84 v3(83.86,142.84) ; 84.18,142.84 84.18,139.57 89.25,134.5 109.69,134.5 126.62,117.57 126.62,93.47 127.58,92.52 127.58,87.16 124.16,83.74 124.16,80 127.36,76.8 127.36,70.18 127.65,69.65 127.67,69.61 127.79,69.39 130.71,67.19 131.36,67.19 131.9,66.66 131.9,66.15 v2(131.64,65.9)
PCH_CPU_NSSC_CLK_DP: length 116.1
  TOP w0.102: U2.G1 132.4,66.27 v2(132.4,65.91)
  BOTTOM w0.102: v3(84.7,140.37) 84.4,140.37 ; 84.4,140.37 84.4,144.32 R13.1 ; 84.4,140.37 84.4,139.66 89.34,134.72 95.7,134.72 95.82,134.83 96.12,134.83 96.23,134.72 96.54,134.72 96.65,134.83 96.95,134.83 97.07,134.72 109.78,134.72 126.84,117.66 126.84,93.56 127.79,92.61 127.79,87.07 124.4,83.68 124.4,83.66 124.38,83.64 124.38,80.09 127.58,76.89 127.58,70.24 127.96,69.53 130.78,67.41 131.45,67.41 132.11,66.75 132.11,66.21 v2(132.4,65.91)
PCH_CPU_PCIBCLK_DN: length 117.7
  TOP w0.102: v2(89.8,136.19) 89.52,136.46 89.22,136.46 83.17,142.52 83.17,142.8 R11.1 ; v2(134.59,65.75) 134.84,65.75 134.96,65.86 134.96,66.14 134.86,66.23 134.56,66.53 134.35,66.75 134.35,66.91 U2.J1
  BOTTOM w0.102: v3(127.93,93.64) 128.22,93.64 ; 128.22,93.64 128.22,95.38 127.4,96.21 127.4,117.89 109.86,135.43 91.73,135.43 90.71,136.45 90.06,136.45 v2(89.8,136.19) ; 128.22,93.64 128.22,86.69 124.94,83.4 124.94,80.35 129.12,76.17 129.12,76.01 129.33,75.8 129.49,75.8 129.71,75.58 129.71,75.42 129.92,75.21 130.08,75.21 130.3,74.99 130.3,71.76 130.18,71.65 130.18,71.34 130.3,71.23 130.3,70.92 130.18,70.81 130.18,70.51 130.3,70.4 130.3,70.09 130.18,69.98 130.18,69.67 130.3,69.56 130.3,69.1 130.94,68.45 132.78,68.45 132.8,68.47 133.16,68.47 134.8,66.83 134.8,65.96 v2(134.59,65.75)
PCH_CPU_PCIBCLK_DP: length 118.9
  TOP w0.102: R9.1 83.38,142.89 83.38,142.61 89.31,136.68 89.47,136.68 v2(89.8,137) ; U2.J2 134.15,67.51 134.35,67.31 134.35,67.3 134.56,67.09 134.56,66.84 134.71,66.69 135.01,66.39 135.17,66.23 135.17,65.12 v2(135.17,65.12)
  BOTTOM w0.102: 130.51,74.26 v3(130.83,74.26) ; 130.51,74.26 130.51,69.19 131.03,68.67 132.69,68.67 132.71,68.69 133.25,68.69 135.02,66.92 135.02,65.27 v2(135.17,65.12) ; 130.51,74.26 130.51,75.08 125.15,80.44 125.15,83.31 128.44,86.6 128.44,95.47 127.62,96.29 127.62,117.98 109.95,135.65 91.82,135.65 90.8,136.66 90.13,136.66 v2(89.8,137)
PCH_CPU_PCIBCLK_R_DN: length 30.3
  TOP w0.102: v1(82.78,145.16) 83.21,145.16 ; 83.21,145.16 83.21,144.75 R11.2 ; 83.21,145.16 83.21,153.4 81.26,155.35 73.3,163.31 73.3,167.9 72.88,168.32 72.88,169.09 CPU1.W2
PCH_CPU_PCIBCLK_R_DP: length 29.1
  TOP w0.102: 83.43,145.97 83.43,144.57 R9.2 ; 83.43,145.97 83.43,153.49 73.52,163.4 73.52,167.99 73.21,168.3 CPU1.W1 ; 83.43,145.97 v1(83.83,145.97)
PCH_DPWROK: length 51.8
  TOP w0.102: v2(148.31,71.03) 148.31,71.04 148.46,71.18 U2.AV11 ; v2(154.76,59.27) 154.18,58.7 R79773.1 C12052.1 153.85,57.06 152.61,57.06 152.34,56.79 152.34,56.41 152.44,56.31 152.44,54.59 151.71,53.86 150.13,53.86 147.82,51.55 132.66,51.55 129.99,48.88 129.99,48.25 v1(129.36,47.61) R1984.1
  L3 w0.127: v2(148.31,71.03) 148.31,70.34 148.54,70.11 148.54,68.31 148.46,68.23 148.46,67.24 147.43,66.2 147.43,64.76 147.47,64.72 147.47,63.93 149.01,62.39 151.1,62.39 152.66,60.83 152.66,60.53 153.92,59.27 v2(154.76,59.27)
PCH_DVI_CLK: length 3.9
  TOP w0.102: Q9502.1 49.77,18.57 49.77,19.12 49.29,19.59 v1(48.2,19.59) 47.97,19.37 47.97,18.9 R9534.1
PCH_DVI_DATA: length 7
  TOP w0.102: Q9502.4 51.48,16.53 v1(51.48,14.95) 51.43,15 50.05,15 49.28,15.77 49.28,16.64 48.61,17.31 R9535.1
PCH_HOT#: length 23.7
  TOP w0.102: U2.AT27 147.71,79.45 147.57,79.3 v2(147.57,79.04)
  BOTTOM w0.102: R1839.1 147.45,97.64 R1840.1 146.89,96.07 146.68,96.07 v3(146.09,95.49) 146.09,94.4 147.39,93.1 147.39,91.16 147.14,90.9 147.14,89.52 146.73,89.11 146.73,88.32 147.24,87.81 147.24,86.81 147.48,86.57 147.48,85.14 146.95,84.61 146.72,84.61 146.02,83.9 146.02,83.87 145.46,83.32 145.46,80.61 145.3,80.45 145.3,80.1 145.55,79.84 146.54,79.84 147.34,79.04 v2(147.57,79.04)
PCH_INTRUDER_N: length 6
  TOP w0.102: U2.BE11 151.9,72.05 153.21,72.05 154.31,70.95 v2(154.88,70.95)
  BOTTOM w0.102: R1835.2 v3(156.2,70.93) 154.91,70.93 v2(154.88,70.95)
PCH_JTAG_TCK: length 184.6
  TOP w0.102: U2.AN3 146.09,67.7 146.22,67.57 146.22,66.98 145.83,66.59 145.83,66.05 146.77,65.11 146.77,64.49 147.55,63.7 147.55,63.23 147.49,63.17 147.49,60.64 146.97,60.12 146.31,60.12 145.76,59.57 145.14,59.57 R79768.1 143.81,58.25 143.37,58.25 142.89,57.77 131.17,57.77 131,57.93 130.16,57.93 129.86,57.93 125.45,62.34 125.04,62.76 125.04,64.74 123.7,66.08 119.84,66.08 117.42,68.5 117.42,68.52 117.42,71.22 117.28,71.35 112.37,76.26 111.77,76.26 111.19,75.69 v2(111.19,75.17) ; v2(43.79,118.19) 43.76,118.19 43.73,118.22 42.73,118.22 41.6,119.36 41.6,121.84 R1764.1
  L4 w0.127: v2(76.64,71.33) 76.64,72.09 75.84,72.88 66.04,72.88 58.45,80.48 56.99,80.48 49.18,88.29 36.83,88.29 34.61,90.51 34.61,95.14 33.23,96.52 33.23,101.51 33.76,102.04 33.76,106.46 34.04,106.74 34.04,109.1 34.73,109.78 34.73,113.05 36.19,114.51 38.42,114.51 38.48,114.45 39.8,114.45 43.53,118.18 43.77,118.18 v2(43.79,118.19)
  BOTTOM w0.102: v2(111.19,75.17) 107.51,75.17 v3(107,74.66) 106.55,75.12 94.57,75.12 91.91,72.45 77.75,72.45 v2(76.64,71.33)
PCH_JTAG_TDI: length 211.2
  TOP w0.102: R43.2 32.48,116.72 31.72,115.96 31.59,115.82 v2(31.59,115.21) ; v2(111.96,75.81) 112.5,75.81 117.19,71.12 117.19,68.62 117.19,68.41 119.75,65.85 123.61,65.85 124.81,64.65 124.81,62.66 125.36,62.11 129.77,57.7 130.25,57.7 130.91,57.7 131.4,57.21 131.4,54.84 132.21,54.03 140.91,54.03 142.44,55.55 142.44,56.77 143.01,57.34 143.39,57.34 143.39,57.33 144.53,57.33 145,57.81 145,58.9 145.39,59.3 145.81,59.3 146.41,59.89 147.07,59.89 147.72,60.54 147.72,62.65 147.78,62.71 147.78,63.98 146.97,64.79 146.97,65.33 146.26,66.04 v2(146.26,66.26) 146.26,66.3 146.43,66.46 146.43,67.18 146.66,67.41 U2.AP2
  L4 w0.127: v2(72.43,68.13) 71.66,67.37 71.66,62.4 69.8,60.53 37.59,60.53 25.76,72.36 25.76,82.59 30.12,86.95 30.12,102.81 30,102.92 30,105.9 30.38,106.28 30.38,114.33 31.26,115.21 v2(31.59,115.21)
  BOTTOM w0.102: v2(146.26,66.26) 146.17,66.26 146.06,66.37 R1841.1 ; v2(72.43,68.13) 73.03,68.13 74.23,69.33 76.1,69.33 78.29,71.51 92.3,71.51 94.94,74.15 102,74.15 102.63,73.52 107,73.52 v3(107.64,72.88) 108.43,73.67 110.72,73.67 111.07,74.02 111.07,74.28 111.96,75.17 v2(111.96,75.81)
PCH_JTAG_TDO: length 208.1
  TOP w0.102: U2.AP1 146.85,66.84 146.85,65.74 147.26,65.32 147.26,64.79 148.01,64.04 148.01,62.62 147.95,62.56 147.95,60.45 147.16,59.66 146.5,59.66 R132.1 145.38,58.55 145.38,58.43 145.23,58.28 145.23,57.71 144.42,56.91 143.33,56.91 143.3,56.88 v2(143.2,56.88) ; R40.2 38.41,143.33 39.34,142.4 v2(40.47,142.4)
  L3 w0.127: v2(40.47,142.4) 40.47,141.82 44.64,137.65 52.39,137.65 54.32,135.73 55.81,135.73 56.56,136.47 63.19,136.47 64.19,137.47 80.48,137.47 83.11,134.84 91.29,134.84 93.45,137.01 109.93,137.01 123.42,123.51 123.42,119.55 122.08,118.2 v2(121.84,118.2)
  L4 w0.127: v2(143.2,56.88) 142.94,57.14 142.57,57.14 140.72,58.99 131.59,58.99 130.8,59.78 128.24,59.78 127.12,60.9 127.12,61.34 121.38,67.08 119.43,67.08 118.86,67.65 117.45,69.06 117.45,69.38 117.45,69.38 117.45,69.87 117.46,69.87 117.46,70.62 117.45,70.62 117.45,71.43 117.46,71.43 117.46,72.72 116.3,73.88 116.3,80.39 117.02,81.11 117.02,83.55 119.4,85.93 122.68,85.93 125.4,88.65 125.4,95.61 125.29,95.73 125.29,101.58 125.51,101.79 125.51,117.53 125.23,117.8 124.84,117.8 124.41,117.37 122.66,117.37 v2(121.84,118.2)
  BOTTOM w0.102: v3(39.62,142.73) 40.13,142.73 v2(40.47,142.4)
PCH_JTAG_TMS: length 222.5
  TOP w0.102: v2(127.96,49.91) 127.96,51.2 130.54,53.78 142.52,53.78 144.73,55.99 146.77,55.99 147.13,56.35 148.04,56.35 149.37,57.68 149.37,58.39 R1842.1 148.91,59.52 149.07,59.68 149.07,61.2 148.47,61.8 148.47,64.15 147.67,64.96 147.67,65.49 147.25,65.91 147.25,67.33 147.27,67.35 U2.AR2 ; v2(62.15,145.7) 61.53,145.08 R44.2
  L4 w0.127: v2(62.15,145.7) 62.03,145.59 62.03,138.87 62.03,138.87 62.03,138.58 56.74,133.29 56.74,132.01 54.81,130.08 54.31,130.08 46.68,122.45 46.68,119.88 44.14,117.34 43.77,117.34 40.12,113.69 38.79,113.69 36.1,111 36.1,110.07 34.8,108.78 34.8,106.42 34.52,106.14 34.52,101.73 33.99,101.19 33.99,97.97 35.88,96.07 35.88,90.86 36.63,90.11 48.98,90.11 57.47,81.62 58.92,81.62 66.51,74.03 76.32,74.03 78.87,71.47 78.87,66.63 78.9,66.6 78.9,64.52 81.52,61.9 83.03,61.9 84.39,60.54 89.14,60.54 89.42,60.82 96.08,60.82 96.21,60.95 98.49,60.95 100.66,58.77 102.84,58.77 105.62,56 108.91,56 112.14,52.77 112.14,51.12 112.01,50.99 112.01,50.51 112.42,50.1 113.35,50.1 113.35,50.1 114,49.45 118.37,49.45 119.09,50.17 127.7,50.17 v2(127.96,49.91)
  BOTTOM w0.102: v3(127.96,49.01) v2(127.96,49.91)
PCH_JTAGX: length 12
  TOP w0.102: U2.AR3 147.27,67.86 147.04,67.63 147.04,67.31 147.05,67.3 147.05,65.82 147.46,65.41 147.46,64.87 148.21,64.12 148.21,63.73 148.24,63.71 148.24,62.52 148.18,62.46 148.18,61.76 148.51,61.43 v2(148.51,60.87) 148.51,60.46 147.77,59.73 R79779.1 R131.1
  BOTTOM w0.102: v2(148.51,60.87) 148.46,60.87 v3(147.9,60.31)
PCH_OSD_DN: length 7.7
  TOP w0.102: R79795.2 147.91,93.42 v1(148.42,92.91) 148.43,92.9 148.43,90.63 146.6,88.81 146.6,88.1 146.24,87.74 U2.AN43
PCH_OSD_MENU: length 7.5
  TOP w0.102: R79793.2 145.78,93.83 v1(147.2,92.41) 147.22,92.38 147.22,91.18 145.87,89.82 145.87,88.25 U2.AM44
PCH_OSD_UP: length 7.1
  TOP w0.102: R79794.2 146.84,93.59 147.75,92.67 147.75,90.96 v1(147.72,90.93) 147.72,90.62 146.22,89.11 U2.AN44
PCH_PCIECLKRQ1_N_1: length 19
  TOP w0.102: R709.2 117.05,243.2 v2(117.04,243.19) ; Q57.S 124.61,251.72 R731.2 v1(122.04,251.7) 116.82,251.7 v2(116.57,251.45)
  L4 w0.127: v2(116.57,251.45) 116.57,243.66 v2(117.04,243.19)
PCH_PECI: length 185.4
  TOP w0.102: v2(55.7,137.53) v1(55.7,140.09) 55.7,142.23 57.35,143.88 59.25,143.88 59.76,144.39 R41.2 ; v2(130.24,59.2) 130.45,59 131.45,59 131.58,58.86 138.63,58.86 140.33,60.57 140.33,61.24 C11892.1 R79772.1 141.78,62.33 142.25,62.8 142.98,62.8 143.64,63.47 143.64,63.68 144.61,64.64 144.61,67.48 145,67.86 U2.AL3
  L3 w0.127: v2(125.04,117.33) 125.04,123.34 110.15,138.23 81.51,138.23 81.25,138.49 63.77,138.49 63.05,137.77 55.94,137.77 v2(55.7,137.53)
  L4 w0.127: v2(125.04,117.33) 125.13,117.25 125.13,101.95 124.91,101.74 124.91,95.57 125.02,95.46 125.02,88.81 122.52,86.31 119.24,86.31 116.64,83.71 116.64,81.27 115.79,80.42 115.79,73.85 117.07,72.56 117.07,71.59 117.07,70.03 117.07,69.53 117.07,69.53 117.07,68.9 118.48,67.49 119.28,66.7 121.22,66.7 126.74,61.18 126.74,60.74 128.28,59.2 v2(130.24,59.2)
PCH_PWROK: length 394.7
  TOP w0.102: v2(149.27,71.24) 149.22,71.29 U2.AW11 ; v2(148.1,65.13) 148.1,64.88 148.82,64.16 148.82,61.95 149.42,61.35 149.42,59.3 149.73,58.99 149.73,57.53 148.19,55.99 147.27,55.99 146.39,55.1 DB1.1 ; R1980.2 20.77,253.61 18.87,251.7 v2(18.1,251.7)
  L3 w0.127: v2(164.41,93) 167.92,93 170.28,95.36 174.73,95.36 177.89,98.52 177.89,102.14 178.03,102.27 178.03,108.39 178.06,108.41 178.06,113.46 177.35,114.17 177.35,130.23 175.24,132.34 175.24,157.88 176.43,159.07 176.43,216.36 163.44,229.36 152.3,229.36 141.29,240.37 141.29,244.56 140.57,245.28 140.57,245.61 135.24,250.94 126.93,250.94 122.62,255.25 122.62,262.37 120.12,264.87 61.64,264.87 59.51,262.73 59.51,259.19 56.71,256.4 40.58,256.4 39.73,257.25 21.78,257.25 18.1,253.57 v2(18.1,251.7)
  L4 w0.127: v2(149.27,71.24) 149.77,71.74 150.01,71.74 152.87,74.6 155.11,74.6 162.06,81.54 162.06,82.65 163.09,83.69 163.09,86.2 162.97,86.32 162.97,86.33 162.36,86.94 162.36,90.63 164.41,92.67 v2(164.41,93)
  BOTTOM w0.102: v2(148.1,65.13) 148.1,65.64 147.67,66.07 147.67,66.43 148.27,67.03 148.27,68.31 148.3,68.33 148.3,70.27 v2(149.27,71.24) ; v2(164.41,93) 163.57,93 v3(161.81,94.76) 160.81,95.76 156.93,95.76 156.53,95.36 R79943.2
PCH_RTCRST_DOWN: length 9
  TOP w0.102: BTRST1.1 142.32,126.61 145.61,126.61 v2(146.37,125.84) 147.2,125.84 R141.1
  BOTTOM w0.102: v2(146.37,125.84) 147.49,126.96 v3(147.61,126.96)
PCH_RTCRST_PULLUP: length 124.3
  TOP w0.089: U2.BC10 151.13,71.51 151.28,71.66 153.03,71.66 153.07,71.61
  TOP w0.102: BTRST1.2 141.94,123.68 145.23,123.68 145.93,122.99 C12149.1 R138.2 147.27,121.83 151.97,121.83 R140.1 152.28,121.52 152.97,121.52 153.55,122.1 153.55,125.91 154.35,126.71 156,126.71 157.34,128.05 172.98,128.05 177.99,123.05 v1(178.63,123.05) 179.27,122.41 v2(179.27,122.03) ; v2(154.45,69.62) 154.45,70.24 153.07,71.61
  L3 w0.127: v2(179.27,122.03) 181.05,120.25 181.05,112.64 182.12,111.57 182.12,106.79 181.83,106.5 181.83,104.23 181.83,103.91 182.4,103.34 182.4,96.91 180.62,95.12 180.62,95.11 179.2,95.11 174.06,89.96 174.06,87.34 168.78,82.05 168.78,79.78 164.42,75.42 163.39,75.42 161.61,73.65 161.61,71.04 159.21,68.64 156.74,68.64 156.44,68.35 155.39,68.35 154.5,69.23 154.5,69.57 v2(154.45,69.62)
PCH_RTCX1: length 19.5
  TOP w0.102: U2.BC9 150.92,70.93 151.18,71.19 151.67,71.19 151.74,71.26 152.85,71.26 153.69,70.42 153.69,69.48 154.19,68.99 154.71,68.99 155.13,69.4 159.17,69.4 159.21,69.41 160.77,69.41 160.81,69.4 161.19,69.4 161.84,68.74 v1(162.22,68.74) 162.82,69.34 164.27,69.34 R180.1 164.72,68.88 C160.1 165.68,68.97 X2.1
PCH_RTCX2: length 11.8
  TOP w0.102: U2.BD10 151.54,71.47 152.93,71.47 153.89,70.51 153.89,69.57 154.27,69.19 154.63,69.19 155.45,70.01 v1(156.85,70.01) 159.11,70.01 159.15,70.02 161.37,70.02 R179.2
PCH_SATA_LED_1: length 6.8
  TOP w0.254: R741.2 52.39,5.14 v1(52.24,4.99) 51.5,4.99 50.53,5.97 Q62.C 47.1,5.97 Q61.B
PCH_SATA_LED_2: length 24.2
  TOP w0.305: v1(35.63,11.9) 35.3,12.23 35.3,13.09 35.63,13.42 35.63,16.62 35.93,16.92 PWRCN1.8
  TOP w0.508: v1(35.63,11.9) 37.2,13.47 v2(37.2,13.58)
  TOP w0.762: v2(46.22,11.59) 46.11,11.48 Q63.C 46.11,8.61 45.09,7.59 Q61.C
  L3 w0.762: v2(46.22,11.59) 45.79,11.16 39.62,11.16 v2(37.2,13.58)
PCH_SATA_LED_N: length 362.5
  TOP w0.254: Q9646.4 40.82,7.72 v2(40.3,8.24) ; v2(143.01,95.74) 143.02,95.73 R191.2 ; v2(49.22,10.4) R79771.2 R744.1
  L3 w0.254: v2(143.01,95.74) 143.57,96.3 150.43,96.3 151,95.74 151,94.54 153.1,92.43 153.1,91.71 153.77,91.05 153.98,91.05 155.78,89.24 160.06,89.24 162.5,91.68 167.37,91.68 170.58,94.89 v2(172.15,94.89) ; 40.33,8.24 v2(40.3,8.24) ; 40.33,8.24 42,6.56 45.38,6.56 v2(49.22,10.4) ; 40.33,8.24 40.33,9.25 37.27,12.31 30.42,12.31 25.34,17.38 25.34,42.52 32.35,49.53 32.35,50.56 32.71,50.91 37.2,50.91 37.61,51.32 v2(37.97,51.32) ; v2(162.5,17.89) 163.04,17.36 163.61,17.36 165.65,19.4 165.65,26.16 165.17,26.64 165.17,39.51 169.51,43.85 169.51,48.09 171.57,50.15 174.81,50.15 177.23,52.57 177.23,53.58 175.25,55.56 175.25,59.4 174.06,60.6 174.06,61.71 174.69,62.34 174.69,68.57 176.22,70.09 176.22,72.24 180.6,76.62 180.6,77.65 181.55,78.6 181.55,79.23 183.46,81.14 183.46,81.5 186.66,84.7 v2(187.65,84.7)
  L4 w0.254: v2(162.5,17.89) 160.09,17.89 159.49,17.3 152.15,17.3 149.99,19.46 145.78,19.46 144.69,20.56 139.78,20.56 135,25.34 126.64,25.34 125.28,26.69 122.84,26.69 121.8,27.74 117.54,27.74 112.86,32.42 112.86,35.32 108.57,39.61 108.57,40.25 107.21,41.61 107.21,42.37 103.31,46.26 76.15,46.26 76.12,46.3 64.9,46.3 64.87,46.26 64.28,46.26 61.14,49.4 50.14,49.4 49.33,48.59 47.93,48.59 46.52,47.18 43.25,47.18 42.02,48.41 41.04,48.41 38.13,51.32 v2(37.97,51.32)
  BOTTOM w0.254: v2(172.15,94.89) 172.75,94.89 174.06,93.59 174.82,93.59 175.96,92.44 175.96,87.24 v3(177.62,85.58) 178.5,84.7 v2(187.65,84.7)
PCH_SATA_LED_R: length 3
  TOP w0.254: v1(52.18,9.9) 52.14,9.86 52.11,9.86 51.61,9.36 R744.2 51.06,8.58 50.71,8.23 Q62.B
PCH_SATA_LED_R_N: length 6.6
  TOP w0.152: 141.99,89.92 141.83,89.76 141.83,88.4 U2.AD44
  TOP w0.254: 141.99,89.92 141.99,90.35 142.39,90.74 v1(142.39,90.84) 142.16,91.07 142.16,93.15 142.98,93.97 142.98,94.05 R191.1
PCH_SIO_DPWROK: length 13.8
  TOP w0.102: U109.14 120.44,56.01 120.57,55.88 121.78,55.88 122.43,55.23 R1946.2 123.14,54.77 123.96,54.77 126.13,52.6 126.13,51.47 127.15,50.46 127.15,49.57 127.39,49.33 v1(127.39,49.05) 127.4,49.05 127.4,47.61 R1984.2
PCH_SLP_A_N: length 6.4
  TOP w0.102: U2.BC15 150.99,73.83 151.28,74.12 152.02,74.12 152.13,74.23 154.22,74.23 154.37,74.08 154.7,74.08 155.2,73.58 TP67.1 155.81,73.54 R1786.1
PCH_SLP_S0_N: length 10.5
  TOP w0.102: U2.BC26 151,79.51 151.38,79.13 152.02,79.13 152.04,79.11 154.34,79.11 154.59,79.35 156.27,79.35 156.46,79.54 157.37,79.54 157.87,80.05 159.33,80.05 160.42,81.14 TP69.1
PCH_SMI_N: length 15.6
  TOP w0.102: R199.2 R1923.2 130.94,99.72 131.94,98.72 132.35,98.72 v1(132.48,98.59) 132.48,98.26 133.8,96.94 133.8,95.1 132.99,94.29 132.99,90.74 133.22,90.51 133.47,90.26 133.85,90.26 134.48,89.63 135.34,88.77 135.36,88.77 U2.M45
PCH_SRCCLKREQ0: length 8.4
  TOP w0.102: R156.1 157.19,78.31 v1(157.16,78.35) ; U2.BC24 151.12,78.46 154.33,78.46 154.38,78.42 154.39,78.42 154.46,78.35 v1(157.16,78.35) ; v1(157.16,78.35) 157.23,78.42 R163.2
PCH_SRCCLKREQ0_N: length 80.5
  TOP w0.102: v2(167.19,81.79) 163.89,81.79 163.47,81.37 163.45,81.37 162.31,80.22 161.1,80.22 160.92,80.05 160.62,80.05 159.91,79.34 159.91,79.22 R163.1
  L4 w0.127: v2(176.6,136.26) 176.22,135.88 176.22,127.84 176,127.63 176,124.47 175.39,123.86 175.39,112.95 176.22,112.13 176.22,100.33 172.62,96.74 172.62,95.68 172.35,95.4 172,95.4 171.68,95.09 171.68,90.65 171.29,90.26 171.29,86.93 167.66,83.3 167.66,82.26 v2(167.19,81.79)
  BOTTOM w0.102: v2(176.6,136.26) 177.21,135.65 v3(178.48,135.65) 182.52,135.65 182.9,136.03 185.14,136.03 186.51,137.39 R458.2
PCH_SRCCLKREQ1: length 23.3
  TOP w0.102: v1(163.01,87.24) 163.01,86.6 163.33,86.28 R164.2 R157.1 162.36,85.53 v2(161.48,85.53) ; U2.AW24 149.24,78.23 v5(148.85,77.85)
  L3 w0.127: v5(148.85,77.85) 148.92,77.85 149.55,78.47 150.94,78.47 152.51,80.04 152.51,81.03 154.43,82.96 154.8,82.96 158.65,86.82 160.05,86.82 161.33,85.53 v2(161.48,85.53)
PCH_SRCCLKREQ1_N: length 208.8
  TOP w0.102: Q57.D 128.76,254.08 v1(130.11,252.72) 131.77,251.07 137.86,251.07 140.6,248.33 v2(140.66,248.33) ; v2(165.17,88.51) 164.56,87.9 164.56,86.18 R164.1
  L4 w0.127: v2(140.66,248.33) 140.66,248.02 144.49,244.18 144.49,231.84 147.94,228.4 164.7,228.4 175.67,217.42 175.67,136.41 175.46,136.19 175.46,128.16 175.24,127.94 175.24,124.79 174.63,124.18 174.63,112.64 175.46,111.81 175.46,100.65 170.76,95.95 170.76,94.06 165.2,88.51 v2(165.17,88.51)
PCH_SRCCLKREQ2: length 18
  TOP w0.102: U2.AT24 147.38,78.52 146.92,78.98 146.66,78.98 v5(146.45,79.18)
  BOTTOM w0.102: R166.2 144.62,91.98 R158.1 145.2,91.4 145.25,91.4 145.69,90.96 v3(145.69,90.23) 145.69,89.11 145.53,88.96 145.53,88.21 145.43,88.11 145.43,87.55 145.03,87.14 145.03,85.57 144.77,85.32 144.46,85.32 144.21,85.06 144.21,84.68 145.22,83.66 145.22,82.09 145.26,82.05 145.26,80.7 145.1,80.54 145.1,80.01 145.47,79.64 145.84,79.64 146.3,79.18 v5(146.45,79.18)
PCH_SRCCLKREQ2_N: length 114.4
  TOP w0.102: v2(65.73,40.12) 65.73,39.12 67.36,37.49 69.33,37.49 69.56,37.26 R425.2
  L3 w0.127: v2(65.73,40.12) 65.73,40.15 66.46,40.88 67.21,40.88 69.18,42.86 69.18,43.01 69.89,43.71 79.73,43.71 81.86,45.85 83,45.85 87.81,50.66 97.77,50.66 100.61,53.5 100.61,55.94 105.23,60.55 106.56,60.55 108.13,62.12 108.13,64.63 113.84,70.34 114.4,70.34 114.88,70.82 114.88,71.72 118.01,74.85 120.64,74.85 123.92,78.14 130.76,78.14 132.32,79.69 133.58,79.69 134.76,80.87 135.71,80.87 136.5,81.66 136.5,82.89 138.25,84.64 138.25,87.38 139.27,88.41 139.27,90.03 141.18,91.93 141.5,91.93 v2(141.62,92.06)
  BOTTOM w0.102: v2(141.62,92.06) 141.62,92.62 v3(141.93,92.92) 142.63,92.23 143.36,92.23 143.73,92.6 R166.1
PCH_SRCCLKREQ3: length 14.8
  TOP w0.102: U2.BD25 151.41,78.9 151.64,78.67 154.42,78.67 154.46,78.62 156.45,78.62 156.73,78.9 159.08,78.9 160.5,80.33 160.81,80.33 160.98,80.5 162.16,80.5 162.65,80.99 162.65,81.34 v1(163.15,81.84) 163.15,82.4 163.58,82.83 R160.1
PCH_SRCCLKREQ4: length 16.2
  TOP w0.102: R161.1 163.24,80.76 162.43,79.95 161.31,79.95 v1(160.47,79.11) 159.72,78.36 159.72,77.76 158.87,76.91 156.72,76.91 156.45,77.18 155.8,77.18 155.19,77.79 153.16,77.79 152.74,77.37 151.98,77.37 151.69,77.67 151.68,77.67 151.58,77.78 151.58,77.84 151.43,77.99 150.95,77.99 150.58,78.36 U2.BB24
PCH_SRCCLKREQ5: length 10.8
  TOP w0.102: U2.BE25 151.88,78.9 156.33,78.9 156.61,79.18 157.51,79.18 157.82,79.49 v1(158.41,79.49) 158.51,79.59 159.37,79.59 160.39,80.61 160.69,80.61 161.03,80.95 R162.1
PCH_SRCCLKREQ6: length 16.8
  TOP w0.102: U2.AT33 147.51,82.83 147.15,82.48 v2(147.15,82.37)
  L3 w0.127: v2(147.15,82.37) 147.15,82.29 149.12,80.32 149.12,80.08 149.47,79.73 150.47,79.73 151.29,80.55 151.29,81.56 152.8,83.07 153.36,83.07 v2(156.11,85.83)
  BOTTOM w0.102: v2(156.11,85.83) 155.68,85.83 155.39,86.12 v3(155.39,86.27) 155.59,86.47 R165.1
PCH_SRCCLKREQ7: length 22.1
  TOP w0.102: v2(145.58,84.05) 145.61,84.03 145.61,81.77 145.99,81.39 146.37,81.39 146.85,81.87 U2.AR31
  BOTTOM w0.102: 144.68,98.32 144.96,98.32 145.28,98 145.28,96.66 145.53,96.4 145.53,95.24 145.74,95.03 145.74,94.25 147.04,92.95 147.04,91.3 146.93,91.19 146.93,89.64 146.53,89.24 146.53,87.98 146.38,87.82 146.38,87.39 147.28,86.49 147.28,85.22 146.87,84.81 146.63,84.81 145.93,84.11 145.64,84.11 v2(145.58,84.05) ; 144.68,98.32 144.62,98.26 R168.1 ; 144.68,98.32 v3(144.75,98.39)
PCH_SRCCLKREQ8: length 11
  TOP w0.102: R169.1 160.39,84.39 160.35,84.39 160.16,84.2 159.4,84.2 158.98,84.62 156.27,84.62 155.81,84.16 v1(155.81,83.95) 155.7,83.95 154.97,83.22 154.39,83.22 153.27,82.1 151.8,82.1 151.69,82.22 151.67,82.22 151.59,82.3 U2.BD32
PCH_SRCCLKREQ9: length 15.1
  TOP w0.102: U2.BC32 150.92,82.3 151.21,82.01 151.6,82.01 151.72,81.9 153.39,81.9 154.44,82.94 155.6,82.94 156.99,84.34 158.83,84.34 159.25,83.92 160.75,83.92 161.11,84.27 161.11,85.05 160.66,85.5 R170.1 161.28,86.42 v1(161.94,86.42)
PCH_SRCCLKREQ10: length 10.6
  TOP w0.102: v2(150.25,82.42) 150.46,82.21 U2.BB31
  BOTTOM w0.102: R172.1 156.34,86.85 155.26,86.85 154.83,86.43 154.83,84.97 v3(154.79,84.93) 153.92,84.06 153.69,84.06 153.52,84.06 152.35,82.89 152.35,82.78 151.89,82.31 150.36,82.31 v2(150.25,82.42)
PCH_SRCCLKREQ11: length 13.9
  TOP w0.102: 160.66,86.92 160.69,86.92 161.74,87.97 161.84,87.97 v1(161.99,88.12) ; 160.66,86.92 R173.1 ; 160.66,86.92 160.09,87.49 159.32,87.49 158.51,86.68 155.84,86.68 154.69,85.53 153.76,84.6 153.76,84.38 153.76,84.37 153.76,84.2 153.03,83.47 152.97,83.47 152.96,83.47 152.39,83.47 152.06,83.15 151.48,83.15 151.21,82.88 U2.BC33
PCH_SRCCLKREQ12: length 12.1
  TOP w0.102: v2(149.47,82.43) 149.47,82.51 149.85,82.88 U2.BA33
  BOTTOM w0.102: v2(149.47,82.43) 149.65,82.43 150.07,82.85 150.43,82.85 150.77,82.51 151.8,82.51 152.15,82.86 152.15,83.28 152.95,84.09 152.98,84.09 154.55,85.66 154.55,86.68 v3(155.64,87.77) 156.63,88.76 R174.1
PCH_SRCCLKREQ13: length 13.2
  TOP w0.102: U2.AW33 149.08,83 148.81,83.28 v2(148.81,83.37)
  BOTTOM w0.102: R175.1 156.46,89.9 v3(155.8,89.25) 155.62,89.25 154.42,88.05 154.42,87.48 154.35,87.4 154.35,85.74 152.89,84.29 152.7,84.29 152.69,84.29 152.14,84.29 151.69,83.83 150.68,83.83 149.92,83.08 149.11,83.08 v2(148.81,83.37)
PCH_SRCCLKREQ14: length 7.8
  TOP w0.102: R176.1 156.1,85.14 155.71,84.75 155.29,84.75 154.49,83.94 v1(154.49,83.92) 154.46,83.92 153.6,83.06 152.55,83.06 152.23,82.74 151.83,82.74 151.65,82.55 150.93,82.55 150.58,82.9 U2.BB33
PCH_SRCCLKREQ15: length 7.5
  TOP w0.102: U2.BD33 151.59,82.78 151.75,82.94 152.15,82.94 152.47,83.27 153.11,83.27 153.96,84.12 153.96,84.33 154.94,85.31 155.43,85.31 v1(155.43,85.31) 155.43,85.8 155.92,86.3 156.93,86.3 R177.1
PCH_SRTCRSTB_PULLUP: length 114.4
  TOP w0.102: U2.BB10 150.31,71.54 v2(150.03,71.26) ; v2(179.39,120.89) 178.38,120.89 v1(176.98,122.29) 176.79,122.48 176.79,123.74 172.84,127.69 157.49,127.69 156.15,126.35 154.5,126.35 153.9,125.75 153.9,122.24 153.9,121.95 153.12,121.17 152.43,121.17 R140.2 151.77,120.83 151.26,121.33 R147.1 C12150.1 R146.2
  L3 w0.127: v2(150.03,71.26) 153.35,71.26 154.53,70.09 155.27,70.09 155.89,69.47 159.5,69.47 161.23,71.2 161.23,74.03 163.01,75.81 163.01,76.5 164.14,77.62 166.08,77.62 168.39,79.94 168.39,82.23 173.68,87.51 173.68,90.12 179.05,95.49 180.44,95.49 182.02,97.07 182.02,103.18 181.44,103.77 181.44,106.64 181.74,106.95 181.74,111.41 180.67,112.48 180.67,112.8 180.67,120 179.77,120.89 v2(179.39,120.89)
PCH_SYSPWROK: length 386.6
  TOP w0.102: U2.AY1 149.61,67.03 149.9,66.74 149.97,66.74 150.25,66.46 150.31,66.46 v2(150.43,66.34) 150.62,66.34 151.22,65.74 151.22,64.8 150.72,64.3 150.72,63.59 150.74,63.57 150.74,62.85 151.75,61.85 C156.1 152,61.45 152.01,61.45 152.71,60.76 R154.1 152.96,59.8 152.96,59.04 152.72,58.8 152.61,58.8 152.51,58.7 152.51,57.96 151.63,57.09 151.63,56.37 151.2,55.94 DB2.1 ; v2(141.17,237.48) 141.85,238.16 146.2,238.16 152.6,231.76 v2(154.88,231.76)
  L3 w0.127: v2(141.17,237.48) 141.17,238.34 137.83,241.68 137.83,247.58 134.91,250.49 126.84,250.49 122.21,255.12 122.21,262.25 119.96,264.49 61.8,264.49 59.97,262.66 59.97,259.12 56.83,255.98 53.17,255.98 49.91,252.72 44.9,252.72 41.85,249.67 25.74,249.67 22.8,252.61 v2(22.8,253.35) ; v2(154.88,231.76) 164.98,231.76 179.26,217.47 179.26,157.17 178.19,156.1 178.19,132.13 180.28,130.03 180.28,121.65 181.43,120.51 181.43,112.8 182.5,111.72 182.5,106.63 182.21,106.34 182.21,104.07 182.78,103.5 182.78,96.75 181,94.97 181,93.93 180.4,93.33 177.97,93.33 174.44,89.81 174.44,87.18 169.16,81.9 169.16,77.63 166.52,74.99 163.5,74.99 161.99,73.49 161.99,70.89 159.36,68.25 157.31,68.25 156.48,67.42 151.51,67.42 v2(150.43,66.34)
  BOTTOM w0.102: R79765.2 23.08,254.37 v3(23.03,254.32) 23.03,254.29 22.8,254.06 v2(22.8,253.35)
PCH_THERMTRIP_N: length 221.1
  TOP w0.102: R1804.2 152.15,53.79 152.8,54.44 v2(152.8,56.6) ; PR1.2 36.19,140.88 v1(36.57,140.5) 37.91,140.5 R38.1 38.36,139.62 v2(37.79,139.05)
  L3 w0.127: v2(121.48,119.01) 122.35,119.01 123.04,119.7 123.04,123.35 109.77,136.63 93.61,136.63 91.45,134.46 82.76,134.46 80.13,137.09 64.35,137.09 63.35,136.09 56.72,136.09 55.97,135.34 54.16,135.34 52.23,137.27 44.39,137.27 42.53,139.14 37.87,139.14 v2(37.79,139.05)
  L4 w0.127: v2(152.8,56.6) 152.76,56.64 148.07,56.64 148.02,56.59 145.65,56.59 145,57.24 143.51,57.24 143.39,57.35 143.27,57.35 143.1,57.52 142.73,57.52 140.88,59.37 131.75,59.37 130.96,60.16 128.4,60.16 127.5,61.06 127.5,61.5 121.54,67.46 119.59,67.46 119.24,67.81 117.84,69.22 117.84,69.71 117.84,72.88 117.32,73.39 117.32,79.09 v2(117.09,79.32) 117.32,79.56 117.32,80.87 117.4,80.95 117.4,83.39 119.56,85.55 122.83,85.55 125.78,88.5 125.78,95.77 125.67,95.88 125.67,101.42 125.89,101.64 125.89,117.69 125.39,118.18 124.68,118.18 124.25,117.75 123.01,117.75 121.75,119.01 v2(121.48,119.01)
  BOTTOM w0.102: R79980.1 108.79,80.19 109.16,80.55 110.69,80.55 111.47,79.77 111.6,79.77 112.16,79.21 116.98,79.21 v2(117.09,79.32)
PCH_THERMTRIP_R_N: length 21.7
  TOP w0.102: R1804.1 151.26,53.14 v2(151.2,53.2) ; v2(144.54,68.04) 144.42,67.92 U2.AJ3
  L3 w0.127: v2(144.54,68.04) 144.65,67.94 144.65,67.91 145.36,67.19 145.36,65.29 145.32,65.25 145.32,60.53 145.58,60.27 146.36,60.27 147.25,59.38 147.25,56.77 149.29,54.73 149.29,53.91 150.27,52.93 150.81,52.93 151.08,53.2 v2(151.2,53.2)
  BOTTOM w0.102: v3(144.9,67.31) 144.54,67.68 v2(144.54,68.04)
PCH_WAKE_N: length 12.9
  TOP w0.089: U2.BC13 151.03,72.69 151.26,72.91 151.61,72.91 151.69,72.83
  TOP w0.102: R115.1 162.18,74.22 161.68,73.71 R79780.1 160.26,73.19 160.03,72.96 158.76,72.96 158.31,72.51 156.66,72.51 156.44,72.29 v1(155.64,72.29) 155.17,72.29 154.7,72.76 153.08,72.76 152.98,72.66 152.24,72.66 152.06,72.83 151.69,72.83
PCH_XDP_PRDY_R_N: length 187.1
  TOP w0.152: U2.AT4 147.63,68.45 v2(147.87,68.68)
  TOP w0.305: R1774.1 46.53,134.35 48.46,134.35 v2(48.84,133.97)
  L3 w0.305: v2(122.55,119.87) 122.45,119.98 122.45,123.11 109.52,136.03 93.86,136.03 91.69,133.87 82.47,133.87 79.84,136.49 64.6,136.49 63.6,135.5 56.97,135.5 56.22,134.75 51.41,134.75 v2(51.26,134.61)
  L4 w0.305: v2(129.63,61.38) 129.63,61.07 129.32,60.76 128.65,60.76 128.1,61.31 128.1,61.75 121.79,68.06 119.84,68.06 118.43,69.46 118.43,73.13 117.92,73.64 117.92,80.63 118,80.71 118,83.14 119.72,84.87 123,84.87 126.38,88.25 126.38,96.02 126.27,96.13 126.27,101.17 126.57,101.48 126.57,117.85 125.64,118.78 124.44,118.78 124.01,118.35 123.31,118.35 122.55,119.11 v2(122.55,119.87)
  BOTTOM w0.305: v2(147.87,68.68) 147.87,67.06 147.36,66.55 147.36,65.15 144.48,62.27 138.77,62.27 138.48,61.98 135.3,61.98 134.79,61.48 129.74,61.48 v2(129.63,61.38) ; v2(48.84,133.97) v3(49.98,133.97) 50.49,133.97 51.12,134.61 v2(51.26,134.61)
PCH_XDP_PREQ_R_N: length 237.3
  TOP w0.102: U2.AT3 147.53,67.87 147.53,67.33 147.46,67.25 147.46,65.99 147.84,65.61 148.23,65.61 148.54,65.31 148.54,64.88 149.04,64.38
  TOP w0.305: 149.04,64.38 149.41,64.01 149.41,63.09 v1(149.4,63.08) 149.45,63.03 149.45,62.15 150.01,61.59 150.01,59.54 150.31,59.24 150.31,57.17 149.01,55.88 149.01,55.07 147.14,53.2 130.78,53.2 128.79,51.2 128.79,49.84 v2(128.72,49.77) ; R1773.1 46.25,135.09 48.74,135.09 v2(48.96,135.32)
  L4 w0.305: v2(48.96,135.32) 47.91,134.26 47.91,132.96 46.71,131.76 46.24,131.76 45.09,130.62 43.9,130.62 40.58,127.3 40.58,124.93 39.8,124.14 39.17,124.14 37.57,125.74 34.47,125.74 34.05,125.33 34.05,122.98 33.31,122.24 33.31,119.17 29.03,114.89 29.03,106.85 28.64,106.47 28.64,102.36 28.76,102.24 28.76,87.51 24.4,83.15 24.4,71.79 37.08,59.12 53.38,59.12 54.1,58.39 61.2,58.39 62.15,59.35 81.58,59.35 82.2,58.72 86.44,58.72 87.01,58.15 92.47,58.15 93.21,57.42 102.28,57.42 105.3,54.39 107.14,54.39 107.91,53.62 108.44,53.62 110.22,51.84 110.22,50.81 111.91,49.12 112.81,49.12 113.46,48.47 127.42,48.47 v2(128.72,49.77)
PCIE_RCOMPN: length 5.1
  TOP w0.127: U2.B18 129.28,75.19
  TOP w0.305: 129.28,75.19 128.12,75.19 v1(128.11,75.2) 128.01,75.09 126.01,75.09 R181.1
PCIE_RCOMPP: length 6
  TOP w0.127: U2.C17 131.06,75.09 130.76,74.79 129.86,74.79
  TOP w0.305: 129.86,74.79 129.48,74.41 v1(126.92,74.41) 126.56,74.41 126.01,73.86 R181.2
PCIE_RST#: length 318.7
  TOP w0.102: NGFF1.66 134.33,245 135.67,246.34 138.04,246.34 138.3,246.59 138.6,246.59 139.06,247.05 140.1,247.05 v2(140.91,246.24) ; v2(139.52,241.5) 138.76,241.5 138.37,241.11 135.16,241.11 135.02,240.97 134.56,240.97 134.03,241.5 NGFF1.52
  L3 w0.127: v2(140.91,246.24) 141.2,245.95 146.31,245.95 148.82,243.44 148.82,243.38 158.03,234.17 165.62,234.17 184.13,215.66 184.13,194.72 183.88,194.46 183.88,191.46 185.74,189.6 185.74,159.95 200.84,144.85 200.84,138.42 191.31,128.89 190.03,128.89 185.15,124.01 185.15,121.97 185.7,121.41 185.7,91.55 184.57,90.41 181.82,90.41 180.8,89.39 178.16,89.39 177.62,88.85 177.62,85.32 175.33,83.03 175.33,82.1 172.9,79.67 172.9,78.63 172.9,77.89 172.21,77.2 172.21,76.55 167.73,72.07 166.08,72.07 165.04,71.03 165.04,59.95 v2(165.68,59.31)
  L4 w0.127: v2(139.52,241.5) 141.8,243.79 141.8,245.86 141.42,246.24 v2(140.91,246.24)
  BOTTOM w0.102: RN2.1 116.42,54.87 116.66,55.1 116.66,55.9 116.92,56.17 117.32,56.17 119.12,54.37 120.19,54.37 122.32,52.23 v3(123.89,52.23) 125.85,52.23 126.59,52.97 148.29,52.97 149.78,54.46 149.78,55.44 151.42,57.09 162.53,57.09 163.28,57.84 164.51,57.84 165.68,59.01 v2(165.68,59.31)
