# Allegro board 14058-1.0623WZS1658.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMI_LANE1_DP: length 14.9
  TOP w0.102: TR17.3 162.59,37.56 162.36,37.32 162.36,35.78 160.64,34.07 160.29,33.71 157.22,33.71 ; 157.22,33.71 155.5,33.71 155.37,33.58 U28.4 U28.7 153.3,33.58 153.17,33.71 152.91,33.71 152.71,33.91 152.5,33.91 152.4,33.81 152.4,33.62 152.3,33.52 HDMI1.4 ; 157.22,33.71 v1(157.22,33.34)
HDMI_LANE1_IC_DN: length 5.1
  TOP w0.102: v1(161.79,40.25) 162.14,40.25 ; 162.14,40.25 162.14,40.88 161.21,41.81 161.21,42.61 161.12,42.7 U118.26 ; 162.14,40.25 162.14,39.36 161.91,39.12 TR17.1
HDMI_LANE1_IC_DP: length 5.1
  TOP w0.102: TR17.4 162.59,39.1 162.36,39.33 162.36,40.97 162.18,41.14 ; 162.18,41.14 161.43,41.9 161.43,42.61 161.52,42.7 U118.27 ; 162.18,41.14 v1(162.43,41.39)
HDMI_LANE2_DN: length 11.5
  TOP w0.102: 159.05,35.96 159.45,35.96 159.73,36.24 159.73,37.32 159.49,37.56 TR18.2 ; 159.05,35.96 158.11,35.96 158,36.07 157.7,36.07 157.59,35.96 157.28,35.96 157.17,36.07 156.86,36.07 156.75,35.96 156.45,35.96 156.34,36.07 156.03,36.07 155.92,35.96 155.5,35.96 155.37,36.09 U26.7 U26.4 153.57,36.09 153.43,35.96 153.09,35.96 152.76,35.63 152.5,35.63 152.4,35.73 152.4,35.92 152.3,36.02 HDMI1.9 ; 159.05,35.96 v1(159.05,36.36)
HDMI_LANE2_DP: length 11.5
  TOP w0.102: 157.8,35.74 159.54,35.74 159.94,36.15 159.94,37.32 160.18,37.56 TR18.3 ; 157.8,35.74 v1(157.8,35.39) ; 157.8,35.74 155.5,35.74 155.37,35.61 U26.6 U26.5 153.57,35.61 153.44,35.74 153.18,35.74 152.85,35.41 152.5,35.41 152.4,35.31 152.4,35.12 152.3,35.02 HDMI1.7
HDMI_LANE2_IC_DN: length 5
  TOP w0.102: U118.24 160.32,42.7 160.41,42.61 160.41,42.07 159.73,41.38 159.73,40.25 ; v1(159.38,40.25) 159.73,40.25 ; 159.73,40.25 159.73,39.36 159.49,39.12 TR18.1
HDMI_LANE2_IC_DP: length 5
  TOP w0.102: U118.25 160.72,42.7 160.63,42.61 160.63,41.98 160.43,41.78 ; 160.43,41.78 159.94,41.29 159.94,39.36 160.18,39.12 TR18.4 ; 160.43,41.78 v1(160.7,41.52)
HDMI_LANE3_DN: length 9.9
  TOP w0.102: HDMI1.12 152.3,37.52 152.4,37.42 152.4,37.23 152.5,37.13 152.61,37.13 152.96,37.48 153.17,37.48 153.3,37.61 U26.1 U26.10 155.37,37.61 155.5,37.48 155.86,37.48 156.23,37.11 ; 156.23,37.11 v1(156.47,37.35) ; 156.23,37.11 156.52,36.81 157.29,36.81 157.51,37.04 157.51,37.49 157.8,37.78 157.8,38.28 157.34,38.75 TR19.2
HDMI_LANE3_DP: length 10.1
  TOP w0.102: v1(158.41,37.81) 158.02,37.81 ; 158.02,37.81 TR19.3 ; 158.02,37.81 158.02,37.69 157.73,37.4 157.73,36.95 157.38,36.6 156.43,36.6 155.77,37.27 155.5,37.27 155.37,37.13 U26.9 U26.2 153.3,37.13 153.17,37.27 153.05,37.27 152.7,36.91 152.5,36.91 152.4,36.81 152.4,36.62 152.3,36.52 HDMI1.10
HDMI_LANE3_IC_DN: length 4.7
  TOP w0.102: TR19.1 157.34,40.46 157.7,40.83 157.7,41.57 ; v1(157.35,41.57) 157.7,41.57 ; 157.7,41.57 157.7,41.65 158.02,41.97 159.02,41.97 159.21,42.16 159.21,42.61 159.12,42.7 U118.21
HDMI_LANE3_IC_DP: length 4.6
  TOP w0.102: 158.77,41.76 158.11,41.76 157.91,41.56 157.91,40.57 158.02,40.46 TR19.4 ; 158.77,41.76 159.11,41.76 159.43,42.07 159.43,42.61 159.52,42.7 U118.22 ; 158.77,41.76 v1(158.77,41.41)
HDMI_SCL_IN: length 15.3
  TOP w0.102: HDMI2.15 152.5,16.02 153.67,17.19 153.67,18.09 152.22,19.54 v2(152.22,21.7) 153.3,22.79 153.3,24.94 152.79,25.45 U5203.1 152.3,25.13 R5210.1
  BOTTOM w0.102: v3(153.03,21.7) v2(152.22,21.7)
HDMI_SDA_IN: length 12.3
  TOP w0.102: HDMI2.16 152.49,16.52 153.22,17.24 v2(153.22,17.88) 151.76,19.34 151.76,22.01 152.61,22.86 U5203.2 152.04,24.12 R5211.1
  BOTTOM w0.102: v3(154.04,17.87) 153.23,17.87 v2(153.22,17.88)
HM_VCCP: length 3.3
  TOP w0.508: G1.2 91.71,53.43 90.81,52.53 R260.1 90.81,52.27 90.45,51.91 90.45,51.18 v1(90.65,50.99)
HM_VCCP_R: length 19
  TOP w0.203: 102.62,50.85 102.98,51.21 U109.95
  TOP w0.508: 102.62,50.85 101.16,49.39 100.58,49.39 99.81,48.63 98.88,48.63 98.74,48.49 96.02,48.49 95.88,48.63 v1(92.65,48.63) 91.43,49.85 91.43,51.8 91.7,52.07 R260.2 93.86,52.31 C184.1
HP_MUTE: length 188.4
  TOP w0.102: v2(184.53,27.67) 184.53,27.73 185.43,28.62 R79920.1 ; SCA1.64 30.01,50.12 30.3,50.41 30.35,50.41 30.5,50.55 30.5,51.22 30.3,51.42 30.3,51.48 R79950.2 29.54,51.74 v2(29.19,51.38)
  L4 w0.127: v2(47.06,48.61) 47.07,48.61 47.39,48.93 49.19,48.93 50,49.74 61.29,49.74 64.39,46.64 76.26,46.64 76.3,46.61 103.45,46.61 107.55,42.51 107.55,41.75 108.91,40.39 108.91,39.75 113.48,35.18 113.48,32.28 117.68,28.08 121.94,28.08 122.98,27.04 125.57,27.04 126.93,25.68 135.15,25.68 138.54,22.29 141.22,22.29 141.67,21.83 149.55,21.83 152.98,18.4 157.8,18.4 157.89,18.49 164.17,18.49 167.4,15.26 172.46,15.26 184.53,27.33 v2(184.53,27.67)
  BOTTOM w0.102: v2(47.06,48.61) 47.06,48.79 44.43,51.42 39.01,51.42 38.42,52.01 35.84,52.01 v3(34.85,51.02) 34.85,49.77 34.47,49.39 33.34,49.39 31.35,51.38 v2(29.19,51.38)
HP_MUTE_D: length 3.1
  TOP w0.102: R79919.2 178.89,27.14 v1(179.24,26.78) 180.36,27.9 Q9620.3
HP_MUTE_L: length 2.7
  TOP w0.102: Q9620.4 183.41,28.16 v1(183.69,27.89) 183.74,27.89 R79920.2
HPOL_CON: length 19.7
  TOP w0.203: v2(183.01,76.19) Q16.1 183.01,73.96 184.16,72.82 R406.2 184.35,71.78 R414.2 R410.2 ; v2(187.39,79.11) 188.09,78.41 C267.1 R412.1 189.49,78.6 191.71,78.6 192.02,78.29 UHS1.1
  L3 w0.203: v2(183.01,76.19) 183.01,77.14 184.98,79.11 v2(187.39,79.11)
  BOTTOM w0.203: v3(188.21,79.11) v2(187.39,79.11)
HPOR_CON: length 24.3
  TOP w0.203: Q16.2 183.58,76.6 183.58,76.06 v1(184.47,75.17) 184.47,74.39 184.85,74.01 184.85,73.46 R415.2 185.68,72.63 R409.2 186.91,72.34 186.91,72.27 187.55,71.63 R411.2 187.95,71.66 188.14,71.66 188.66,71.14 189.4,71.14 R413.1 C268.1 190.82,72.12 192.22,73.52 194,73.52 195.78,71.74 200.05,71.74 UHS1.2
HPOUT-JD: length 16.5
  TOP w0.203: R366.1 186.19,62.25 186.17,62.27 v1(186.17,62.37) 186.17,62.42 186.68,62.93 186.68,65.78 185.58,66.88 185.58,68 185.89,68.31 186.67,68.31 188.07,69.71 192.42,69.71 UHS1.6
HPOUT-L: length 21.7
  TOP w0.203: R406.1 183.77,74.28 v2(183.58,74.28) ; v2(182.57,56.37) 182.57,56.73 182.06,57.24 U9.26
  L3 w0.203: v2(182.57,56.37) 182.57,69.2 183.58,70.22 v2(183.58,74.28)
  BOTTOM w0.203: v2(182.57,56.37) v3(182.57,55.56)
HPOUT-R: length 24.1
  TOP w0.203: v2(183.46,56.37) 182.19,57.64 U9.27 ; R409.1 187.89,72.63 v2(188.87,71.65)
  L4 w0.203: v2(188.87,71.65) 188.54,71.65 185.18,68.29 185.18,66.92 184.09,65.82 184.09,62.41 185.54,60.96 185.54,58.81 185.41,58.68 185.41,58.14 183.65,56.37 v2(183.46,56.37)
  BOTTOM w0.203: v3(188.05,71.65) v2(188.87,71.65)
HSI_C_DN6: length 4.5
  BOTTOM w0.102: 187.5,143.14 187.04,143.14 186.51,143.67 185.38,143.67 C325.1 ; 187.5,143.14 U14.8 ; 187.5,143.14 v3(187.5,143.45)
HSI_C_DP6: length 4.6
  BOTTOM w0.102: 186,143.45 186.42,143.45 186.95,142.93 188.26,142.93 188.44,142.74 U14.7 ; 186,143.45 v3(186,143.12) ; 186,143.45 185.38,143.45 C324.1
HSI_DN6: length 135.8
  TOP w0.102: U2.G22 133.2,76.86 133.2,76.58 v2(133.2,76.58)
  L4 w0.127: v2(133.2,76.58) 132.89,76.26 132.89,75.4 133.56,74.72 133.76,74.72 134.03,74.45 134.03,74.26 134.3,73.99 134.49,73.99 134.76,73.72 134.76,73.53 135.59,72.69 136.32,72.69 136.99,72.03 136.99,70.48 137.11,70.36 137.72,70.36 138.23,69.85 138.95,69.85 139.49,69.31 139.49,68.26 140.19,67.56 142.2,67.56 142.48,67.84 143.55,67.84 144.07,67.31 144.61,67.31 145.23,66.69 145.23,66.51 145.95,65.79 146.24,65.79 146.24,65.79 146.74,65.79 148.51,64.02 153.68,64.02 154.49,64.83 154.49,67.03 155.66,68.2 160.13,68.2 163.15,71.21 163.15,72.86 163.87,73.58 167.87,73.58 170.46,76.18 170.46,82.87 175.49,87.9 175.49,93.9 181.21,99.61 181.21,101.42 178.48,104.15 178.48,111.7 175.82,114.35 175.82,123.68 177.68,125.54 177.68,140.05 177.54,140.19 177.54,140.57 177.68,140.71 177.68,141.09 177.54,141.23 177.54,141.61 177.68,141.75 177.68,142.16 179.55,144.03 181.37,144.03 181.71,143.69 182.87,143.69 v2(183.18,143.99)
  BOTTOM w0.102: C325.2 183.84,143.69 183.49,143.69 v2(183.18,143.99) v3(183,144.59)
HSI_DN8: length 174.7
  TOP w0.102: 113.63,235.39 115.96,237.72 117.19,237.72 117.59,238.12 R714.2 ; 113.63,235.39 112.76,234.52 112.76,148.03 128.85,131.94 128.85,129.81 v2(128.44,129.4) ; 113.63,235.39 v1(113.38,235.65) ; v2(134.56,77.84) 134.41,78 U2.K24
  L4 w0.127: v2(134.56,77.84) 134.89,78.17 134.89,78.91 133.1,80.7 133.1,85.01 133.53,85.44 133.53,87.23 133.71,87.41 133.71,87.84 132.53,89.02 132.53,89.78 131.16,91.15 131.16,119.91 128.73,122.34 128.73,129.11 v2(128.44,129.4)
HSI_DP6: length 135.7
  TOP w0.102: U2.E22 132.43,76.88 v2(132.43,76.64)
  L4 w0.127: v2(183.18,143.13) 182.88,143.42 181.6,143.42 181.26,143.76 179.66,143.76 177.95,142.05 177.95,125.43 176.09,123.57 176.09,114.46 178.75,111.81 178.75,104.26 181.48,101.53 181.48,99.5 175.76,93.79 175.76,87.79 170.73,82.76 170.73,76.07 167.98,73.32 163.98,73.32 163.42,72.75 163.42,71.1 160.24,67.93 155.77,67.93 154.76,66.92 154.76,64.72 153.79,63.75 148.4,63.75 146.63,65.52 146.13,65.52 146.12,65.52 145.84,65.52 144.96,66.4 144.96,66.58 144.5,67.04 143.96,67.04 143.43,67.57 142.59,67.57 142.31,67.3 140.08,67.3 139.22,68.15 139.22,69.2 138.84,69.58 138.12,69.58 137.61,70.09 137,70.09 136.72,70.37 136.72,71.92 136.21,72.42 135.48,72.42 132.62,75.29 132.62,76.45 v2(132.43,76.64)
  BOTTOM w0.102: C324.2 183.8,143.47 183.52,143.47 v2(183.18,143.13) v3(183.03,142.53)
HSI_DP8: length 174.7
  TOP w0.102: 115.14,236.6 112.97,234.43 112.97,148.12 129.06,132.03 129.06,129.84 129.36,129.55 v2(129.36,129.35) ; 115.14,236.6 116.05,237.51 117.39,237.51 117.49,237.4 117.49,237.21 117.59,237.11 R717.2 ; 115.14,236.6 v1(115.41,236.33) ; U2.L24 135.17,77.94 v2(135.32,77.79)
  L4 w0.127: v2(129.36,129.35) 129,128.99 129,125.56 129.14,125.42 129.14,125.04 129,124.91 129,124.53 129.14,124.39 129.14,124.01 129,123.87 129,122.45 131.43,120.02 131.43,91.26 132.8,89.89 132.8,89.13 133.98,87.95 133.98,87.3 133.8,87.12 133.8,85.33 133.37,84.9 133.37,80.81 135.16,79.02 135.16,77.95 v2(135.32,77.79)
HSI_LAN_DN1_R: length 4
  TOP w0.102: 63.25,30.76 62.85,30.35 62.85,30.34 62.66,30.15 U9623.18 ; 63.25,30.76 63.97,31.48 63.97,32.12 63.58,32.52 C12119.1 ; 63.25,30.76 v1(63.01,31)
HSI_LAN_DN5: length 96.2
  TOP w0.102: U2.K19 134.41,75.81 v2(134.88,75.34) ; v2(63.65,34.44) 63.94,34.15 63.94,33.84 C12119.2
  L3 w0.127: v2(63.65,34.44) 63.9,34.7 63.9,35.04 64.32,35.46 71.95,35.46 72.99,36.5 77.73,36.5 83.68,42.44 84.56,42.44 89.46,47.34 99.46,47.34 111.79,59.67 114.87,59.67 117.14,61.93 117.14,63.68 118.98,65.53 128.51,65.53 130.27,67.3 132.91,67.3 133.01,67.4 133.09,67.47 133.09,67.47 133.72,68.11 133.72,69.89 133.99,70.16 133.99,70.92 133.79,71.12 133.79,73.5 135.07,74.79 135.07,75.15 v2(134.88,75.34)
  BOTTOM w0.102: v2(63.65,34.44) 63.63,34.43 v3(63.63,33.83)
HSI_LAN_DP1_R: length 3.9
  TOP w0.102: 64.19,31.48 64.19,31.39 63.06,30.26 U9623.17 ; 64.19,31.48 64.19,32.22 64.49,32.52 C12118.1 ; 64.19,31.48 v1(64.6,31.48)
HSI_LAN_DP5: length 96.3
  TOP w0.102: C12118.2 64.52,33.44 64.15,33.81 64.15,34.12 v2(64.48,34.44) ; U2.L19 135.17,75.92 v2(135.68,75.41)
  L3 w0.127: v2(64.48,34.44) 64.17,34.75 64.17,34.93 64.43,35.19 72.06,35.19 73.1,36.23 77.84,36.23 83.79,42.18 84.67,42.18 89.57,47.08 99.57,47.08 111.9,59.4 114.98,59.4 117.4,61.82 117.4,63.57 119.09,65.26 128.62,65.26 130.38,67.03 133.02,67.03 133.15,67.16 133.2,67.21 133.99,67.99 133.99,69.78 134.26,70.05 134.26,71.03 134.05,71.23 134.05,73.39 135.68,75.02 v2(135.68,75.41)
  BOTTOM w0.102: v3(64.48,35.05) 64.48,34.45 v2(64.48,34.44)
HSO_C_DN6: length 154.9
  TOP w0.102: C161.1 121.03,76.82 120,76.82 v2(119.75,76.57)
  L4 w0.127: v2(119.75,76.57) 119.96,76.78 126.86,76.78 130.08,73.56 130.08,68.86 131.68,67.26 133.78,67.26 135.66,65.38 137.22,65.38 138.08,66.24 139.07,66.24 139.13,66.19 142.45,66.19 143.03,65.61 146.58,62.05 161.04,62.05 165.31,66.32 165.31,70.82 166.11,71.61 168.69,71.61 172.51,75.44 172.51,76.14 172.51,77.94 172.86,78.29 172.86,82.49 177.46,87.09 177.46,90.89 178.96,92.39 179.93,92.39 183.66,96.13 183.66,109.31 177.79,115.18 177.79,122.87 179.65,124.72 179.65,125.64 187.33,133.32 187.33,140.18 186.67,140.84 185.81,140.84 v2(185.57,141.08)
  BOTTOM w0.102: 187.42,141.16 v3(187.21,141.37) ; 187.42,141.16 187.05,140.79 185.86,140.79 v2(185.57,141.08) ; 187.42,141.16 187.8,141.54 188.3,141.54 188.3,141.54 U14.4
HSO_C_DN8: length 171.9
  TOP w0.102: v2(122.08,81.03) 122.38,80.73 123.59,80.73 C167.1 ; 114.1,232.84 116.95,235.69 117.61,235.69 R719.2 ; 114.1,232.84 v1(113.84,233.11) ; 114.1,232.84 113.39,232.13 113.39,151.27 127.74,136.92 127.74,136.03 127.48,135.77 127.22,135.51 v2(126.76,135.51)
  L4 w0.127: v2(126.76,135.51) 126.76,135.08 126.01,134.34 126.01,122.65 129.34,119.32 129.34,119.31 129.42,119.24 129.42,87.33 122.84,80.75 122.35,80.75 v2(122.08,81.03)
HSO_C_DP6: length 155.4
  TOP w0.102: C162.1 120.96,77.04 120.13,77.04 v2(119.8,77.37)
  L4 w0.127: v2(119.8,77.37) 120.12,77.05 126.97,77.05 130.35,73.67 130.35,68.97 131.79,67.52 133.89,67.52 135.77,65.65 137.11,65.65 137.97,66.51 139.19,66.51 139.24,66.45 142.56,66.45 143.18,65.84 146.69,62.32 160.93,62.32 165.04,66.43 165.04,70.93 165.99,71.88 168.58,71.88 172.24,75.55 172.24,76.03 172.24,76.03 172.24,78.05 172.6,78.41 172.6,82.6 177.2,87.2 177.2,91 178.85,92.66 179.82,92.66 183.39,96.24 183.39,99.5 183.26,99.63 183.26,100.02 183.39,100.15 183.39,100.53 183.26,100.67 183.26,101.05 183.39,101.19 183.39,106.27 183.26,106.41 183.26,106.79 183.39,106.92 183.39,107.31 183.26,107.44 183.26,107.82 183.39,107.96 183.39,108.34 183.26,108.48 183.26,108.86 183.39,109 183.39,109.2 177.53,115.06 177.53,122.98 179.38,124.83 179.38,125.75 187.06,133.43 187.06,136.96 186.93,137.1 186.93,137.48 187.06,137.61 187.06,137.99 186.93,138.13 186.93,138.51 187.06,138.65 187.06,139.03 186.93,139.17 186.93,139.55 187.06,139.69 187.06,140.07 186.56,140.58 185.77,140.58 v2(185.51,140.32)
  BOTTOM w0.102: v3(184.98,140.02) v2(185.51,140.32) 185.77,140.58 187.14,140.58 187.89,141.32 188.3,141.32 188.48,141.14 U14.3
HSO_C_DP8: length 172.4
  TOP w0.102: v2(122.08,80.21) 122.38,80.51 123.33,80.51 C168.1 ; R720.2 117.61,235.47 117.04,235.47 116.17,234.61 ; 116.17,234.61 113.61,232.04 113.61,156.17 113.72,156.05 113.72,155.75 113.61,155.64 113.61,155.33 113.72,155.22 113.72,154.92 113.61,154.81 113.61,154.5 113.72,154.39 113.72,154.08 113.61,153.97 113.61,153.65 113.72,153.54 113.72,153.23 113.61,153.12 113.61,151.36 127.96,137.01 127.96,135.94 127.38,135.36 v2(127.38,134.9) ; 116.17,234.61 v1(116.43,234.35)
  L4 w0.127: v2(122.08,80.21) 122.35,80.49 122.95,80.49 129.69,87.22 129.69,119.35 129.61,119.42 129.61,119.43 126.28,122.76 126.28,134.23 126.95,134.9 v2(127.38,134.9)
HSO_C_LAN_DN5: length 93.2
  TOP w0.102: C165.1 125.07,76.16 124.76,76.48 124.55,76.48 124.45,76.38 124.45,75.59 124.55,75.22 v2(124.63,75.14) ; U9623.14 64.65,28.14 65.29,28.78 65.29,30.27 66.85,31.82 66.85,33.83 68.59,35.57 68.59,36.05 ; v2(68.29,36.99) 68.59,36.7 68.59,36.05 ; 68.59,36.05 v1(68.22,36.05)
  L3 w0.127: v2(124.63,75.14) 124.54,75.23 124.54,75.54 124.79,75.79 125.12,75.79 125.53,75.37 125.53,74.39 125.4,74.25 125.4,73.87 125.53,73.73 125.53,73.35 125.4,73.21 125.4,72.83 125.53,72.69 125.53,72.31 125.4,72.18 125.4,71.8 125.53,71.66 125.53,69.9 123.34,67.7 118.54,67.7 116.65,65.81 116.46,65.81 116.19,65.54 116.19,65.34 115.92,65.07 115.72,65.07 115.45,64.8 115.45,64.61 115.18,64.34 114.99,64.34 114.72,64.07 114.72,63.88 112.59,61.75 111.06,61.75 110.14,60.83 110.14,60.52 109.87,60.25 109.68,60.25 109.41,59.98 109.41,59.79 109.14,59.52 108.94,59.52 108.67,59.25 108.67,59.06 98.66,49.05 88.76,49.05 83.85,44.14 82.97,44.14 79.91,41.08 73.86,41.08 70.62,37.84 68.92,37.84 68.52,37.45 68.52,37.23 v2(68.29,36.99)
HSO_C_LAN_DP5: length 93.7
  TOP w0.102: U9623.13 64.16,27.74 64.34,27.93 64.74,27.93 65.51,28.69 65.51,30.18 67.06,31.74 67.06,33.74 67.84,34.52 ; v2(69.1,36.99) 68.8,36.69 68.8,35.48 67.84,34.52 ; C166.1 125.09,77.02 124.76,76.69 124.46,76.69 124.24,76.47 124.24,75.87 v2(123.92,75.55) ; 67.84,34.52 v1(68.1,34.26)
  L3 w0.127: v2(69.1,36.99) 68.98,36.99 68.79,37.18 68.79,37.34 69.03,37.58 70.73,37.58 73.97,40.82 80.02,40.82 83.08,43.88 83.96,43.88 88.87,48.78 98.77,48.78 110.41,60.41 110.41,60.72 111.18,61.49 112.71,61.49 114.99,63.77 114.99,63.96 115.1,64.07 115.29,64.07 118.66,67.44 123.45,67.44 125.8,69.79 125.8,75.48 125.23,76.05 124.68,76.05 124.18,75.55 v2(123.92,75.55)
HSO_DN5: length 6.8
  TOP w0.102: 126.99,76.45 127.42,76.45 127.7,76.17 129.18,76.17 130.04,77.03 131.33,77.03 U2.D22 ; 126.99,76.45 v1(126.99,76.05) ; 126.99,76.45 126.27,76.45 C165.2
HSO_DN6: length 9.7
  TOP w0.102: 123.77,77.58 124.31,78.13 126.13,78.13 126.8,77.46 U2.B22 ; 123.77,77.58 v1(124.02,77.33) ; 123.77,77.58 123.01,76.82 122.5,76.82 C161.2
HSO_DN8: length 8.2
  TOP w0.102: C167.2 125.16,80.95 125.26,80.85 125.26,80.7 125.37,80.6 125.56,80.6 126.07,80.09 ; 126.07,80.09 126.43,79.72 126.43,79.34 126.96,78.81 130.61,78.81 130.73,78.7 130.93,78.7 U2.C24 ; 126.07,80.09 v1(126.31,80.33)
HSO_DP5: length 6.2
  TOP w0.102: C166.2 126.34,76.67 127.51,76.67 127.79,76.39 128.16,76.39 ; 128.16,76.39 v1(128.17,76.81) ; 128.16,76.39 129.09,76.39 129.95,77.25 130.13,77.25 130.14,77.23 131,77.23 U2.C22
HSO_DP6: length 9.5
  TOP w0.102: C162.2 122.56,77.04 122.92,77.04 124.22,78.35 125.29,78.35 ; v1(125.29,78.73) 125.29,78.35 ; 125.29,78.35 126.22,78.35 126.89,77.68 130.12,77.68 130.25,77.81 U2.A23
HSO_DP8: length 7.6
  TOP w0.102: v1(127.42,78.24) 127.42,78.6 ; 127.42,78.6 130.52,78.6 U2.B24 ; 127.42,78.6 126.87,78.6 126.22,79.25 126.22,79.63 126.07,79.78 125.5,80.35 125.47,80.38 125.37,80.38 125.26,80.28 125.26,80.14 125.16,80.03 C168.2
I2CC_SCL_PU: length 12.6
  TOP w0.102: GPU1.A9 85.71,100.22 86.33,99.6 87.52,99.6 88.64,98.49 89.3,98.49 90.14,97.65 v1(90.34,97.65) 90.61,97.92 91.78,97.92 v2(92.27,98.41)
  BOTTOM w0.102: v2(92.27,98.41) 92.6,98.74 94.86,98.74 95,98.88 R628.2 94.56,99.36 R80224.1
I2CC_SDA_PU: length 12.1
  TOP w0.102: v2(91.38,98.35) 91.26,98.23 89.85,98.23 89.29,98.79 88.73,98.79 87.72,99.81 86.41,99.81 GPU1.B9
  BOTTOM w0.102: R79990.2 91,100.79 91,100.16 91.95,99.21 92.24,99.21 ; 92.24,99.21 v2(91.38,98.35) 91.38,97.9 v3(91.64,97.65) ; 92.24,99.21 R80223.1
I2CS_SCL_G: length 10.6
  TOP w0.102: GPU1.D9 85.22,102.62 v5(85.62,102.22)
  BOTTOM w0.102: v5(85.62,102.22) 86,102.61 86.62,102.61 86.89,102.88 86.89,104.88 87.74,105.73 90.06,105.73 90.24,105.9 v3(90.67,105.9) R630.2 91.7,105.78 91.19,105.27 R632.1
I2CS_SDA_G: length 12.3
  TOP w0.102: GPU1.D8 86.04,102.62 86.04,102.59 86.35,102.27 86.36,102.27 86.45,102.17 v5(86.46,102.17)
  BOTTOM w0.102: v5(86.46,102.17) 86.69,102.4 86.71,102.4 87.1,102.79 87.1,103.92 87.72,104.55 87.72,104.88 88.37,105.52 90.23,105.52 90.77,104.98 90.77,104.33 91.13,103.97 91.13,103.93 R79983.2 91.57,104.13 92.54,104.13 93.17,104.76 v3(93.24,104.76) 93.24,104.81 93.54,105.12 R79992.1
ICH_RSMRST_N_R: length 5.6
  TOP w0.102: R291.1 99.83,56.72 101.04,57.93 v1(101.97,57.93) 102.89,57.01 102.89,56.63 103.11,56.41 U109.82
IMAX: length 7.8
  TOP w0.254: PR4474.1 42.93,238.94 43.12,238.75 v2(43.12,238.62)
  BOTTOM w0.203: v2(43.12,238.62) 42.36,238.62 42.34,238.64 v3(42.21,238.64) 42.19,238.62 41.55,238.62 41,239.16 41,239.89 40.96,239.93 40.96,240.52 40.58,240.9 40.58,241.36 40.91,241.69 PU4401.36
IMAXA: length 4.3
  BOTTOM w0.203: PU4401.29 43.71,241.34 44.27,240.78 44.27,240.65
  BOTTOM w0.254: PR4462.1 44.27,239.47 v3(44.34,239.55) 44.27,239.62 44.27,240.65
IMS: length 33.6
  TOP w0.102: LVDS1.4 23.29,54.5 23.36,54.57 v2(23.92,54.57) 24.19,54.57 R79811.1
  L4 w0.127: v2(23.92,54.57) 24.58,53.91 24.58,49.82 25.34,49.06 25.34,47.48 23.88,46.02 23.88,37.9 23.18,37.2 v2(23.18,28.18)
  BOTTOM w0.102: v3(24.2,26.66) R79832.2 24.01,27.61 23.44,28.18 v2(23.18,28.18)
INIT_3V: length 7.1
  TOP w0.102: R763.2 138.56,49.94 138.63,50 v2(138.63,50.38)
  L3 w0.127: LPC1.2 140.56,53.48 138.63,51.55 v2(138.63,50.38)
  BOTTOM w0.102: v3(139.2,49.8) v2(138.63,50.38)
IO_SMI_N: length 76.6
  TOP w0.102: v2(150.46,53.4) 150.18,53.4 147.97,51.19 132.8,51.19 130.52,48.91 130.52,47.99 129.09,46.55 v1(126.86,46.55) 126.69,46.73 126.69,49.9 126.43,50.15 125.04,50.15 124.91,50.02 124.91,49.31 124.66,49.06 124.14,49.06 R254.2 123.46,48.5 121.86,50.09 121.86,50.72 122.17,51.02 122.17,52.21 120.37,54.01 U109.9 ; U2.AV29 148.37,80.44 v2(148.67,80.15)
  L3 w0.127: v2(150.46,53.4) 149.68,54.19 149.68,58.89 147.09,61.48 147.09,64.98 147.2,65.09 147.2,66.84 147.54,67.19 147.54,67.42 148.23,68.11 148.23,68.32 148.3,68.39 148.3,68.49 148.31,68.49 148.31,68.86 148.3,68.87 148.3,69.73 147.87,70.17 147.87,70.84 147.86,70.85 147.86,71.35 147.41,71.8 147.14,71.8 146.66,72.28 146.66,72.3 146.2,72.75 146.16,72.75 145.9,73.02 145.9,73.65 145.46,74.08 145.46,75.17 145.54,75.25 145.54,75.62 145.31,75.85 145.31,76.83 145.3,76.83 145.3,79.15 145.9,79.74 148.26,79.74 v2(148.67,80.15)
ISEN1: length 7.7
  TOP w0.254: v2(21.28,11.29) 21.21,11.29 21.15,11.35 21.79,11.99 R79693.1
  BOTTOM w0.254: v2(21.28,11.29) 20.61,11.95 v3(19.88,11.95) 19.84,11.99 16.18,11.99 15.94,12.23 U120.17
ISEN2: length 7.8
  TOP w0.254: R79696.1 22.74,12.56 21.15,12.56 v2(21.02,12.69)
  BOTTOM w0.254: v2(21.02,12.69) 20.26,13.45 v3(19.12,13.45) 18.46,12.79 U120.16
ISEN3: length 9
  TOP w0.254: R79699.1 24.45,12.81 v2(24.58,12.94)
  BOTTOM w0.254: U120.14 17.95,14.25 18.14,14.06 20.14,14.06 20.47,14.39 v3(22.65,14.39) 23.13,14.39 v2(24.58,12.94)
ISEN4: length 10.7
  TOP w0.254: R79705.1 v2(25.6,13.07)
  BOTTOM w0.254: v2(25.6,13.07) 23.67,15 21.25,15 v3(20.9,15.35) 20.71,15.35 19.92,14.57 18.51,14.57 18.33,14.75 U120.13
ISET: length 7.7
  TOP w0.102: R1596.2 168.34,45.45 v1(169,44.79) 168.52,44.31 R2086.1 166.96,44.99 165.12,44.99 165.04,45.08 U118.34
ISP_CLK1: length 7.8
  TOP w0.102: v1(53.33,17.72) 52.82,17.72 52.25,18.29 Q9502.6 51.16,19.06 50.34,19.06 50.06,19.34 Q9501.6 49.74,20.04 48.95,20.83 47.9,20.83 R9540.2
ISP_DAT1: length 10.8
  TOP w0.102: R9541.2 52.98,21.34 Q9501.3 51.73,21.54 v2(51.73,22.08) ; v1(50.18,15.66) 50.18,15.68 50.06,15.81 Q9502.3 49.56,16.99 49.02,17.53 49.02,18.02 v2(49.02,18.02)
  L3 w0.127: v2(51.73,22.08) 51.73,20.6 49.26,18.12 49.21,18.12 49.02,17.94 49.02,18.02 v2(49.02,18.02)
ISW: length 19.6
  BOTTOM w0.254: R79710.2 5.61,6.72 5.61,4.86 6.93,3.54 11.37,3.54 v3(11.75,3.92) 12.52,3.92 14.61,6.02 C12235.1 14.93,11.61 U120.19
ISW_1:
  vias: v3(5.78,10.15)
ITP_PMODE: length 191.7
  TOP w0.102: v2(31.79,123.18) 31.88,123.09 R1770.1 ; v2(129.37,50.33) 129.37,50.96 131.02,52.61 147.38,52.61 149.6,54.83 149.6,55.64 150.89,56.93 150.89,59.48 150.59,59.78 150.59,62 150.03,62.56 150.03,63.27 150.01,63.3 150.01,63.95 148.74,65.22 148.74,65.39 148.32,65.81 147.92,65.81 147.66,66.08 147.66,67.17 147.78,67.29 U2.AT2
  L4 w0.127: v2(129.37,50.33) 129.28,50.42 118.98,50.42 118.26,49.71 114.17,49.71 112.65,51.22 112.65,52.61 109.02,56.25 105.72,56.25 102.95,59.03 100.76,59.03 98.43,61.37 92.3,61.37 91.87,61.8 89.14,61.8 88.94,61.59 86.35,61.59 81.73,66.22 81.73,67.3 80.46,68.57 80.46,70.48 76.66,74.28 66.62,74.28 58.17,82.73 57.93,82.73 57.19,83.46 57.16,83.46 49.48,91.13 36.74,91.13 36.62,91.01 v2(36.39,91.01)
  BOTTOM w0.102: v2(31.79,123.18) 31.97,123.18 32.66,122.49 v3(32.66,122.08) 32.25,121.68 32.25,117.61 34.08,115.78 34.08,113.26 32.5,111.69 32.5,101.89 30.22,99.6 30.22,93.04 32.24,91.01 v2(36.39,91.01)
JACK_PSID: length 21.2
  L4 w0.127: DCIN1.3 71.57,25.28 69.31,25.28 65.7,21.68 56.69,21.68 56.52,21.51 v2(56.46,21.51)
  BOTTOM w0.102: v2(56.46,21.51) 56.06,21.91 56.04,21.91 v3(54.49,23.46) 54.43,23.52 L21.1
JDREF: length 4.8
  TOP w0.203: 182.26,61.58 182.26,61.04 182.06,60.84 U9.35
  TOP w0.254: R367.1 184.41,63.71 183.81,63.11 v1(183.33,63.11) 183.33,62.63 183.04,62.34 182.76,62.34 182.26,61.84 182.26,61.58
JTAG_TCLK: length 5.2
  TOP w0.127: v5(89.2,122.84) 89.13,122.77 89.13,122.14 89.02,122.03 89.02,120.97 88.89,120.83 88.89,120.67 88.53,120.32 GPU1.AE5
  BOTTOM w0.127: v3(90.11,124.07) 89.77,123.72 R79985.2 89.1,122.94 v5(89.2,122.84)
JTAG_TDI: length 4.4
  TOP w0.127: GPU1.AE6 88.13,120.47 88.13,121.24 88.26,121.38 88.26,122.38 v5(87.82,122.82)
  BOTTOM w0.127: TP40.1 87.88,122.88 v5(87.82,122.82)
JTAG_TDO: length 2.4
  TOP w0.127: GPU1.AF6 87.68,121.12 88.04,121.47 88.04,121.96 v5(87.83,122.17)
  BOTTOM w0.127: v5(87.83,122.17) 87.38,122.17 TP42.1
JTAG_TMS: length 7.6
  TOP w0.127: GPU1.AD6 87.71,119.22 88.15,119.66 88.68,119.66 89.02,120.01 89.02,120.17 89.32,120.46 89.53,120.46 89.76,120.69 89.76,121.74 91.2,123.18 v2(91.2,123.86)
  BOTTOM w0.127: v2(91.2,123.86) 91.2,124.04 TP258.1
JTAG_TRST: length 3.8
  TOP w0.127: v5(89.86,122.54) 89.4,122.08 89.4,121.64 GPU1.AG4
  BOTTOM w0.127: v5(89.86,122.54) 89.86,122.67 90.13,122.94 v3(90.59,122.94) 90.59,121.81 R79988.2
KBCLK: length 5.7
  TOP w0.102: v2(106.45,58.63) 106.45,58.36 106.2,58.1 105.43,58.1 105.34,58.01 U109.78
  BOTTOM w0.102: v2(106.45,58.63) 106.34,58.74 106.34,59.35 v3(106.44,59.45) 106.47,59.47 106.77,59.47 107,59.24 107,58.73 107.1,58.63 RN3.3
KBRST_N: length 85.3
  TOP w0.102: U2.AT17 147.2,75.4 v2(147.2,75.56) ; v2(114.57,66.05) 114.17,65.65 U109.42
  BOTTOM w0.102: v2(147.2,75.56) 147.41,75.56 148.16,74.81 151.35,74.81 151.53,74.99 152.7,74.99 152.88,74.81 154.78,74.81 155.01,74.58 156.45,74.58 156.65,74.79 R196.2 157.23,75.06 157.61,75.44 159.44,75.44 159.79,75.08 159.79,74.84 160.34,74.29 160.34,73.5 160.72,73.12 160.72,72.29 160.12,71.69 160.12,71.31 160.39,71.04 161.22,71.04 v3(162.5,69.76) 163.47,68.79 163.47,62.92 162.54,61.99 162.29,61.99 161.86,61.56 161.27,61.56 161.15,61.43 154.27,61.43 154.01,61.7 147.86,61.7 145.61,59.45 142.45,59.45 141.93,58.92 132.5,58.92 131.74,58.16 128.87,58.16 127.28,59.75 126.49,59.75 123.55,62.7 123.45,62.7 120.97,65.19 116.96,65.19 116.78,65.01 115.59,65.01 114.72,65.87 114.72,65.9 v2(114.57,66.05)
KDAT: length 6.7
  TOP w0.102: U109.77 104.72,58.41 105.19,58.88 105.48,58.88 105.71,58.65 105.71,58.69 v2(105.69,58.69)
  BOTTOM w0.102: v2(105.69,58.69) 105.35,59.03 v3(105.35,60.06) 105.61,60.31 106.88,60.31 107.53,59.65 RN3.4
L_AD0: length 102.3
  TOP w0.102: v2(148.18,77.76) 148.16,77.75 148.16,77.63 U2.AT22 ; U109.38 115.77,63.79 116.2,63.37 v2(116.2,63.08)
  L4 w0.127: LPC1.5 137.41,56.02 137.41,54.51 136,53.1 127.83,53.1 125.01,55.92 123.84,55.92 122.69,57.07 121.37,57.07 120.84,57.61 120.12,57.61 119.2,58.53 119.2,59.45 118.51,60.13 116.91,60.13 115.17,61.88 115.17,62.54 115.71,63.08 v2(116.2,63.08)
  BOTTOM w0.102: v2(148.18,77.76) 148.35,77.76 148.67,77.44 150.94,77.44 151.23,77.74 151.71,77.74 152.07,77.37 152.55,77.37 153.36,76.57 154.72,76.57 155,76.85 155.41,76.85 155.76,77.2 156.25,77.2 156.88,77.84 158.39,77.84 158.68,78.13 159.12,78.13 159.45,77.8 159.45,77.42 159.83,77.04 160.94,77.04 v3(162.01,75.96) 163.26,74.71 163.47,74.71 163.67,74.51 163.67,74.37 165.07,72.97 165.07,71.62 165.66,71.03 165.66,62.02 165.07,61.43 163.44,59.8 163.33,59.8 162.93,59.41 162.93,59.29 161.97,58.33 150.87,58.33 148.53,55.99 147.26,55.99 145.48,54.22 142.56,54.22 140.75,56.03 137.4,56.03 LPC1.5 ; v2(116.2,63.08) 116.21,63.07 116.21,62.28 116.53,61.96 116.53,60.86 RN1.4
L_AD1: length 95.6
  TOP w0.102: U2.AV22 148.26,77.18 147.9,76.82 147.65,76.82 v5(147.51,76.68) ; v2(116.04,61.67) 116.1,61.73 116.1,62.53 115.39,63.24 115.37,63.24 U109.39
  L4 w0.127: LPC1.7 134.56,56.55 135.41,55.7 135.41,54.51 134.31,53.41 127.96,53.41 125.14,56.22 123.97,56.22 122.81,57.38 121.5,57.38 120.96,57.91 120.24,57.91 119.5,58.65 119.5,59.57 118.64,60.44 117.51,60.44 116.27,61.67 v2(116.04,61.67)
  BOTTOM w0.102: v5(147.51,76.68) 147.61,76.68 148.1,76.19 148.41,76.19 148.76,75.84 150.2,75.84 150.44,75.6 150.44,75.54 150.76,75.22 151.18,75.22 151.36,75.4 153.05,75.4 153.15,75.3 155.85,75.3 v3(156,75.45) 156.41,75.45 157.04,76.07 160.25,76.07 161.44,74.88 161.44,73.88 164.69,70.63 164.69,62.42 163.04,60.77 162.8,60.77 162.27,60.23 161.9,60.23 161.52,59.85 153.84,59.85 153.31,59.32 150.36,59.32 149.07,58.03 145.92,58.03 143.76,55.87 142.75,55.87 140.91,57.7 135.4,57.7 LPC1.7 ; RN1.3 115.66,61.33 116.01,61.67 v2(116.04,61.67)
L_AD2: length 96.1
  TOP w0.102: v2(146.7,76.69) 147.02,76.38 147.08,76.38 147.38,76.08 U2.AT19 ; v2(115.64,62.34) 115.36,62.34 114.97,62.72 U109.40
  L4 w0.127: LPC1.9 132.56,56.37 133.41,55.52 133.41,54.51 132.61,53.71 128.08,53.71 125.27,56.53 124.37,56.53 122.78,58.12 122.78,58.52 121.66,59.64 119.98,59.64 118.88,60.74 117.64,60.74 116.03,62.34 v2(115.64,62.34)
  BOTTOM w0.102: RN1.2 115.16,61.91 115.59,62.34 v2(115.64,62.34) ; LPC1.9 133.68,57.98 141.03,57.98 142.86,56.15 143.64,56.15 146.16,58.66 v3(147.52,58.66) 148.71,58.66 149.65,59.6 153.19,59.6 153.72,60.13 161.4,60.13 161.78,60.51 162.15,60.51 162.68,61.05 162.92,61.05 164.41,62.53 164.41,70.52 161.16,73.77 161.16,74.77 160.14,75.79 157.15,75.79 156.3,74.94 155.79,74.94 155.71,75.02 152.97,75.02 152.79,75.2 151.45,75.2 151.27,75.01 149.08,75.01 148.83,75.26 148.83,75.35 148.27,75.92 147.48,75.92 v2(146.7,76.69)
L_AD3: length 94.1
  TOP w0.102: v2(160.25,75.03) 160.07,74.85 160.02,74.85 159.48,74.31 158.2,74.31 158.19,74.29 156.61,74.29 156.47,74.43 155.69,74.43 155.56,74.56 154.46,74.56 154.39,74.64 151.79,74.64 151.69,74.53 151.68,74.53 151.5,74.35 U2.BD16 ; U109.41 114.57,61.76 115.11,61.22 116.23,61.22 116.67,61.66 v2(116.67,62.47)
  L4 w0.127: v2(116.67,62.47) 116.67,62.14 117.76,61.05 119.01,61.05 120.11,59.94 121.78,59.94 123.08,58.64 123.08,58.25 124.5,56.83 125.39,56.83 128.21,54.02 130.91,54.02 131.41,54.51 131.41,55.23 130.56,56.08 LPC1.11
  BOTTOM w0.102: v2(116.67,62.47) 116.67,63.26 116.39,63.53 115.68,63.53 114.51,62.36 RN1.1 ; LPC1.11 131.38,56.87 132.77,58.26 141.17,58.26 143.01,56.42 143.53,56.42 146.65,59.55 148.79,59.55 149.65,60.41 v3(149.98,60.41) 161.28,60.41 161.77,60.9 162.14,60.9 162.57,61.33 162.81,61.33 164.13,62.65 164.13,70.21 160.83,73.52 160.83,74.46 v2(160.25,75.03)
L_BKLTCTL: length 149.4
  TOP w0.165: U2.W36 139.29,84.39 138.86,83.97 v2(138.78,83.97)
  L3 w0.165: v2(45.69,26.15) 45.69,26.57 48.74,29.62 48.74,30.12 50.23,31.61 51.14,31.61 52.39,32.86 53.48,32.86 58.03,37.41 62.77,37.41 64.61,39.25 66.18,39.25 69.59,42.65 69.59,42.85 70.05,43.31 79.89,43.31 82.03,45.45 83.25,45.45 88.06,50.26 97.94,50.26 101.57,53.9 101.57,54.84 102.81,56.08 102.81,57.57 105.39,60.15 106.72,60.15 112.09,65.52 112.09,67.43 116.02,71.36 116.02,72.29 118.13,74.41 120.99,74.41 124.32,77.74 131.19,77.74 131.92,78.47 136.16,78.47 137.61,79.92 137.61,80.89 138.31,81.59 138.31,83.5 v2(138.78,83.97)
  BOTTOM w0.165: v2(45.69,26.15) 45.43,25.89 44.81,25.89 44.81,25.89 42.47,25.89 41.2,24.62 37.27,24.62 v3(37.09,24.43) 36.66,24.01 29.39,24.01 28.9,24.5 25.41,24.5 23.47,26.44 22.77,26.44 22.29,26.91 R79777.1
L_FRAME_N: length 81.5
  TOP w0.102: v2(163.75,76.57) R198.2 ; v2(117.95,62.44) 117.57,62.44 116.18,63.84 U109.37
  L4 w0.127: v2(117.95,62.44) 119.04,61.35 119.13,61.35 120.24,60.25 121.91,60.25 123.39,58.77 123.39,58.38 124.63,57.14 127.81,57.14 128.08,56.87 LPC1.13
  BOTTOM w0.102: R327.1 117.24,62.77 117.57,62.44 v2(117.95,62.44) 118.69,61.71 R324.2 ; LPC1.13 127.72,56.03 127.72,54.52 128.31,53.94 147.73,53.94 148.81,55.02 148.81,55.87 151,58.05 162.08,58.05 162.9,58.86 163.68,58.86 163.95,59.13 163.95,59.92 165.35,61.31 165.94,61.9 165.94,71.15 165.35,71.74 165.35,73.09 163.95,74.48 v3(163.95,75.5) 163.76,75.69 163.76,76.53 163.75,76.54 v2(163.75,76.57)
L_FRAME_N_R: length 11.7
  TOP w0.102: U2.BE16 151.96,74.43 154.3,74.43 154.46,74.28 155.45,74.28 155.57,74.15 156.35,74.15 156.49,74.01 158.3,74.01 158.31,74.03 159.59,74.03 160.14,74.58 160.44,74.58 161.03,75.16 v1(161.03,75.45) 161.03,75.63 161.96,76.57 R198.1
LAN_DISABLE_N: length 184.6
  TOP w0.102: U2.AR15 146.92,73.3 v2(147.03,73.2)
  L3 w0.127: v2(114.92,77.03) 110.39,77.03 104.72,71.36 102.68,71.36 101.88,70.56 101.88,69.65 96.26,64.03 96.26,62.87 92.8,59.4 92.8,58.21 93.11,57.9 93.11,57.28 91.69,55.87 88.87,55.87 88.03,55.03 87.79,55.03 86,55.03 81.19,50.21 80.05,50.21 79.24,49.4 78.52,49.4 66.28,49.4 66.26,49.37 65.61,49.37 64.81,50.18 50.89,50.18 50.17,50.9 42.62,50.9 41.43,49.71 41.43,48.52 38.74,45.83 38.74,37.92 38.92,37.74 v2(38.92,37.72)
  L4 w0.127: v2(51.89,23.74) 53.14,24.99 53.43,24.99 53.75,25.32 53.75,25.71 53.48,25.98 51.08,25.98 50.91,25.81 50.29,25.81 49.86,26.24 48.7,26.24 48.12,25.65 45.5,25.65 44.71,26.44 43.08,26.44 40.75,28.77 40.75,35.94 38.98,37.71 38.93,37.71 v2(38.92,37.72)
  BOTTOM w0.102: R79750.1 52.65,22.97 v2(51.89,23.74) ; v2(114.92,77.03) 116.23,78.35 v3(117.16,78.35) 120.4,78.35 124.3,74.44 124.3,68.51 125.32,67.5 125.32,66.81 126.27,65.86 126.95,65.86 128.77,64.04 130.8,64.04 131.46,63.38 134.22,63.38 134.42,63.59 136.54,63.59 137.48,64.53 137.48,65.58 R122.1 138.68,66.78 141.32,66.78 142.82,68.27 142.82,68.9 143.32,69.4 144.48,69.4 144.77,69.11 144.77,68.43 145.19,68.01 145.89,68.01 146.26,68.38 146.26,69.54 146.52,69.8 146.79,69.8 147.06,70.07 147.06,70.54 146.67,70.94 146.67,71.53 146.89,71.75 146.89,72.42 147.03,72.56 v2(147.03,73.2)
LAN_DISABLE_N_1: length 4.7
  BOTTOM w0.254: Q1265.B 54.36,20.37 53.73,21 C12120.1 R79750.2 52.49,20.85 v3(52.49,19.86) R79747.1
LAN_DISABLE_N_2: length 7.9
  TOP w0.254: v2(56.03,19.7) 56.1,19.62 56.58,19.62 56.96,19.99 Q1266.B
  BOTTOM w0.254: v2(56.03,19.7) 56.03,18.54 Q1265.C 54.9,17.42 54.9,17.23 v3(54.43,16.75) 54.17,16.75 53.6,17.32 R79743.2 53.41,18.08 R79747.2
LAN_DISABLE_N_3: length 10
  TOP w0.102: Q1266.C 57.74,18.52 58.39,17.87 v1(58.39,17.84) 58.39,16.5 56.39,14.5 Q1267.C 55.95,13.89 R79745.1 R79744.2
LAN_DISABLE_N_4: length 17.5
  TOP w0.102: C280.2 50.53,22.78 Q1264.G 50.89,23.1 51.64,23.1 52.6,22.14 55.53,22.14 56,21.66 56,20.32 55.42,19.73 55.42,17.85 C12123.1 56.47,16.8 57.5,16.8 v1(57.52,16.78) 57.52,16.5 57.09,16.06 56.06,16.06 54.81,14.81 R79745.2
LAN_DISABLE_V3: length 5.9
  TOP w0.102: R426.1 60.78,13.51 59.82,12.56 R1194.2 ; C12122.1 59.76,12.62 R1194.2 ; R1194.2 59.82,12.27 59.35,11.8 58.84,11.8 v1(58.72,11.92) 58.67,11.92 58.3,12.29 Q1267.B
LAN_LEDACT_R#: length 10.7
  TOP w0.254: RJ1.10 101.92,20.92 101.92,25.51 101.54,25.89 99.38,25.89 98.75,26.53 R79829.2
  BOTTOM w0.254: v3(101.27,19.04) RJ1.10
LAN_MDI0_C_DN: length 32.9
  TOP w0.089: v2(100.36,9.64) 100.65,9.34 100.65,9.13 100.09,8.56 RJ1.2 ; XF3.22 78.13,4.35 78.48,4 78.48,3.92 v2(78.08,3.52)
  L4 w0.102: v2(100.36,9.64) 100.66,9.33 100.66,6.68 99.63,5.65 79.56,5.65 78.41,4.5 78.41,3.91 78.08,3.58 v2(78.08,3.52)
  BOTTOM w0.089: v3(77.79,2.98) v2(78.08,3.52)
LAN_MDI0_C_DP: length 32.6
  TOP w0.089: v2(79.02,3.52) 78.83,3.71 78.83,4 79.12,4.3 XF3.23 ; RJ1.1 101.36,8.55 101,8.91 101,9.34 v2(101.29,9.64)
  L4 w0.102: v2(101.29,9.64) 100.99,9.33 100.99,6.55 99.76,5.32 79.7,5.32 78.74,4.36 78.74,3.86 79.02,3.58 v2(79.02,3.52)
  BOTTOM w0.089: v3(79.49,3.14) v2(79.02,3.52)
LAN_MDI0_DN: length 37.3
  TOP w0.089: 60.03,17.35 62.1,15.28 62.1,13.78 62.76,13.12 63.11,13.12 63.3,12.93 63.3,12.57 63.49,12.39 63.84,12.39 64.03,12.2 64.03,11.84 64.22,11.65 64.58,11.65 64.76,11.47 64.76,11.11 66.48,9.4 76.67,9.4 77.53,10.25 77.53,10.61 77.72,10.8 78.07,10.8 78.47,11.19 78.47,11.59 78.21,11.85 78.21,12.11 78.47,12.36 78.47,13.26 78.13,13.59 XF3.3 ; 60.03,17.35 59.63,17.75 59.63,20.82 58.98,21.46 58.98,22.01 U9614.3 58.98,22.31 58.98,23.32 60.66,25 U9623.2 ; 60.03,17.35 v1(60.19,17.51)
LAN_MDI0_DP: length 37.5
  TOP w0.089: XF3.2 79.12,13.56 78.81,13.24 78.81,11.05 76.81,9.05 66.34,9.05 62.62,12.77 ; 62.62,12.77 v1(62.35,12.51) ; 62.62,12.77 61.75,13.64 61.75,15.14 59.28,17.61 59.28,19.32 U9614.4 59.28,19.61 59.28,20.68 58.64,21.32 58.64,23.46 60.26,25.08 U9623.1
LAN_MDI1_C_DN: length 31.9
  TOP w0.089: v2(95.24,9.56) 95.27,9.56 95.45,9.38 95.45,9 95.01,8.56 RJ1.6 ; XF3.19 75.16,4.32 75.56,3.92 75.56,3.84 v2(75.24,3.52)
  L4 w0.102: v2(95.24,9.56) 96.77,8.03 96.77,7.36 96.33,6.92 77.54,6.92 75.57,4.95 75.57,3.96 75.24,3.63 v2(75.24,3.52)
  BOTTOM w0.089: v3(74.95,4.05) v2(75.24,3.52)
LAN_MDI1_C_DP: length 31.6
  TOP w0.089: v2(76.18,3.52) 75.91,3.79 75.91,4.02 76.15,4.27 XF3.20 ; RJ1.3 98.82,8.68 98.44,9.05 v2(98.44,9.56)
  L4 w0.102: v2(98.44,9.56) 97.1,8.21 97.1,7.23 96.46,6.59 77.68,6.59 75.9,4.81 75.9,3.82 76.18,3.54 v2(76.18,3.52)
  BOTTOM w0.089: v3(76.47,4.05) v2(76.18,3.52)
LAN_MDI1_DN: length 31.1
  TOP w0.089: 65.38,13.76 65.48,13.66 65.48,12.53 67.39,10.62 72.72,10.62 73.02,10.92 73.29,10.92 73.59,10.62 73.75,10.62 74.06,10.92 74.32,10.92 74.62,10.62 74.93,10.62 75.49,11.18 75.49,12.2 75.24,12.45 75.24,12.71 75.49,12.97 75.49,13.23 75.16,13.56 XF3.6 ; 65.38,13.76 v1(65.63,14.01) ; 65.38,13.76 62.28,16.86 62.28,17.21 62.09,17.4 61.74,17.4 61.54,17.6 61.54,18.1 61.79,18.35 61.79,18.62 61.54,18.87 61.54,20.05 61.38,20.2 61.38,21.2 60.91,21.67 60.91,22.03 U9614.1 60.91,22.29 60.91,22.86 61.86,23.81 U9623.5
LAN_MDI1_DP: length 31
  TOP w0.089: XF3.5 76.15,13.59 75.84,13.27 75.84,11.04 75.08,10.27 67.25,10.27 65.13,12.39 65.13,13.52 63.33,15.32 ; v1(63.11,15.1) 63.33,15.32 ; 63.33,15.32 61.19,17.46 61.19,19.32 U9614.6 61.04,21.06 60.57,21.53 60.57,23 61.52,23.95 61.52,25.02 61.46,25.08 U9623.4
LAN_MDI2_C_DN: length 34.9
  TOP w0.089: XF3.16 72.19,4.32 72.59,3.92 72.59,3.84 v2(72.27,3.52) ; v2(96.47,9.66) 96.47,8.88 96.28,8.69 RJ1.5
  L3 w0.102: v2(96.47,9.66) 96.77,9.36 96.77,6.86 96.07,6.16 73.47,6.16 72.6,5.29 72.6,3.87 72.27,3.54 v2(72.27,3.52)
  BOTTOM w0.089: v3(71.9,3.03) v2(72.27,3.52)
LAN_MDI2_C_DP: length 34.8
  TOP w0.089: v2(97.41,9.66) 97.55,9.53 RJ1.4 ; XF3.17 73.18,4.25 72.94,4 72.94,3.79 v2(73.21,3.52)
  L3 w0.102: v2(97.41,9.66) 97.1,9.36 97.1,6.72 96.21,5.83 73.6,5.83 72.93,5.16 72.93,3.82 73.21,3.54 v2(73.21,3.52)
  BOTTOM w0.089: v3(73.7,3.16) v2(73.21,3.52)
LAN_MDI2_DN: length 24.4
  TOP w0.089: U9623.7 62.66,24.5 62.92,24.25 62.92,23.98 62.66,23.73 62.66,23.4 63.09,22.97 63.09,22.33 U11.3 63.09,22 63.09,21.65 63.72,21.03 63.72,17.92 ; XF3.9 72.19,13.61 72.48,13.32 72.48,12.2 72.14,11.86 71.87,11.86 71.62,12.11 71.36,12.11 71.11,11.86 70.84,11.86 70.59,12.11 70.32,12.11 70.07,11.86 67.84,11.86 66.71,12.99 66.71,14.22 66.52,14.41 66.52,14.77 66.33,14.96 65.97,14.96 64.64,16.29 64.64,16.65 64.45,16.84 64.09,16.84 63.72,17.22 63.72,17.92 ; 63.72,17.92 v1(64.13,17.92)
LAN_MDI2_DP: length 24.4
  TOP w0.089: U9623.6 62.26,24.94 62.32,24.88 62.32,23.25 62.74,22.83 62.74,21.51 63.37,20.88 63.37,20.3 63.25,20.18 U11.4 63.25,18.82 63.37,18.7 63.37,17.07 63.54,16.9 ; XF3.8 73.18,13.59 72.83,13.23 72.83,12.06 72.28,11.52 67.7,11.52 66.36,12.85 66.36,14.08 63.54,16.9 ; 63.54,16.9 v1(63.29,16.65)
LAN_MDI3_C_DN: length 33.6
  TOP w0.089: RJ1.8 92.47,8.56 92.93,9.03 92.93,9.41 v2(92.66,9.69) ; v2(69.3,3.47) 69.62,3.79 69.62,3.9 69.22,4.3 XF3.13
  L3 w0.102: v2(69.3,3.47) 69.63,3.8 69.63,5.24 71.94,7.56 92.22,7.56 92.96,8.3 92.96,9.38 v2(92.66,9.69)
  BOTTOM w0.089: v3(68.8,3.82) v2(69.3,3.47)
LAN_MDI3_C_DP: length 33.5
  TOP w0.089: XF3.14 70.21,4.29 69.97,4.05 69.97,3.74 v2(70.24,3.47) ; RJ1.7 93.74,8.55 93.27,9.01 93.27,9.36 v2(93.6,9.69)
  L3 w0.102: v2(93.6,9.69) 93.29,9.38 93.29,8.16 92.36,7.23 72.08,7.23 69.96,5.11 69.96,3.74 v2(70.24,3.47)
  BOTTOM w0.089: v3(70.58,3.97) v2(70.24,3.47)
LAN_MDI3_DN: length 19.2
  TOP w0.089: 65.74,17.92 65.74,19.37 65.79,19.42 65.79,20.38 65.04,21.14 65.04,22.04 U11.1 65.04,22.28 65.04,23.35 65.29,23.6 65.29,23.87 65.04,24.12 65.04,25.75 64.24,26.55 U9623.10 ; 65.74,17.92 65.74,17.31 66.57,16.48 66.92,16.48 67.11,16.29 67.11,15.94 67.3,15.75 67.66,15.75 67.84,15.56 67.84,15.21 68.13,14.92 68.13,13.31 68.38,13.05 69.29,13.05 69.49,13.25 69.49,13.4 69.22,13.66 XF3.12 ; 65.74,17.92 v1(66.08,17.92)
LAN_MDI3_DP: length 19.3
  TOP w0.089: 65.97,16.59 67.79,14.78 67.79,13.17 68.24,12.71 69.44,12.71 70.21,13.49 XF3.11 ; 65.97,16.59 v1(65.69,16.31) ; 65.97,16.59 65.4,17.17 65.4,19.23 U11.6 65.45,19.76 65.45,20.24 64.69,21 64.69,25.61 64.15,26.14 U9623.9
LAN_RSET: length 7.4
  TOP w0.102: R79742.2 54.74,28.62 55.09,28.97 v1(55.83,28.97) 56.63,28.17 56.63,27.36 57.89,26.1 58.69,26.1 59.14,26.55 U9623.31
LAN_WAKE_N: length 6.5
  TOP w0.102: U9623.21 61.46,30.53 61.54,30.61 61.54,34.65 v1(61.7,34.81) R2281.1
LAN_XTALI: length 12.7
  TOP w0.102: U9623.28 58.19,27.74 57.88,28.05 57.88,30.47 57.98,30.57 v1(57.98,32.12) 57.78,32.32 56.31,32.32 56.07,32.56 C284.1 55.89,32.56 R442.2 52.93,35.52 X3.1
LAN_XTALO: length 16
  TOP w0.102: X3.3 51.13,37.19 51.89,36.44 51.89,34.79 52.27,34.4 52.52,34.4 R442.1 55.5,31.42 C283.1 56.8,31.42 v1(57.24,30.97) 57.24,27.9 57.8,27.35 U9623.29
LANCLK_REQ_U_N: length 11.4
  TOP w0.102: R425.1 69.56,34.34 v1(69.53,34.3) 69.53,33.25 65.94,29.67 65.94,27.95 R79831.1 65.34,27.35 U9623.12
LANWAKE_SMC_WAKE_SCI_N: length 16.6
  TOP w0.089: 153.17,71.8 153.12,71.85 151.59,71.85 U2.BD11
  TOP w0.102: R119.1 164.77,72.84 164.35,72.84 163.99,72.48 163.99,71.58 163.06,70.65 155.72,70.65 v1(155.67,70.6) 155.59,70.52 154.46,70.52 153.17,71.8
LDR: length 5.7
  BOTTOM w0.305: U120.1 13.48,13.47 13.02,13.02 13.02,12.94
  BOTTOM w0.508: R79701.2 10.31,12.38 v3(10.36,12.43) 12.52,12.43 13.02,12.94
LDR_1: length 3.9
  BOTTOM w0.508: 12.26,9.89 11.7,10.45 v3(10.48,10.45) R79701.1
LDRQ#: length 5.7
  TOP w0.102: U109.2 120.04,51.21 121.99,49.26 v1(121.99,48.25) 121.99,47.17 R262.1
LED_5VSB: length 4.1
  TOP w0.254: LED2.A 65.73,49.94 v2(65.93,50.15)
  BOTTOM w0.254: v2(65.93,50.15) 64.97,50.66 v3(64.59,51.04) 65.04,51.5 R515.2
LED_DRIVE: length 8.6
  TOP w0.102: U2.BD36 151.6,84.88 151.63,84.88 151.91,85.15 152.66,85.15 154.32,86.81 154.32,87.74 v1(155.41,88.83) 156.48,89.9 R205.1
LEDC_ISET: length 4.6
  TOP w0.102: v2(19.12,15.1) 18.61,14.59 R79709.1
  BOTTOM w0.102: U120.12 18,15.25 18.74,15.99 v3(19.25,15.99) 19.5,15.73 19.5,15.48 v2(19.12,15.1)
LINE2-VREFO: length 31.5
  TOP w0.203: R404.1 188.47,77.39 v2(188.41,77.46) ; U9.29 182.51,58.44 183.3,57.64 183.84,57.64 184.04,57.44 184.86,57.44 v2(185.29,57.01) ; v2(189.93,72.88) 189.3,73.52 R405.1
  L4 w0.203: v2(188.41,77.46) 189.93,75.93 v2(189.93,72.88) 189.93,72 189.08,71.14 188.89,71.14 185.64,67.9 185.64,66.73 184.55,65.63 184.55,62.6 186,61.15 186,58.62 185.87,58.49 185.87,57.59 v2(185.29,57.01)
  BOTTOM w0.203: v3(185.87,56.43) v2(185.29,57.01)
LINEOUT-JD: length 175.5
  TOP w0.203: LOUT1.Q 102.02,32.96 103.17,31.81 103.17,30.77 104.13,29.81 104.13,26.58 106.8,23.91 106.8,5.04 108.83,3.01 182.06,3.01 183.61,4.56 183.61,12.03 179.44,16.2 179.44,22.13 182.8,25.49 185.59,25.49 187.5,27.39 187.5,27.77 187.5,58.62 R365.1
  BOTTOM w0.203: v3(100.73,32.96) LOUT1.Q
LINEOUT-L: length 166.1
  TOP w0.203: 181.82,48.59 185.76,48.59 186.58,47.76 186.58,27.77 185.21,26.4 182.42,26.4 178.52,22.51 178.52,15.71 182.57,11.67 182.57,4.94 181.55,3.92 109.57,3.92 107.71,5.78 107.71,24.29 105.1,26.91 R421.1 ; 181.82,48.59 v1(181.79,48.56) ; 181.82,48.59 180.95,48.59 178.7,50.84 U9.19
LINEOUT-R: length 170.5
  TOP w0.203: v2(179.9,48.27) 179.9,49 178.25,50.65 178.25,54.79 178.3,54.85 U9.18 ; R422.1 104.02,30.57 104.59,30 104.59,26.77 107.26,24.1 107.26,5.59 109.38,3.47 181.74,3.47 183.15,4.88 183.15,11.84 178.98,16.01 178.98,22.32 182.61,25.94 185.4,25.94 187.04,27.58 187.04,48.45 v1(186.71,48.78) 186.35,49.14 v2(183.03,49.14)
  L3 w0.203: v2(179.9,48.27) 180.76,49.14 v2(183.03,49.14)
LINEOUT_C-L: length 2.5
  TOP w0.203: R421.2 v2(105.1,32.63) L12.1
  BOTTOM w0.203: v2(105.1,32.63) 104.84,32.37 v3(104.84,31.84)
LINEOUT_C-R: length 3
  TOP w0.203: L13.1 103.32,32.82 v2(103.32,32.63) 103.32,32.43 R422.2
  BOTTOM w0.203: v2(103.32,32.63) 103.27,32.68 v3(103.27,33.44)
LINEOUT_CON-L: length 17
  TOP w0.203: LOUT1.4 99.3,37.39 C271.1 102.75,37.39 103.16,37.8 Q17.1 104.15,37.01 105.1,36.05 L12.2
  BOTTOM w0.203: v3(93.07,41.86) LOUT1.4
LINEOUT_CON-R: length 15.1
  TOP w0.203: LOUT1.1 97.26,34.34 L13.2 104.15,34.53 Q17.2 102.97,35.83 C272.1
  BOTTOM w0.203: v3(93.21,31.91) LOUT1.1
LINK_ACTIVITY_N: length 47.6
  TOP w0.203: v2(58.49,28.31) 58.65,28.14 U9623.27
  TOP w0.254: v2(87.06,27.29) 87.06,28.26 v1(87.17,28.36) 87.81,29.01 U9624.4 93.73,29.01 94.43,29.7 98.24,29.7 98.75,29.2 R79829.1
  L4 w0.254: v2(87.06,27.29) 87.06,27.93 84.58,30.42 78.22,30.42 77.98,30.65 77.98,30.65 77.68,30.95 70.96,30.95 70.96,30.95 64.54,30.95 62.98,29.39 61.1,29.39 60.25,28.54 58.72,28.54 v2(58.49,28.31)
LINK_PWR: length 10.6
  TOP w0.508: RJ1.9 103.07,20.75 103.07,25.77 101.99,26.85 R79618.2
  BOTTOM w0.254: v3(103.56,19.04) RJ1.9
LPC_0_ESPI_CLK_EC: length 6.4
  TOP w0.102: R1807.1 156.77,74.92 155.89,74.92 155.69,75.12 v1(154.76,75.12) 154.04,75.12 153.76,74.84 151.71,74.84 151.6,74.74 151.18,74.74 U2.BC17
LPC_CLK: length 83.1
  TOP w0.102: v2(113.37,66.15) U109.44
  L4 w0.127: LPC1.1 139.79,56.87 138.93,57.72 127.32,57.72 127.32,57.71 125.65,57.71 124.07,59.29 123.59,59.29 122.12,60.76 121.34,60.76 121.16,60.93 121.16,60.94 120.89,61.21 120.88,61.21 120.77,61.33 120.08,61.33 118.56,62.85 118.56,63.39 117.19,64.76 114.77,64.76 v2(113.37,66.15)
  BOTTOM w0.102: R1983.2 155.05,76.03 156.32,76.03 156.84,76.55 160.45,76.55 162.26,74.75 v3(162.26,74.31) 162.26,73.74 165.17,70.83 165.17,62.22 164.53,61.58 164.53,61.58 163.24,60.29 163,60.29 162.47,59.75 162.1,59.75 161.8,59.46 161.8,59.11 161.51,58.81 150.56,58.81 148.22,56.48 147.06,56.48 146.58,55.99 144.73,55.99 144.13,55.38 142.08,55.38 140.95,56.51 140.92,56.51 LPC1.1
LPC_PIRQ_PU: length 26.6
  TOP w0.102: U2.AW17 149.24,75.42 v5(149.24,75.43) ; v2(166.03,79.69) 165.96,79.62 R203.2
  L3 w0.127: v5(149.24,75.43) 149.29,75.43 149.8,74.92 151.2,74.92 151.96,74.15 154.76,74.15 156.41,72.5 156.41,71.84 156.87,71.37 158,71.37 158.37,71.75 158.37,75.36 160.18,77.16 161.1,77.16 162.95,79.02 163.59,79.02 164.26,79.69 v2(166.03,79.69)
  BOTTOM w0.102: v3(165.22,79.69) v2(166.03,79.69)
LPC_PME#: length 246.1
  TOP w0.102: R79837.2 98.37,61.84 98.11,62.09 98.11,65.08 95.66,67.53 95.66,69.06 v2(95.76,69.16) ; v2(167,77.32) 166.71,77.61 166.38,77.61 165.61,78.38 165.61,78.46 165.53,78.54 R79796.1
  L3 w0.127: v2(34.49,19.29) 34.49,29.73 35.33,30.58 35.47,30.58 38.35,33.46 38.35,45.87 41.13,48.65 41.13,49.84 42.5,51.21 50.29,51.21 51.02,50.48 64.94,50.48 65.74,49.68 66.13,49.68 66.16,49.71 79.11,49.71 79.92,50.52 81.06,50.52 85.87,55.33 87.91,55.33 88.74,56.17 91.13,56.17 91.91,56.94 91.91,57.84 92.49,58.43 92.49,59.53 95.84,62.88 95.84,65.07 95.76,65.15 v2(95.76,69.16)
  L4 w0.127: v2(95.76,69.16) 97.69,69.16 98.38,68.48 99.26,68.48 99.95,67.79 105.05,67.79 107.63,65.21 108.78,65.21 109.5,64.49 109.5,62.68 111.28,60.9 111.28,59.94 111.56,59.67 112.15,59.67 114.26,57.56 114.92,57.56 115.19,57.28 115.19,56.43 118.04,53.58 125.04,53.58 125.19,53.43 126.42,53.43 127.51,52.34 147.12,52.34 147.64,52.85 150.51,52.85 150.63,52.73 151.71,52.73 153.11,54.13 154.35,54.13 154.89,54.67 154.89,55.51 155.57,56.18 162.89,56.18 163.02,56.05 165.25,56.05 165.39,56.19 v2(166.1,56.19)
  BOTTOM w0.102: v2(34.49,19.29) 34.87,18.91 43.05,18.91 44.68,17.28 49.7,17.28 51.88,15.1 R79838.2 R9556.1 ; v2(166.1,56.19) 166.39,56.48 167.5,56.48 169.89,58.87 169.89,60.33 170.96,61.4 170.96,71.23 171.6,71.87 171.6,75.86 v3(171.09,76.36) 170.17,77.28 167.03,77.28 v2(167,77.32)
LPC_PME_N: length 5.4
  TOP w0.102: R79837.1 R253.2 100.44,62.85 100.45,62.84 100.54,62.84 v1(101.1,62.28) 101.39,62.28 102.41,61.25 102.89,61.25 102.93,61.21 U109.70
LPCPD_N: length 12.7
  TOP w0.102: U2.BC18 151.02,75.25 153.47,75.25 154.17,75.96 156.33,75.96 v1(156.37,76) 157.36,76 157.68,75.68 158.31,75.68 158.75,76.12 159.12,76.12 160.44,77.44 160.44,77.82 160.84,78.22 R1922.2
LPF: length 4.5
  BOTTOM w0.102: C12233.1 16.77,19.54 17.21,19.54 v3(17.47,19.29) 17.47,19.04 16.51,18.08 16.51,17.73 15.94,17.15 U120.9
LPSS_GSPI0_CLK: length 3.1
  TOP w0.102: v5(149.32,79.04) 149.24,79.12 U2.AW27
  BOTTOM w0.102: v5(149.32,79.04) 150.02,79.74 150.46,79.74 150.72,79.99 150.72,80.01 TP176.1
LPSS_GSPI0_CS_N: length 5.4
  TOP w0.102: v2(147.49,77.89) 147.49,78.04 147.02,78.52 U2.AR24
  BOTTOM w0.102: v2(147.49,77.89) 147.49,77.63 147.52,77.6 147.52,77.56 147.95,77.13 151.38,77.13 TP175.1
LPSS_GSPI0_MISO: length 7.4
  TOP w0.102: TP174.1 156.88,81.47 156.65,81.24 156.63,81.24 155.55,80.16 154.23,80.16 153.79,79.72 152.75,79.72 152.57,79.89 151.74,79.89 151.69,79.94 151.68,79.94 151.6,80.03 U2.BD27
LPSS_GSPI0_MOSI: length 10.2
  TOP w0.102: U2.BD28 151.62,80.38 152.57,80.38 152.77,80.58 153.36,80.58 153.55,80.39 155.45,80.39 155.82,80.76 155.82,81.84 156.09,82.1 156.29,82.1 156.56,82.37 156.56,82.88 R218.2 157.36,83.68 158.11,83.68 v1(158.12,83.67) 158.12,82.7 R79875.1
LPSS_GSPI1_CS_N: length 6.8
  TOP w0.102: TP172.1 156.46,80.63 156.15,80.33 156.04,80.33 155.64,79.93 154.29,79.93 153.87,79.51 152.66,79.51 152.49,79.69 151.65,79.69 151.6,79.74 151.21,79.74 150.92,80.03 U2.BC27
LPSS_GSPI1_MISO: length 1.8
  TOP w0.102: v5(146.47,80.3) 146.47,80.42 U2.AR29
  BOTTOM w0.102: TP171.1 145.99,81.23 146.47,80.76 v5(146.47,80.3)
LPSS_GSPI1_MOSI: length 17.9
  TOP w0.102: U2.AT29 147.61,80.71 147.18,80.28 147.15,80.28 v5(147.15,80.28)
  BOTTOM w0.102: v5(147.15,80.28) 147.07,80.28 146.78,80.56 146.78,81.37 146.2,81.95 146.19,81.95 145.94,82.2 145.94,83.36 146.55,83.97 146.55,84.15 146.8,84.4 147.03,84.4 147.68,85.05 147.68,86.66 147.47,86.87 147.47,88.68 v3(147.24,88.9) 147.24,88.91 147.34,89.01 147.34,90.75 147.75,91.16 147.75,93.54 R222.2 R223.1
LVDS_BL_ADJ: length 7.8
  TOP w0.165: R79717.1 R79723.2 6.27,16.39 v2(6.8,15.86)
  BOTTOM w0.165: v2(6.8,15.86) 8.07,15.86 8.32,16.12 8.32,16.43 R79721.1 8.9,18.15 v3(8.39,18.66) 8.39,19.75 R134.2
LVDS_DET_A*: length 130.5
  TOP w0.102: U109.116 112.97,48.5 113.61,47.87 115.32,47.87 116.15,47.03 116.15,44.23 115.89,43.97 115.89,41.68 115.61,41.4 114.7,41.4 114.13,41.97 109.34,41.97 108.65,41.29 107.1,41.29 v2(105.78,39.97) ; v2(20.77,43.8) 21.02,43.55 21.02,41.92 21.45,41.5 LVDS1.17
  L4 w0.127: v2(105.78,39.97) 106.31,40.49 106.31,42.06 102.96,45.41 75.8,45.41 75.77,45.45 65.26,45.45 65.23,45.41 63.93,45.41 61.02,48.32 v2(53.16,48.32)
  BOTTOM w0.102: 25.6,45.33 25.22,44.94 23.8,44.94 23.31,45.43 23.31,48.26 25.52,50.47 26.42,50.47 26.82,50.86 27.46,50.86 28.2,51.6 28.2,52.12 28.67,52.59 31.29,52.59 v3(32.07,51.8) 32.94,52.67 33.77,52.67 34.83,53.73 41.83,53.73 42.24,53.33 43.88,53.33 46.2,51.01 46.2,50.17 47.26,49.11 51.3,49.11 51.9,48.51 51.9,48.15 52.16,47.88 52.71,47.88 v2(53.16,48.32) ; 25.6,45.33 R79730.2 ; 25.6,45.33 25.6,44.82 24.07,43.29 21.28,43.29 v2(20.77,43.8)
