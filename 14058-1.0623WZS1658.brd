# Allegro board 14058-1.0623WZS1658.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SLP_S4_N_C: length 4.8
  TOP w0.102: R297.1 99.9,58.61 100.01,58.61 101.45,60.06 101.72,60.06 v1(101.75,60.08) 102.54,60.08 103.02,59.61 U109.74
SLP_S4_N_CN: length 1.4
  TOP w0.102: R1784.2 164.42,75.42 TP221.1
SLP_S4_N_R: length 5.4
  BOTTOM w0.102: v3(159.58,207.15) 159.58,207.86 160.05,208.33 R1953.2 R1958.2 C12168.1 161.68,206.87 U171.2
SLP_S4_N_SFR: length 6.1
  TOP w0.102: R1683.2 41.66,154.04 v1(41.66,155.13) 41.45,155.34 C12060.1 39.73,155.34 39.28,155.79 37.98,155.79 37.79,155.59 Q1233.2
SLP_S4_N_SFR_1: length 7.4
  TOP w0.102: Q1233.5 37.79,153.91 37.92,154.04 38.32,154.04 38.42,153.94 38.42,153.24 Q1233.6 38.44,152.37 38.68,152.13 40.12,152.13 v1(40.25,152.01) 40.33,152.01 40.46,151.88 R1990.1 R1988.2
SLP_S4_N_SFR_2: length 20.9
  TOP w0.102: v2(39.57,156.2) 39.52,156.15 37.84,156.15 37.14,155.45 Q1233.3 ; R1992.1 R1989.2 43.25,149.66 R1991.1 44.2,149.66 v1(44.65,150.1) 45.15,150.1 v2(45.99,149.26)
  L3 w0.127: v2(45.99,149.26) 45.7,149.55 45.7,149.88 46.55,150.73 46.55,151.72 44.84,153.43 41.98,153.43 39.57,155.84 v2(39.57,156.2)
SLP_S4_N_SFR_G: length 7.8
  TOP w0.102: R1992.2 39.63,151.12 v1(38.93,151.12) 38.73,151.32 C12059.1 C12058.1 35.88,149.92 Q1234.G
SLP_S4_N_SIO: length 3.9
  TOP w0.102: R297.2 98.11,58.53 R1950.2 ; v1(97.78,60.33) 97.78,60.33 97.86,60.25 R1950.2 ; R1950.2 R1951.1
SLP_S5_N: length 80.1
  TOP w0.102: v2(148.84,72.27) 149,72.27 149.49,72.76 U2.BA13 ; R1950.1 96.84,58.91 96.84,60.05 97.05,60.25 97.05,60.62 97.76,61.33 97.76,64.94 95.31,67.39 95.31,69.6 95.43,69.72 95.43,69.8 98.85,73.21 99.81,73.21 v2(100.27,72.76)
  BOTTOM w0.102: v2(100.27,72.76) 101.03,72 104.83,72 105.46,71.37 v3(112.59,71.37) 114.37,71.37 114.7,71.04 114.7,70.98 118.13,67.55 121.84,67.55 124.4,64.98 124.57,64.98 127.14,62.42 134.4,62.42 134.76,62.77 137.94,62.77 138.17,63 144.49,63 146.69,65.2 146.69,67.58 147.14,68.02 147.14,69.71 147.39,69.96 147.39,71.01 148.16,71.78 148.34,71.78 v2(148.84,72.27)
SLP_SUSB: length 237.6
  TOP w0.102: U109.3 118.5,51.61 118.35,51.76 117.19,51.76 v2(116.93,51.5) 115.52,52.92 114.85,52.92 114.48,53.29 114.48,54.8 v2(116.56,56.87) ; U2.BB13 150.46,72.78 150.84,72.4 151.05,72.4 151.14,72.31 152.02,72.31 152.07,72.25 153.3,72.25 154.07,71.49 154.98,71.49 155.31,71.16 155.9,71.16 156.03,71.03 159.88,71.03 160.35,71.5 v2(160.58,71.5) ; v2(152.98,122.41) 152.6,122.8 R1947.1
  L3 w0.127: v2(109.29,21.7) 116.02,28.43 116.02,29.07 116.03,29.08 116.03,31.21 119.32,34.5 119.32,39.13 116.48,41.97 116.48,46.41 116.38,46.52 116.38,50.81 116.93,51.37 v2(116.93,51.5)
  L4 w0.127: v2(152.98,122.41) 152.98,120.38 151.07,118.48 151.07,112.02 151.87,111.22 151.87,109.28 158.22,102.93 158.38,102.93 164.88,96.43 164.88,92.6 162.84,90.57 162.84,87.65 163.47,87.03 163.47,81.01 159.73,77.27 159.73,74.7 159.3,74.28 157.7,74.28 156.52,73.1 156.52,71.72 156.87,71.37 160.45,71.37 v2(160.58,71.5)
  BOTTOM w0.102: v2(160.58,71.5) 161.85,71.5 162.1,71.26 v3(162.11,71.26) 163.83,69.54 163.83,62.78 162.68,61.63 162.44,61.63 162.01,61.2 161.42,61.2 161.29,61.07 154.12,61.07 153.85,61.34 148.01,61.34 144.92,58.25 143.37,58.25 142.89,57.77 142.09,57.77 141.3,58.57 132.65,58.57 131.78,57.7 128.21,57.7 125.23,54.72 119.27,54.72 117.46,56.53 116.9,56.53 v2(116.56,56.87) ; v2(109.29,21.7) 108.15,21.7 101.03,28.82 90.24,28.82 87.7,31.36 87.7,35.42 88.38,36.1 88.38,42.09 84.77,45.71 79.32,45.71 78.87,46.15 R80220.1 R513.1
SLP_SUSB_C: length 23.5
  BOTTOM w0.102: Q9634.C 83.19,49.83 v3(81.86,51.17) 80.97,52.06 R80221.1 80.78,56.31 81.35,56.88 81.35,59.82 81.94,60.41 88.74,60.41 90.11,59.04 R80222.1
SLP_SUSB_R: length 6.1
  BOTTOM w0.102: R80219.1 R80218.1 79.76,48.75 R80220.2 79.76,46.53 v3(79.83,46.47) 81.1,46.47 81.29,46.66 Q9634.B
SLP_WLAN_N: length 217.5
  TOP w0.102: v2(167.86,80.07) 167.99,79.95 167.99,74.43 167.26,73.71 R123.1 ; v2(148.07,72.21) 148.29,72.43 U2.AV13 ; v2(151.45,234.81) 151.05,234.81 v1(150.61,235.24) 150.56,235.29 R729.1
  L3 w0.127: v2(151.45,234.81) 151.45,234.53 154.73,231.25 164.94,231.25 178.88,217.32 178.88,157.33 177.81,156.26 177.81,131.75 178.75,130.81 178.75,114.75 179.77,113.72 179.77,112.41 181.36,110.82 181.36,107.18 181.06,106.88 181.06,103.61 181.64,103.03 181.64,100.14 173.3,91.79 173.3,88 167.84,82.54 167.84,81.77 167.46,81.39 167.46,80.48 v2(167.86,80.07) 167.86,80.02 166.06,78.22 164.22,78.22 164.01,78 163.54,78 162.63,77.09 162.63,75.97 160.85,74.19 160.85,72.44 160.11,71.7 160.11,70.62 159.34,69.85 156.05,69.85 155.42,70.47 154.68,70.47 153.63,71.52 150.4,71.52 150.18,71.74 148.54,71.74 v2(148.07,72.21)
SMB0_CVT_CLK: length 4.8
  TOP w0.102: v2(14.44,18.22) 14.44,18.42 14.67,18.66 C12231.1 R79690.2 12.58,19.23 v1(12.52,19.29)
  BOTTOM w0.102: v2(14.44,18.22) U120.6
SMB0_CVT_DATA: length 4.8
  TOP w0.102: v2(15.19,18.13) 15.56,18.5 C12232.1 R79691.2 v1(17.6,19.23)
  BOTTOM w0.102: U120.7 14.93,17.87 v2(15.19,18.13)
SMB_CLK_MAIN: length 422.3
  TOP w0.102: v2(52.05,19.03) 52.05,19.76 51.94,19.87 Q9501.1 ; Q4.S 149.34,96.43 150.47,96.43 150.74,96.69 150.74,96.97 151.29,97.53 151.34,97.53 151.39,97.58 R133.2 151.48,98.03 151.94,97.57 152.35,97.57 v2(152.87,97.05) ; v2(38.48,120.14) 38.68,120.14 39.51,119.32 39.51,118.94 37.78,117.21 36.42,117.21 34.77,115.56 33.6,115.56 33.22,115.18 U6701.4 ; v2(117.93,124.45) 118.31,124.07 134.09,124.07 138.53,128.5 146.04,128.5 151.07,133.53 151.07,135.04 151.98,135.95 DIMM1.202 157.39,135.95 159.65,133.69 162.29,133.69 164.55,135.95 DIMM2.202 169.45,135.95 170.5,134.89 170.5,132.22 v2(176.5,126.22)
  L3 w0.127: v2(117.93,124.45) 116.85,125.52 115.11,125.52 106.73,133.91 92.62,133.91 91.98,133.27 82.22,133.27 80.14,135.36 77.46,135.36 75.25,133.15 75.25,132.19 74.3,131.24 70.62,131.24 69.96,130.58 63.68,130.58 62.16,132.1 47.21,132.1 47.08,131.97 45.59,131.97 45.57,131.99 44.54,131.99 40.16,127.61 40.16,120.93 39.37,120.14 v2(38.48,120.14) ; v2(152.87,97.05) 161.29,97.05 163.14,95.21 168.9,95.21 170.45,96.76 175.05,96.76 176.84,98.55 176.84,102.16 177.22,102.54 177.22,108.66 177.3,108.73 177.3,113.14 176.59,113.85 176.59,126.14 v2(176.5,126.22)
  L4 w0.127: v2(54.65,58.96) 54.65,58.99 53.93,59.71 37.32,59.71 25,72.04 25,82.91 29.36,87.26 29.36,102.49 29.24,102.6 29.24,106.22 29.62,106.6 29.62,114.64 35.78,120.8 37.8,120.8 38.46,120.14 v2(38.48,120.14) ; v2(117.93,124.45) 117.8,124.32 103.45,124.32 102,122.87 v2(99.76,122.87)
  BOTTOM w0.102: v2(99.76,122.87) 99.36,122.46 99.36,121.39 95.42,117.46 95.42,109.53 93.69,107.81 93.69,105.83 93.34,105.47 92.66,105.47 R632.2 ; v2(54.65,58.96) v3(54.65,56.5) 54.65,48.65 51.91,45.91 51.91,41.15 51.19,40.42 51.17,40.42 50.51,39.76 48.78,39.76 48.12,39.1 48.12,33.72 48.89,32.96 48.89,29.56 47.8,28.47 47.8,23.28 v2(52.05,19.03) ; XDPC1.53 41.15,122.51 40.46,121.81 40.46,120.74 39.78,120.06 38.56,120.06 v2(38.48,120.14)
SMB_CLK_RESUME: length 213.8
  TOP w0.102: v2(147.67,99.24) 147.67,99.24 148.04,99.6 148.96,99.6 149.23,99.34 R1837.2 C146.1 149.23,97.83 148.77,97.36 148.77,95.92 148.99,95.69 149.52,95.69 150.31,94.91 Q4.D 150.31,93.21 v1(150.88,92.63) 150.88,91.54 149.21,89.86 149.21,88.53 149,88.33 U2.AW44 ; v2(139.26,244.08) 138.62,244.73 R702.1
  L3 w0.127: v2(139.26,244.08) 139.05,243.86 139.05,241 151.83,228.22 162.96,228.22 174.4,216.78 174.4,159.59 174.1,159.28 174.1,131.77 175.24,130.63 175.24,113.58 175.49,113.33 175.49,102.7 175.7,102.5 175.7,100.35 173.47,98.13 162.42,98.13 161.02,99.53 156.82,99.53 155.66,100.7 154.25,100.7 153.49,101.46 150.44,101.46 149.55,100.57 148.91,100.57 147.67,99.34 v2(147.67,99.24)
SMB_DATA_MAIN: length 414.2
  TOP w0.102: v2(37.91,119.23) 36.71,119.23 35.76,118.27 35.76,117.08 34.97,116.29 32.56,116.29 32.07,115.81 32.07,114.64 32.44,114.28 U6701.6 ; v2(176.47,127.43) 175.79,127.43 170.86,132.37 170.86,135.04 169.35,136.55 DIMM2.200 167.7,136.55 167.46,136.31 164.37,136.31 162.12,134.05 159.8,134.05 157.3,136.55 DIMM1.200 152.08,136.55 150.64,135.11 150.64,133.6 145.9,128.85 138.38,128.85 133.95,124.42 118.6,124.42 118.11,124.9 115.72,124.9 v2(115.64,124.83) ; Q9501.4 50.06,21.52 50.05,21.52 49.04,22.53 49.04,24.98 49.2,25.15 49.2,26.36 49.49,26.65 49.7,26.85 49.7,28.07 49.75,28.12 49.75,29.34 50.26,29.85 v2(50.26,30.64)
  L3 w0.127: v2(115.64,124.83) 115.27,124.83 106.57,133.53 92.78,133.53 92.14,132.89 82.07,132.89 79.98,134.97 77.62,134.97 75.63,132.99 75.63,132.04 73.8,130.2 62.32,130.2 60.8,131.72 47.37,131.72 40.54,124.9 40.54,120.78 39.44,119.67 38.35,119.67 v2(37.91,119.23) ; v2(153.21,96.33) 161.26,96.33 162.76,94.83 169.21,94.83 170.76,96.38 175.21,96.38 177.51,98.68 177.51,102.29 177.6,102.38 177.6,108.5 177.68,108.57 177.68,113.3 176.97,114.01 176.97,126.94 v2(176.47,127.43)
  L4 w0.127: v2(101.92,123.68) 102.94,124.7 115.51,124.7 v2(115.64,124.83) ; v2(37.91,119.23) 37.69,119.45 34.97,119.45 30,114.49 30,106.44 29.62,106.06 29.62,102.76 29.74,102.65 29.74,87.1 25.38,82.75 25.38,72.2 37.48,60.1 54.84,60.1 55.95,58.99 v2(55.95,58.96)
  BOTTOM w0.102: v2(37.91,119.23) 37.91,120.21 38.3,120.6 38.84,120.6 39.02,120.42 39.63,120.42 40.07,120.86 40.07,122.15 40.93,123.01 XDPC1.51 ; v2(101.92,123.68) 101.92,123.46 95.78,117.31 95.78,109.39 94.63,108.24 94.63,106.41 R79992.2 ; Q1.S 151.33,96.47 151.33,97.97 R124.2 151.39,97.97 151.88,97.47 151.88,96.83 152.39,96.33 v2(153.21,96.33) ; v2(50.26,30.64) 49.6,31.31 49.6,32.75 48.48,33.87 48.48,38.95 48.88,39.36 50.6,39.36 51.31,40.07 51.33,40.07 52.27,41 52.27,45.76 55.95,49.44 v3(55.95,52.28) v2(55.95,58.96)
SMB_DATA_RESUME: length 215.7
  TOP w0.102: v2(150.84,87.59) 150.73,87.71 U2.BB43 ; v2(140.19,244.08) 140.19,243.7 139.93,243.45 139.9,243.45 v1(139.77,243.32) 139.52,243.57 139.01,243.57 138.87,243.71 R704.1
  L3 w0.127: v2(148.43,99.15) 148.52,99.15 149.56,100.19 149.71,100.19 150.6,101.08 153.33,101.08 154.09,100.32 155.5,100.32 156.67,99.15 160.87,99.15 162.26,97.75 162.58,97.75 173.63,97.75 176.08,100.2 176.08,102.65 175.88,102.86 175.88,113.48 175.62,113.74 175.62,130.8 174.48,131.94 174.48,159.12 175.67,160.32 175.67,216.05 163.12,228.6 151.98,228.6 140.19,240.39 v2(140.19,244.08)
  BOTTOM w0.102: v2(148.43,99.15) 148.52,99.15 148.62,99.05 149.23,99.05 R1838.2 149.26,97.85 C145.1 149.23,97.46 148.6,96.82 148.6,96.09 149.03,95.66 149.49,95.66 150.03,95.11 150.03,94.82 Q1.D 151.44,94.54 151.63,94.35 151.63,91.66 151.3,91.33 151.3,88.87 151.2,88.77 151.2,87.95 v2(150.84,87.59)
SMBALERT#: length 221.4
  TOP w0.102: R701.1 138.44,246.24 139.52,246.24 v1(139.77,246.49) 140.02,246.24 v2(140.02,245.49) ; U2.BB41 150.4,87.24 149.32,87.24 v2(148.91,87.65)
  L3 w0.127: v2(140.02,245.49) 140.19,245.32 140.19,245.12 140.91,244.4 140.91,240.21 152.14,228.98 163.28,228.98 176.05,216.21 176.05,159.23 174.86,158.04 174.86,132.15 176,131.01 176,113.9 176.26,113.64 176.26,103.02 176.46,102.81 176.46,98.71 174.89,97.14 170.29,97.14 168.74,95.59 163.47,95.59 160.4,98.66 153,98.66 151.96,99.69 150.3,99.69 149.08,98.48 v2(147.83,98.48)
  BOTTOM w0.102: v2(148.91,87.65) 149.01,87.65 149.39,87.26 149.83,87.26 150.97,88.4 150.97,88.82 151.05,88.9 151.05,91.07 150.95,91.17 150.95,91.74 R227.1 150.75,92.19 150.5,92.19 R1794.2 149.93,93.71 149.68,93.97 149.68,94.96 149.34,95.3 148.88,95.3 148.02,96.16 148.02,97.66 147.92,97.76 147.92,98.38 v2(147.83,98.48)
SMBUS_ISP: length 124
  TOP w0.102: v2(49.57,30.26) 49.4,30.09 49.4,28.27 49.35,28.22 49.35,27 49.06,26.71 48.85,26.51 48.85,25.29 48.68,25.13 48.68,22.38 49.32,21.74 49.32,21.09 49.73,20.69 Q9501.5 Q9501.2 52.27,20.69 52.65,20.31 52.65,19.04 52.84,18.85 R9557.2 53.85,18.85 54.35,18.35 54.35,16.95 ; U109.115 112.57,49.98 112.31,50.25 112.29,50.25 111.78,50.76 v2(111.12,50.76) ; 54.35,16.95 R9563.1 ; 54.35,16.95 52.93,16.95 52.25,17.64 Q9502.5 Q9502.2
  L4 w0.127: v2(111.12,50.76) 110.81,51.06 110.81,53.02 109.62,54.22 108.16,54.22 107.38,54.99 105.55,54.99 102.53,58.01 93.46,58.01 91.88,59.59 89.81,59.59 89.61,59.4 83.91,59.4 82.71,60.6 74.78,60.6 74.24,60.06 58.16,60.06 v2(57.09,58.99)
  BOTTOM w0.102: R257.2 112.39,48.84 C182.1 111.12,50.11 111.12,50.76 v2(111.12,50.76) ; v2(49.57,30.26) 49.65,30.19 50.45,30.19 50.72,30.45 50.72,31.41 50.56,31.56 50.56,32.92 51.17,33.53 53.55,33.53 54.5,34.48 54.5,39.86 52.62,41.74 52.62,45.61 56.36,49.35 57.1,50.09 v3(57.1,53.86) 57.09,53.87 v2(57.09,58.99)
SML0ALERT#: length 8
  TOP w0.102: U2.BA40 149.99,86.43 v5(150.26,86.7)
  BOTTOM w0.102: R221.2 148.28,90.98 R224.1 148.81,90.45 148.81,88.96 148.02,88.17 v3(148.02,87.19) 148.38,87.19 148.51,87.06 149.9,87.06 v5(150.26,86.7)
SMLICLK_PCH: length 10
  TOP w0.102: U2.AW42 148.59,86.8 148.59,86.61 v2(148.56,86.57)
  BOTTOM w0.102: v2(148.56,86.57) 148.66,86.68 149.6,86.68 149.98,86.3 150.56,86.3 v3(151.05,86.78) 151.4,87.13 151.4,88.04 151.41,88.06 151.41,88.69 151.55,88.83 151.55,90.81 151.71,90.96 151.71,91.24 C142.2 R79740.1
SMLIDATA_PCH: length 10.5
  TOP w0.102: U2.AW45 148.95,88.8 149,88.85 149,89.94 149.6,90.54 v1(149.6,92.33) 149.6,94.64 149.61,94.65 149.61,95.03 149.31,95.34 148.84,95.34 147.55,96.63 C144.2 147.45,97.59 R79741.1
SMLINK0_CLK: length 3.9
  TOP w0.102: U2.AY44 149.76,87.8 v2(149.65,87.7)
  BOTTOM w0.102: v2(149.65,87.7) 149.65,88.09 C140.2 150.54,88.97 v3(150.54,89.52) 150.63,89.61 R104.1
SMLINK0_DATA: length 14.8
  TOP w0.102: U2.BB39 150.33,86.05 150.14,85.86 v2(149.95,85.86)
  BOTTOM w0.102: R105.1 156.86,92.82 156.99,92.69 v3(156.99,91.93) 156.86,91.81 C141.2 155.71,91.36 155.39,91.05 152.14,91.05 151.76,90.67 151.76,88.75 151.62,88.61 151.62,87.97 151.61,87.96 151.61,86.59 151.02,86.01 150.1,86.01 v2(149.95,85.86)
SO_1: length 5.6
  TOP w0.102: U9501.2 56.08,9 55.44,9.64 55.44,10.65 55.82,11.04 55.82,11.8 v1(55.77,11.85) 55.7,11.77 55.52,11.77 54.62,10.87 R9506.2
SP1: length 3.5
  BOTTOM w0.089: v3(192.42,145.32) 192.68,145.07 ; 192.68,145.07 191.99,144.38 U14.15 ; 192.68,145.07 193.21,145.6 193.21,146.11 R79844.1
SP2: length 4.4
  BOTTOM w0.089: U14.16 192.39,144.3 193.55,145.46 193.55,145.91 R79845.1 194.61,146.39 v3(195,146.77)
SP3: length 3.7
  BOTTOM w0.102: U14.17 193.08,144.1 194.16,145.18 v3(194.16,145.32) 194.24,145.4 R79846.1
SP4: length 3.4
  BOTTOM w0.102: R79847.1 195.4,143.37 v3(195.14,143.12) 194.89,142.86 194.2,142.86 193.68,142.34 U14.19
SP5: length 3.1
  BOTTOM w0.102: R79848.1 v3(194.35,142.1) 194.19,141.94 U14.20
SP6: length 3.3
  BOTTOM w0.102: U14.21 194.68,141.54 v3(195.14,141.08) 195.27,140.96 R79849.1
SP7: length 3.4
  BOTTOM w0.102: U14.29 190.79,138.45 v3(190.01,137.67) 189.88,137.55 R79851.1
SP_PLLVDD: length 8.9
  TOP w0.305: GPU1.M6 87.74,109.32 88.08,109.66 v5(88.13,109.66)
  BOTTOM w0.508: v5(88.13,109.66) 88.13,110.12 v3(89.25,111.24) 89.25,111.56 C469.1 C463.1 91.95,112.17 C467.1 C468.2 94.56,112.23 L28.2
SPDIF_IC: length 201.9
  TOP w0.102: U9.16 177.5,54.66 v1(177.03,54.19) 176.6,53.76 v2(176.6,53.07) ; SCA1.68 32.45,45.45 34.18,43.72 38.6,43.72 v2(40.95,46.07)
  L3 w0.127: v2(176.6,53.07) 176.6,52.69 174.4,50.49 171.43,50.49 169.17,48.23 169.17,43.99 163.39,38.21 163.39,27.94 165.31,26.02 165.31,19.54 163.66,17.89 v2(163.39,17.89)
  L4 w0.127: v2(40.95,46.07) 41.02,46.07 41.27,46.32 46.5,46.32 48.18,47.99 49.33,47.99 49.58,47.99 50.39,48.8 60.9,48.8 64.03,45.67 65.12,45.67 65.15,45.7 75.87,45.7 75.91,45.67 103.06,45.67 106.61,42.12 106.61,41.36 107.97,40 107.97,39.36 112.26,35.07 112.26,32.17 117.29,27.14 121.55,27.14 122.86,25.83 125.19,25.83 126.29,24.73 134.77,24.73 139.53,19.96 144.44,19.96 145.54,18.87 148.16,18.87 150.75,16.28 162.07,16.28 163.39,17.61 v2(163.39,17.89)
SPEAKER1_L1: length 5.8
  TOP w0.203: v2(175.2,47.23) 174.64,47.79 C241.1 174.2,47.67 R79812.2 175.13,45.59 U9615.3
  BOTTOM w0.203: v3(175.2,46.42) v2(175.2,47.23)
SPEAKER1_R1: length 21.3
  TOP w0.203: U9615.9 181.39,46.09 R79813.2 182.53,47.7 182.82,47.99 185.21,47.99 186,47.2 186,44.87 185.97,44.84 v1(185.97,44.58) 185.97,42.73 185.54,42.3 184.52,42.3 184.35,42.48 182.03,42.48 180.36,40.8 180.36,40.04 181.3,39.1 181.3,38.34 C234.1
SPEED_100*_CON: length 5.2
  TOP w0.254: RJ1.12 89.6,20.92 UR6.2
  BOTTOM w0.254: v3(90.27,19.04) RJ1.12
SPEED_100_N: length 45.8
  TOP w0.203: v2(58.36,29.07) 58.54,29.07 59.06,28.55 U9623.26
  TOP w0.254: v2(90.75,25.61) 90.87,25.49 91.36,25.49 92.83,26.96 U9624.6 92.13,27.1 91.72,26.69 91.7,26.69 91.67,26.66 89.46,26.66 v1(89.17,26.36) 89.17,25.25 UR6.1
  L4 w0.254: v2(58.36,29.07) 58.49,28.94 60.08,28.94 60.93,29.79 62.81,29.79 64.37,31.36 71.12,31.36 71.13,31.36 77.85,31.36 78.15,31.06 78.39,30.82 84.75,30.82 89.96,25.61 v2(90.75,25.61)
SPEED_1000*_CON: length 5.6
  TOP w0.254: UR7.2 90.75,22.07 RJ1.11
  BOTTOM w0.254: v3(92.56,19.04) RJ1.11
SPEED_1000_N: length 52.1
  TOP w0.203: U9623.25 59.25,28.95 58.97,29.22 v2(58.97,29.58)
  TOP w0.254: v2(94.51,26) 94.51,25.96 96.64,25.96 97.59,26.91 97.59,27.32 v1(97.52,27.39) 97.45,27.46 96.51,27.46 96.14,27.1 U9624.1 94.37,27.1 93.03,25.77 92.27,25.77 91.32,24.81 UR7.1
  L4 w0.254: v2(94.51,26) 94.51,25.96 94.26,26.2 90.41,26.2 89.95,26.2 84.92,31.23 78.56,31.23 78.02,31.76 71.29,31.76 71.29,31.76 64.2,31.76 62.64,30.2 60.76,30.2 59.91,29.35 59.2,29.35 v2(58.97,29.58)
SPI_CLK: length 33
  TOP w0.102: R352.2 169.87,89.84 v2(169.87,87.62) ; U2.BC31 151.06,81.79 151.35,81.49 153.94,81.49 154.43,81.98 154.87,81.98 155.29,82.4 v2(155.35,82.4)
  BOTTOM w0.102: v2(169.87,87.62) 169,87.62 168.9,87.51 168.9,86.04 168.8,85.94 168.52,85.94 168.41,86.04 168.41,87.51 168.31,87.62 168.03,87.62 167.93,87.51 167.93,86.07 167.83,85.97 167.55,85.97 167.45,86.07 167.45,87.51 167.35,87.62 167.07,87.62 166.97,87.51 166.97,86.14 166.87,86.04 166.59,86.04 166.48,86.14 166.48,86.73 166.31,86.9 165.35,86.9 v3(164.25,85.81) 161.07,82.62 156.81,82.62 156.29,82.1 155.65,82.1 v2(155.35,82.4)
SPI_CLK_1: length 7.9
  TOP w0.102: U9622.6 171.46,86.47 171.71,86.73 172.43,86.73 172.54,86.83 172.54,87.67 172.43,87.77 171.16,87.77 v2(170.35,88.58) 170.35,89.43 R352.1
  BOTTOM w0.102: v3(170.35,89.39) v2(170.35,88.58)
SPI_CS0_N: length 39.8
  TOP w0.102: v2(154.59,82.49) 153.8,81.7 151.54,81.7 U2.BD31 ; SRCON1.1 168.92,79.53 169.13,79.74 v2(169.89,79.74)
  BOTTOM w0.102: v2(154.59,82.49) 154.35,82.49 154.04,82.18 154.04,81.65 153.92,81.52 153.36,81.52 153.23,81.39 153.23,81.13 153.36,81.01 154.49,81.01 154.65,80.85 154.65,80.2 154.83,80.02 161.08,80.02 161.28,80.22 161.28,81.6 161.38,81.7 161.59,81.7 161.69,81.6 161.69,80.12 161.79,80.02 161.99,80.02 162.09,80.12 162.09,81.57 162.2,81.67 162.4,81.67 162.5,81.57 162.5,80.17 162.6,80.07 164.81,80.07 164.99,80.25 166.19,80.25 167.02,79.41 v3(167.2,79.41) 167.4,79.21 168.32,79.21 168.42,79.31 168.42,80.89 168.52,80.99 169.13,80.99 169.24,80.88 169.24,80.66 169.14,80.55 168.93,80.55 168.83,80.45 168.83,80.25 168.93,80.15 169.18,80.15 169.28,80.05 169.28,79.79 169.18,79.69 168.93,79.69 168.83,79.59 168.83,79.31 168.93,79.21 170.45,79.21 170.55,79.31 170.55,80.15 170.45,80.25 170,80.25 169.89,80.15 v2(169.89,79.74)
SPI_CS1_N: length 3.3
  TOP w0.102: U2.AW31 148.8,82.25 148.8,82.37 148.71,82.46 v2(148.71,82.46)
  BOTTOM w0.102: v2(148.71,82.46) 148.43,82.46 148.09,82.8 147.96,82.8 147.64,83.12 147.64,84.11 TP220.1
SPI_IO2: length 234.1
  TOP w0.102: v2(155.26,80.85) 155.2,80.78 152.15,80.78 152.1,80.74 151.12,80.74 U2.BC29 ; R1832.1 32.52,118.16 32.78,117.89 33.7,117.89 35.49,119.69 38.29,119.69 38.3,119.68 38.49,119.68 v2(39.05,119.13)
  L3 w0.127: v2(77.97,134.12) 76.61,132.76 76.61,131.93 74.11,129.44 62.01,129.44 60.66,130.78 46.97,130.78 40.92,124.74 40.92,120.62 39.43,119.13 v2(39.05,119.13)
  L4 w0.127: v2(143.33,109.84) 143.33,117.08 138.52,121.88 138.52,123.48 137.91,124.09 136.9,124.09 136.21,124.78 136.21,126.73 134.24,128.7 132.95,128.7 132.1,129.55 132.1,131.94 132.1,132.3 127.23,137.16 113.01,137.16 112.41,137.76 89.71,137.76 87.83,135.88 79.72,135.88 v2(77.97,134.12) ; v2(175.89,99.3) 175.62,99.3 172.97,96.65 172.97,91.05 171.72,89.8 171.72,86.78 167.96,83.02 167.96,81.18 v2(167.92,81.14)
  BOTTOM w0.102: R351.1 167.92,82.46 v2(167.92,81.14) 167.92,80.85 167.32,80.24 166.71,80.24 166.06,80.89 166.06,81.11 165.96,81.22 165.37,81.22 165.27,81.32 165.27,81.52 165.37,81.62 165.68,81.62 165.78,81.72 165.78,81.93 165.68,82.03 164.96,82.03 164.86,81.93 164.86,80.48 164.76,80.38 164.56,80.38 164.46,80.48 164.46,81.93 164.36,82.03 164.15,82.03 164.05,81.93 164.05,80.45 163.95,80.35 163.75,80.35 163.64,80.45 163.64,81.93 163.54,82.03 163.34,82.03 163.24,81.93 163.24,80.45 163.14,80.35 162.93,80.35 162.83,80.45 162.83,81.93 162.73,82.03 160.91,82.03 R1798.2 R1797.1 160.2,80.3 156.41,80.3 v3(156.15,80.55) 155.56,80.55 v2(155.26,80.85) ; v2(175.89,99.3) 173.25,99.3 171.09,101.46 159.96,101.46 158.57,102.86 157.3,102.86 154.88,105.27 147.9,105.27 v2(143.33,109.84)
SPI_IO3: length 33.4
  TOP w0.102: R348.2 v2(169.36,91.3) ; U2.BD30 151.59,80.94 152.02,80.94 152.09,81.01 154.76,81.01 155.08,81.34 155.08,81.49 155.81,82.21 155.81,82.27 v2(156.1,82.56)
  BOTTOM w0.102: v2(156.1,82.56) 156.19,82.56 156.55,82.92 159.26,82.92 R1799.1 R1800.1 159.77,84.63 161.23,86.09 162.63,86.09 163.22,86.69 163.37,86.69 163.73,86.32 163.87,86.32 164.07,86.52 164.07,86.66 163.71,87.03 163.71,87.17 163.91,87.37 164.05,87.37 164.41,87 164.56,87 164.76,87.2 164.76,87.35 164.39,87.71 164.39,87.85 164.58,88.05 165.87,88.05 166,88.17 166,88.32 v3(166.11,88.43) 166.41,88.73 166.56,88.73 167.22,88.07 167.4,88.07 167.56,88.23 167.56,88.41 166.9,89.08 166.9,89.22 167.1,89.42 167.24,89.42 167.97,88.69 168.15,88.69 168.31,88.85 168.31,89.03 167.58,89.76 167.58,89.9 167.78,90.1 167.92,90.1 168.33,89.69 168.51,89.69 168.67,89.85 168.67,90.03 168.26,90.44 168.26,90.58 168.27,90.59 168.27,90.73 167.96,91.04 167.96,91.19 168.16,91.38 168.3,91.38 168.8,90.88 168.95,90.88 v2(169.36,91.3)
SPI_MISO: length 32
  TOP w0.102: v2(154.62,81.53) 154.31,81.22 151.92,81.22 U2.BE30
  BOTTOM w0.102: R347.1 167.15,84 167.15,85.61 167.05,85.71 166.76,85.71 166.66,85.61 166.66,84.31 166.56,84.21 166.36,84.21 166.26,84.31 166.26,85.63 166.15,85.74 165.93,85.74 165.82,85.63 165.82,85.3 165.72,85.2 164.89,85.2 164.79,85.1 164.79,84.46 165.85,83.41 165.85,83.26 165.7,83.12 165.56,83.12 163.91,84.77 163.77,84.77 163.62,84.62 163.62,84.48 164.6,83.5 164.6,83.36 164.45,83.22 164.31,83.22 163.34,84.19 163.19,84.19 163.05,84.05 163.05,83.9 163.45,83.5 163.45,83.36 163.31,83.21 163.16,83.21 162.93,83.45 162.65,83.45 v3(161.87,82.66) 161.56,82.36 157.69,82.36 R1829.2 R236.1 156.86,80.76 156.46,81.16 155.97,81.16 155.61,81.53 v2(154.62,81.53)
SPI_MISO_ROM_1: length 7.7
  TOP w0.102: SRCON1.2 170.19,79.04 170.35,79.21 170.35,79.93 170.03,80.25 168.73,80.25 168.29,80.68 166.96,80.68 v2(166.95,80.69)
  BOTTOM w0.102: v2(166.95,80.69) 166.94,80.69 166.39,81.24 v3(166.39,81.61) 166.39,82.35 R347.2
SPI_MOSI: length 196.7
  TOP w0.102: R1779.1 49.41,130.03 53.67,130.03 54.86,131.22 54.86,131.44 54.93,131.52 54.93,133.34 57.12,135.52 v2(57.12,138.7) ; U2.BB29 150.84,80.99 v2(150.84,81.33) ; R355.2 171.65,90.51 170.86,91.3 v2(170.25,91.3) 170.25,91.48 171.44,92.67 171.44,95.94 172.79,97.28 172.79,100.14 172.84,100.19 172.84,101.11 v2(173.1,101.37)
  L3 w0.127: v2(173.1,101.37) 172.96,101.37 172.54,100.95 168.96,100.95 168.73,101.18 162.25,101.18 161.22,102.21 161.22,110.25 159.98,111.49 137.74,111.49 110.62,138.61 81.67,138.61 81.4,138.87 63.54,138.87 62.87,138.2 57.61,138.2 v2(57.12,138.7)
  BOTTOM w0.102: v2(170.25,91.3) 169.79,91.76 168.14,91.76 167.52,91.13 166.58,91.13 166.48,91.03 166.48,90.13 166.38,90.03 166.1,90.03 165.99,90.13 165.99,91.03 165.89,91.13 165.61,91.13 165.51,91.03 165.51,90.13 165.41,90.03 165.13,90.03 165.03,90.13 165.03,90.99 164.93,91.1 164.38,91.1 164.28,90.99 v3(164.28,90.03) 164.28,88.47 162.13,86.32 161.08,86.32 159.94,85.18 159.64,85.18 159.33,84.86 159.33,84.56 159.01,84.24 157.56,84.24 R1828.1 R239.2 156.98,83.43 156.24,83.43 155.78,82.97 154.42,82.97 152.78,81.33 v2(150.84,81.33)
SPI_MOSI_1: length 7.5
  TOP w0.102: R355.1 171.66,89.6 v2(172.56,89.6) 172.84,89.6 173.55,88.89 173.55,86.57 173.45,86.47 172.83,86.47 172.73,86.37 U9622.5
  BOTTOM w0.102: v3(173.37,89.6) v2(172.56,89.6)
SPI_WP_N_1: length 7.7
  TOP w0.102: SRCON1.3 171.46,79.27 v2(169.87,80.86)
  BOTTOM w0.102: v2(169.87,80.86) 169.72,80.86 168.98,81.6 v3(168.98,81.62) 168.98,82.35 R1830.1 169.19,83.6 R343.2 R351.2
SPKR: length 51.2
  TOP w0.102: 156.15,79.89 155.96,79.7 154.35,79.7 153.96,79.31 152.58,79.31 152.53,79.36 151.61,79.36 U2.BD26
  TOP w0.305: v2(165.45,84.59) 164.79,83.93 162.53,83.93 162.15,83.56 161.66,83.56 161.36,83.25 161.36,83.23 R217.2 160.51,82.38 R79861.1 159.63,81.99 159.63,81.01 159.15,80.53 157.71,80.53 157.18,80 156.25,80 156.15,79.89 ; v2(174.96,70.51) 174.95,70.49 174.92,70.49 174.4,69.98 174.4,69.27 174.47,69.21 174.47,67.49 174.13,67.15 173.27,67.15 172.95,67.47 R371.1
  L3 w0.305: v2(165.45,84.59) 167.07,86.22 170.27,86.22 172.33,88.28 v2(172.33,88.76)
  BOTTOM w0.305: v2(172.33,88.76) 172.14,88.57 172.14,81.88 175.61,78.41 175.61,77.44 175.61,73.61 174.97,72.97 v3(174.97,72.76) 174.96,72.74 v2(174.96,70.51)
SPKR_DET: length 106.1
  TOP w0.102: 175.02,28.77 175.53,28.77 176.08,28.22 R1203.1 ; 175.02,28.77 175.02,26.92 174,25.89 v2(171.14,25.89) ; 175.02,28.77 v1(175.01,28.78) ; v2(113.6,52.09) 113.6,56.22 113.73,56.35 113.73,56.73 108.24,62.22 107.8,62.22 106.89,63.12 106.89,63.5 107.38,63.99 U109.59 107.38,65.88 105.45,67.8 105.03,67.8 R283.1
  L3 w0.127: v2(113.6,52.09) 114.44,52.09 115.19,51.34 115.19,51.09 115.19,51.09 115.19,47.23 116.15,46.28 116.15,41.84 117.04,40.95 v2(117.04,36.69)
  L4 w0.127: v2(117.04,36.69) 117.37,36.36 122.88,36.36 127.27,31.97 133.16,31.97 134.25,30.89 135.36,30.89 137.54,33.06 151.99,33.06 152.93,32.12 161.01,32.12 164.94,28.18 168.85,28.18 v2(171.14,25.89)
SPKR_DET_C: length 7.8
  TOP w0.102: v1(177.2,28.7) 177.2,27.96 176.5,27.27 R1203.2 176.08,26.26 175.03,25.21 SPK1.6
SPKR_IN_L: length 15.7
  TOP w0.203: v2(171.44,38.8) 171.15,38.5 U10.6 ; v2(171.87,48.25) 171.87,48.64 172.14,48.92 C243.2 172.79,48.82 C241.2
  L3 w0.203: v2(171.87,48.25) 172.36,47.75 172.36,40.11 171.44,39.19 v2(171.44,38.8)
  BOTTOM w0.203: v3(172.2,39.13) 171.77,39.13 v2(171.44,38.8)
SPKR_IN_R: length 7.1
  TOP w0.203: U10.31 175.44,35.4 175.89,35.85 v1(175.89,35.88) 177.54,35.88 177.74,35.67 180.16,35.67 C234.2
SPKR_L+_C: length 12.5
  TOP w0.711: SPK1.1 v2(167.53,19.71)
  TOP w1.016: v2(163.39,26.02) 163.39,27.09 L7.2
  BOTTOM w1.016: v2(167.53,19.71) 167.16,19.71 v3(165.63,21.25) 164.92,21.96 R400.1 C253.1 164.92,25.51 164.41,26.02 v2(163.39,26.02)
SPKR_L+_SNB: length 3.5
  BOTTOM w0.635: C255.1 162.12,22.49 162.48,22.13 v3(162.88,22.13) 163.01,22.13 163.39,22.52 R400.2
SPKR_L-_C: length 12.5
  TOP w0.711: SPK1.2 v2(169.03,19.71)
  TOP w1.016: L8.2 165.85,27.58 v4(166.19,27.25)
  BOTTOM w1.016: v2(169.03,19.71) 169.03,20.19 168.22,21 v3(168.21,21) 166.31,22.9 R401.1 C254.1 166.31,27.16 166.19,27.29 v4(166.19,27.25)
SPKR_L-_SNB: length 2.8
  BOTTOM w0.635: R401.2 167.84,23.08 168.48,22.44 v3(168.5,22.44) 168.72,22.44 169.11,22.82 C256.1
SPKR_OUT_L+: length 5.6
  TOP w0.305: U10.16 169.31,32.12 168.57,31.38 168.57,30.21 168.24,29.88 166.64,29.88 C244.2
  vias: v1(164.86,30.21)
SPKR_OUT_L-: length 6.9
  TOP w0.305: U10.18 170.65,30.74 169.88,29.97 v1(169.53,29.97) 169.55,29.95 169.55,28.89 C242.2
  TOP w0.864: C242.2 169.51,28.56 169.54,28.54 C252.1
  TOP w1.016: C252.1 168.62,27.65 168.17,28.1 168.17,28.18 L8.1
SPKR_OUT_R+: length 8.9
  TOP w0.305: C235.2 176.68,30.24 176.68,30.45 176,31.12 176,31.67 175.27,32.4 U10.25
  TOP w1.016: C235.2 176.68,30.2 176.37,29.9 176.37,29.3 v2(176.35,29.28)
  BOTTOM w1.016: v3(174.82,29.5) L10.1 176.42,28.13 C257.1 176.47,29.16 v2(176.35,29.28)
SPKR_OUT_R-: length 10.3
  TOP w0.305: C239.2 173.68,29.36 173.35,29.75 173.35,30.2 173.34,30.21 173.34,30.5 173.15,30.68 U10.23
  TOP w0.864: v4(174.9,31.15) 174.99,31.06 174.99,30.1 174.25,29.36 C239.2
  BOTTOM w1.016: L11.1 C258.1 172.66,30.06 173.09,30.49 173.09,30.9 v3(173.23,31.04) 173.75,31.56 174.39,31.56 174.79,31.15 v4(174.9,31.15)
SPKR_R+_C: length 10.1
  TOP w0.711: SPK1.4 v2(172.03,19.71)
  BOTTOM w1.016: v2(172.03,19.71) 172.26,19.71 v3(174.57,22.03) 174.57,22.03 R402.1 C259.1 174.57,25.94 L10.2
SPKR_R+_SNB: length 3.3
  BOTTOM w0.635: C261.1 177.36,22.62 177.03,22.29 v3(176.6,22.29) 176.29,22.29 176.09,22.49 R402.2
SPKR_R-_C: length 10.1
  TOP w0.711: SPK1.3 170.53,19.82 170.5,19.8 v2(170.5,19.71)
  BOTTOM w1.016: v2(170.5,19.71) 170.5,20.33 v3(171.98,21.8) 173.17,23 R403.1 C260.1 173.17,25.69 L11.2
SPKR_R-_SNB: length 2.3
  BOTTOM w0.635: v3(170.38,22.47) C262.1 170.4,23.51 R403.2
SST_HOLDJ_1: length 7.3
  TOP w0.102: SRCON1.7 U9622.7 170.19,86.13 v2(169.47,86.85) 168.22,88.1 R345.2 R348.1
  BOTTOM w0.102: v2(169.47,86.85) 169.62,86.7 v3(169.62,86.05)
SSTCMP: length 4.9
  TOP w0.102: R79695.1 18.42,18.14 v2(18.36,18.2)
  BOTTOM w0.102: v2(18.36,18.2) 18.55,18.2 v3(19.25,17.51) 19.25,17.21 17.78,15.75 U120.11
SSTCMP_1: length 2.3
  TOP w0.102: C12234.1 19.31,16.43 R79695.2 19.3,17.3 v1(19.3,18.3)
STATUS: length 3
  BOTTOM w0.102: R79700.1 15.44,19.04 16,18.47 v3(16,18.15) 16,17.77 15.44,17.2 U120.8
STRAP0: length 12.9
  TOP w0.127: GPU1.D1 91.96,102.62 92.61,101.97 93.35,101.97 94.09,101.23 94.09,100.91 95.6,99.39 96.04,99.39 97.35,98.08 97.35,97.37 v2(97.83,96.89) 98.68,96.04 R231.1
  BOTTOM w0.127: R231.1 98.68,96.04 v2(97.83,96.89) 97.07,96.13 v3(97.07,95.85)
STRAP1: length 12.9
  TOP w0.102: GPU1.D2 91.29,102.62 91.64,102.96 91.92,102.96 92.61,102.27 92.7,102.27
  TOP w0.127: 92.7,102.27 93.37,102.27 94.34,101.3 94.34,101.14 95.75,99.73 96.18,99.73 97.86,98.05 v2(97.86,97.75) 98.6,97.01 R238.1
  BOTTOM w0.127: R238.1 98.43,97.27 98.34,97.27 v2(97.86,97.75) 97.49,97.75 v3(96.93,97.19)
STRAP2: length 16.1
  TOP w0.102: 92.66,101.45 90.83,101.45 90.59,101.69 90.59,101.93 90.27,102.25 90.07,102.25 89.78,102.54 89.78,103.07 GPU1.E4
  TOP w0.127: 92.66,101.45 92.91,101.21 92.91,100.81 95.14,98.58 95.42,98.58 96,97.99 96,96.96 v1(96.72,96.25) 97.25,95.72 97.25,95.62 v2(97.88,94.98) 98.68,94.18 R79989.1
  BOTTOM w0.127: R79989.1 97.88,94.77 v2(97.88,94.98)
STRAP3: length 12.9
  TOP w0.127: R219.1 98.68,98.16 v2(98.05,98.79) 96.77,100.07 95.89,100.07 93.46,102.5 92.69,102.5 92.01,103.18 91.55,103.18 91.48,103.11 90.54,103.11 GPU1.E3
  BOTTOM w0.127: R219.1 98.68,98.16 v2(98.05,98.79) 97.34,98.79 v3(97.11,98.56)
STRAP4: length 13.8
  TOP w0.102: GPU1.D3 90.37,102.62 90.77,102.22 92.02,102.22 92.5,101.74
  TOP w0.127: R243.1 97.88,95.78 v2(97.88,95.92) 96.72,97.09 v1(96.72,97.9) 95.57,99.05 95.46,99.05 93.86,100.65 93.86,101.14 93.26,101.74 92.5,101.74
  BOTTOM w0.127: R243.1 98.68,95.05 97.88,95.85 v2(97.88,95.92)
STRAP_REF0: length 2.4
  TOP w0.127: GPU1.F6 87.74,104.32 v5(88.13,104.71)
  BOTTOM w0.127: v3(89.78,105) 89.73,105.05 R610.2 88.47,105.05 v5(88.13,104.71)
SUS_LED_GREEN_C: length 16.7
  TOP w0.254: PWRCN1.7 35.41,17.42 35.02,17.03 35.02,13.65 34.64,13.27 34.64,10.83 R752.2 36.85,8.62 Q64.D 36.85,7.86 37.29,7.42 38.27,7.42 38.52,7.16 38.52,6.49 38.65,6.36 v1(39.16,6.36) 39.16,6.41 39.19,6.44 R758.2
SUS_LED_GREEN_C2: length 4.8
  TOP w0.254: v1(37.23,9.82) 37.18,9.82 R752.1 36.57,10.93 36.57,11.85 R751.2
SUS_PWR_ACK: length 83
  TOP w0.102: R1949.1 v2(124.47,52.87) ; U2.BB19 150.68,76.29 152.66,76.29 153.42,77.06 v2(153.65,77.06)
  BOTTOM w0.102: v2(153.65,77.06) 154.03,77.43 154.84,77.43 155.83,78.43 155.83,78.47 R126.2 156.23,78.46 156.53,78.46 156.55,78.45 157.24,78.45 157.77,78.98 161,78.98 162.32,77.66 v3(162.32,77.61) 163.78,77.61 164.62,76.77 164.62,76.54 164.76,76.4 164.76,75.27 166.39,73.65 167.18,73.65 168.85,71.97 168.85,62.34 167.46,60.95 166.69,60.95 166.68,60.96 165.22,59.5 165.22,59.06 164.36,58.2 163.14,58.2 162.38,57.44 151.27,57.44 149.42,55.59 149.42,55.02 149.42,55.01 149.42,54.76 147.98,53.33 124.92,53.33 v2(124.47,52.87)
SUS_PWR_ACK_SIO: length 9.2
  TOP w0.102: U109.13 120.34,55.61 120.42,55.52 121.64,55.52 122.75,54.4 v1(122.75,53.07) 122.99,52.83 122.99,51.05 123.13,50.91 R79836.1 R1949.2
SUS_WARNB: length 77.5
  TOP w0.102: v2(154.41,77) 154.28,77 153.88,76.59 153.25,76.59 152.67,76.01 151.64,76.01 151.59,75.96 U2.BD19
  BOTTOM w0.102: v2(154.41,77) 154.44,77 154.49,76.95 154.82,76.95 155.02,77.15 155.28,77.15 155.64,77.51 155.76,77.51 R126.1 156.39,78.14 157.37,78.14 157.9,78.68 159.82,78.68 R127.1 160.77,78.41 162.08,77.1 163.86,77.1 164.32,76.64 164.32,76.41 164.46,76.27 164.46,74.46 165.65,73.27 165.65,71.86 166.24,71.28 166.24,61.78 165.65,61.19 164.89,60.43 164.89,59.16 164.23,58.5 162.97,58.5 162.21,57.75 151.15,57.75 149.12,55.72 149.12,54.89 147.86,53.63 125.34,53.63 v3(125.06,53.91) 124.29,53.91 R1948.1
SUS_WARNB_SIO: length 5.9
  TOP w0.102: v2(122.29,54.22) 121.34,55.16 120.28,55.16 120.23,55.21 U109.12
  BOTTOM w0.102: R1948.2 122.69,53.2 v3(122.12,53.2) 121.99,53.33 121.99,53.91 v2(122.29,54.22)
SUSCLK: length 35
  TOP w0.102: v2(146.34,73.2) 146.16,73.38 U2.AN15
  L3 w0.127: v2(166.06,78.93) 164.22,78.93 163.8,78.51 163.33,78.51 162.12,77.3 162.12,76.18 160.34,74.4 160.34,72.65 159.6,71.91 159.6,70.83 159.13,70.36 156.45,70.36 154.94,71.87 153.74,71.87 152.8,72.81 150.07,72.81 149.15,73.72 146.86,73.72 v2(146.34,73.2)
  BOTTOM w0.102: v2(166.06,78.93) 166.26,78.73 v3(171.01,78.73) R145.1 R137.1
SUSCLK_NGFF: length 201.1
  TOP w0.102: NGFF1.50 133.83,241 134.21,240.63 134.22,240.63 134.36,240.48 135.22,240.48 135.36,240.63 138.83,240.63 139.01,240.8 144.79,240.8 v2(145.43,240.17)
  L3 w0.127: v2(145.43,240.17) 145.43,239.83 154.51,230.75 163.31,230.75 177.32,216.73 177.32,156.49 176.13,155.3 176.13,132.71 178.24,130.6 178.24,114.54 178.97,113.8 178.97,107.67 178.92,107.62 178.92,106.5 179.23,106.2 179.23,102.21 178.78,101.77 178.78,98 172.79,92 172.79,91.14 171.1,89.44 170.55,89.44 170.16,89.05 170.16,89.05 169.88,88.78 169.88,88.77 v2(169.36,88.25)
  BOTTOM w0.102: v2(169.36,88.25) 169.92,88.25 170.78,87.38 170.78,81.24 v3(171.65,80.38) 172.85,79.17 R145.2
SW_ON_N: length 31.7
  TOP w0.102: v2(147.32,72.24) 147.32,72.55 U2.AT13 ; v1(160.75,57.01) 160.72,57.01 160.41,57.33 R120.1 R139.2 158.06,57.83 R142.1 C149.1 156.28,58.27 v2(157.3,59.3)
  L3 w0.127: v2(147.32,72.24) 147.4,72.24 148.14,71.51 148.45,71.51 148.75,71.21 148.75,71.13 149.09,70.79 149.94,70.79 150.37,70.36 150.37,69.43 150.22,69.29 150.22,68.01 148.84,66.63 148.84,65.83 148.76,65.75 148.76,64.39 149.63,63.51 151.14,63.51 153.3,61.35 153.71,61.35 154.34,60.72 157.43,60.72 158.61,59.54 158.61,59.15 158.33,58.88 157.72,58.88 v2(157.3,59.3)
SW_ON_N_SIO: length 7.7
  TOP w0.102: U109.69 102.56,61.61 100.52,63.65 v2(100.4,63.65)
  BOTTOM w0.102: v3(98.78,61.5) 98.93,61.64 R334.1 100.02,62.66 R277.2 100.08,63.33 v2(100.4,63.65)
SYS_3VSB: length 5.1
  TOP w0.102: R300.1 100.73,65.01 v1(101.62,64.12) 102.17,63.56 102.17,63.39 102.18,63.38 102.18,63.05 102.82,62.41 U109.67
SYS_FAN_TACH1_1: length 5.6
  BOTTOM w0.102: R361.2 R364.1 13.16,173.85 FANC3.3
SYS_FAN_TACH1_2: length 3.9
  BOTTOM w0.102: R363.1 5.66,173.28 5.66,174.23 v3(5.91,174.48) 6.61,173.79 R362.2 7.94,173.79 R364.2
SYSTEM_FAN_PWM1_1: length 7.6
  BOTTOM w0.102: FANC3.4 12.76,170.67 9.72,170.67 9.15,170.1 R359.2 R360.2 8.9,171.18 D4.A
THERMAL_SHUT#_SIO: length 4
  TOP w0.102: R285.1 121.79,58.2 v2(121.46,58.2) 121.43,58.24 120.43,58.24 120.26,58.41 U109.20
  BOTTOM w0.102: v2(121.46,58.2) 121.46,57.41 v3(121.48,57.39)
TMDS_3V3: length 24
  TOP w0.305: v2(42.36,28.56) 42.47,28.46 SCA1.1 45.7,28.46 C12187.1 ; v2(42.46,37.07) 42.49,37.1 42.49,37.49 42.95,37.96 SCA1.20
  TOP w0.508: L9502.2 47.95,25.18 48.13,25.36 48.13,25.36 48.25,25.49 48.25,27.02 R9531.1 47.5,27.48 C12185.1 47.19,27.8 46.36,27.8 C12187.1
  L3 w0.508: v2(42.36,28.56) 42.36,29.26 43.06,29.96 43.06,36.27 42.46,36.88 v2(42.46,37.07)
  BOTTOM w0.508: C12186.1 43.57,37.32 43.57,36.63 43.25,36.31 v3(43.12,36.31) 42.74,36.31 42.46,36.59 v2(42.46,37.07)
TP3131_GVDD: length 8.8
  TOP w0.203: R398.2 176.51,39.6 C249.2 175.2,40.04 R396.1 174.29,39.42 174.86,38.85 175.23,38.85 v1(175.6,38.48) 175.6,38.48 175.6,38.11 174.97,37.48 173.35,37.48 173.15,37.28 U10.2
TP_AC37: length 29.1
  TOP w0.102: CPU1.AC37 78.24,204.09 v2(78.25,204.09)
  BOTTOM w0.102: TP8.1 96.02,221.6 91.57,217.16 86.3,217.16 79.61,210.46 79.61,206.15 78.68,205.22 78.68,204.84 78.25,204.41 v2(78.25,204.09)
TP_BD1: length 3.6
  TOP w0.102: U2.BD1 151.81,66.75 151.81,64.3 TP63.1
TP_BE2: length 4.7
  TOP w0.102: U2.BE2 152.01,67.25 152.01,62.88 TP64.1
TP_CK_48M_SIO: length 3.2
  TOP w0.102: v2(146.59,74.29) 146.59,74.54 U2.AR17
  BOTTOM w0.102: v2(146.59,74.29) 146.59,74.06 145.91,73.38 145.91,73.02 146.12,72.81 146.12,72.38 TP163.1
TP_CPU_AU9: length 1.7
  TOP w0.102: CPU1.AU9 89.74,175.82 v5(90.13,176.21)
  BOTTOM w0.102: TP187.1 90.26,176.34 v5(90.13,176.21)
TP_CPU_AU10: length 1.6
  TOP w0.102: v2(89.22,177.15) 89.64,176.74 CPU1.AU10
  BOTTOM w0.102: TP188.1 89.07,177.3 v2(89.22,177.15)
TP_CPU_AU39: length 2.8
  TOP w0.102: CPU1.AU39 91.11,205.98 91.56,205.98 v5(91.99,206.41)
  BOTTOM w0.102: v5(91.99,206.41) 92.65,207.07 TP183.1
TP_CPU_AU40: length 1.8
  TOP w0.102: v5(91.31,206.44) 90.65,206.44 CPU1.AU40
  BOTTOM w0.102: TP184.1 90.98,206.77 v5(91.31,206.44)
TP_CPU_AV1: length 1.8
  TOP w0.102: v5(91.51,168.52) 91.37,168.52 91.37,168.51 CPU1.AV1
  BOTTOM w0.102: v5(91.51,168.52) 91.66,168.36 TP20.1
TP_CPU_AV39: length 2.6
  TOP w0.102: CPU1.AV39 91.62,205.46 92.53,206.36 v5(92.78,206.36)
  BOTTOM w0.102: v5(92.78,206.36) 92.91,206.23 TP19.1
TP_CPU_AW2: length 1.5
  TOP w0.102: CPU1.AW2 91.55,169.42 v5(91.98,169.84)
  BOTTOM w0.102: TP21.1 92.27,169.55 v5(91.98,169.84)
TP_CPU_AW38: length 1.7
  TOP w0.102: CPU1.AW38 92.51,204.54 92.98,205.01 v5(92.98,205.09)
  BOTTOM w0.102: v5(92.98,205.09) 93.49,204.58 TP149.1
TP_CPU_B39: length 1.8
  TOP w0.102: CPU1.B39 58.34,205.46 v2(57.91,205.02)
  BOTTOM w0.102: v2(57.91,205.02) 58.49,205.6 TP180.1
TP_CPU_C40: length 1.7
  TOP w0.102: v2(58.93,206.92) 58.94,206.9 58.96,206.9 CPU1.C40
  BOTTOM w0.102: v2(58.93,206.92) 58.93,207.57 TP179.1
TP_CPU_D15: length 11.2
  TOP w0.102: CPU1.D15 58.95,181.86 58.43,181.86 58.39,181.9 56.46,181.9 56.25,182.1 51.68,182.1 50.49,183.3 v2(50.06,183.3)
  BOTTOM w0.102: TP189.1 v2(50.06,183.3)
TP_CPU_G38: length 4.2
  TOP w0.102: CPU1.G14 v5(62.7,179.94)
  BOTTOM w0.102: TP9.1 60.01,180.83 60.4,180.45 62.19,180.45 v5(62.7,179.94)
TP_CPU_H11: length 3.8
  TOP w0.102: v5(62.71,178.07) 63.12,177.65 CPU1.H11
  BOTTOM w0.102: v5(62.71,178.07) 62.3,177.66 60.27,177.66 TP13.1
TP_CPU_H12: length 3.7
  TOP w0.102: CPU1.H12 63.6,178.12 v5(63.62,178.12)
  BOTTOM w0.102: TP15.1 61.24,178.59 62.99,178.59 63.47,178.12 v5(63.62,178.12)
TP_CPU_H37: length 1.7
  TOP w0.102: v5(63.61,179.98) 63.19,180.4 CPU1.H14
  BOTTOM w0.102: TP10.1 63.52,180.07 v5(63.61,179.98)
TP_CPU_J7: length 2.1
  TOP w0.102: CPU1.J7 64.07,174.16 64.46,173.77 64.46,173.59 v5(64.48,173.57)
  BOTTOM w0.102: v5(64.48,173.57) 63.65,172.73 TP14.1
TP_CPU_J8: length 1.8
  TOP w0.102: CPU1.J8 64,174.91 v5(63.54,174.46)
  BOTTOM w0.102: TP12.1 62.81,175.2 v5(63.54,174.46)
TP_CPU_J11: length 2.8
  TOP w0.102: CPU1.J11 64.48,178.07 v5(64.51,178.07)
  BOTTOM w0.102: TP192.1 64.08,176.74 64.08,177.63 v5(64.51,178.07)
TP_CPU_J13: length 1.9
  TOP w0.102: v5(63.62,179.06) 63.64,179.06 CPU1.J13
  BOTTOM w0.102: v5(63.62,179.06) 64.38,179.82 TP191.1
TP_CPU_J14: length 2.7
  TOP w0.102: CPU1.J14 64.1,180.4 64.44,180.74 64.47,180.74 v5(64.52,180.79)
  BOTTOM w0.102: TP186.1 65.89,181.31 64.98,181.31 64.53,180.86 64.53,180.83 64.52,180.82 v5(64.52,180.79)
TP_CPU_J15: length 2.8
  TOP w0.102: CPU1.J15 v5(63.61,181.77)
  BOTTOM w0.102: TP185.1 62.07,182.21 63.17,182.21 v5(63.61,181.77)
TP_CPU_J17: length 2.9
  TOP w0.102: CPU1.J17 v5(64.52,182.68)
  BOTTOM w0.102: TP178.1 65.84,183.14 65.15,183.14 64.69,182.68 v5(64.52,182.68)
TP_CPU_J19: length 1.9
  TOP w0.102: CPU1.J19 v5(64.52,184.51)
  BOTTOM w0.102: TP177.1 65.14,185.34 64.52,184.72 v5(64.52,184.51)
TP_CPU_K8: length 2.8
  TOP w0.102: v5(64.52,174.45) 64.72,174.64 CPU1.K8
  BOTTOM w0.102: v5(64.52,174.45) 64.05,173.98 63.06,173.98 TP17.1
TP_CPU_K10: length 3.5
  TOP w0.102: CPU1.K10 v5(64.52,177.2)
  BOTTOM w0.102: v5(64.52,177.2) 65.15,176.57 66.93,176.57 TP182.1
TP_CPU_K11: length 3.3
  TOP w0.102: CPU1.K11 v5(65.44,178.11)
  BOTTOM w0.102: v5(65.44,178.11) 65.94,177.61 67.37,177.61 TP190.1
TP_CPU_K12: length 1.7
  TOP w0.102: v5(65.4,178.98) CPU1.K12
  BOTTOM w0.102: v5(65.4,178.98) 66.09,178.29 TP262.1
TP_CPU_K13: length 7
  TOP w0.102: CPU1.K13 v5(65.44,179.94)
  BOTTOM w0.102: R1996.1 69.92,180.2 v3(68.4,181.72) 67.38,181.72 66.77,181.11 66.77,180.74 66.46,180.43 65.93,180.43 v5(65.44,179.94)
TP_CPU_L8: length 1.5
  TOP w0.102: CPU1.L8 v5(65.44,174.45)
  BOTTOM w0.102: TP16.1 66.33,174.45 v5(65.44,174.45)
TP_CPU_L10: length 4.2
  TOP w0.102: CPU1.L10 v5(65.44,177.2)
  BOTTOM w0.102: TP181.1 67.87,177.02 66.85,177.02 66.6,176.77 65.86,176.77 v5(65.44,177.2)
TP_CPU_L12: length 2.7
  TOP w0.102: CPU1.L12 65.9,178.59 v5(66.34,179.03)
  BOTTOM w0.102: v5(66.34,179.03) 66.74,179.44 68.01,179.44 TP261.1
TP_DDR0_DQSN8: length 1.9
  TOP w0.14: CPU1.AU32 90.14,199.5 90.14,199.62 v5(90.13,199.62)
  BOTTOM w0.14: TP4.1 90.39,199.88 v5(90.13,199.62)
TP_DDR0_DQSP8: length 3.6
  TOP w0.14: CPU1.AV32 91.03,198.59 91.02,198.6 v5(89.22,198.6)
  BOTTOM w0.14: TP3.1 90.35,198.6 v5(89.22,198.6)
TP_DDR0_PAR: length 2.3
  TOP w0.102: CPU1.AY15 93.93,184.11 94.35,184.11 v2(94.39,184.15)
  BOTTOM w0.102: TP1.1 94.43,184.11 v2(94.39,184.15)
TP_DDR1_DQSN8: length 1.5
  TOP w0.14: v2(86.48,193.13) 86.92,193.57 CPU1.AN26
  BOTTOM w0.14: TP6.1 86.07,192.72 v2(86.48,193.13)
TP_DDR1_DQSP8: length 1.7
  TOP w0.14: v2(87.39,193.15) 86.93,192.69 CPU1.AN25
  BOTTOM w0.14: TP5.1 87.95,192.59 v2(87.39,193.15)
TP_DDR1_PAR: length 2.1
  TOP w0.102: v2(84.63,188.56) CPU1.AL20
  BOTTOM w0.102: v2(84.63,188.56) 83.84,187.77 TP2.1
TP_DET: length 196.9
  TOP w0.102: v2(112.59,41.52) 113.23,41.52 114.03,40.72 115.58,40.72 116.35,41.49 116.35,43.78 116.6,44.04 116.6,47.22 116.47,47.36 115.5,48.32 113.97,48.32 113.77,48.52 U109.118 ; TOUCH2.1 15.98,136.1 16.18,135.89 17.97,135.89 v1(17.98,135.9) 18.23,136.16 18.23,136.7 R738.2 17.09,136.96 17.02,136.89 v2(17.02,136.96)
  L3 w0.127: v2(17.02,136.96) 17.02,116.91 15.42,115.31 15.42,108.62 16.52,107.53 16.52,106.86 15.06,105.4 15.06,73.85 v2(26.99,61.91)
  L4 w0.127: v2(112.59,41.52) 112.14,41.52 103.82,49.83 98.96,49.83 98.6,49.48 75.47,49.48 75.04,49.91 73.12,49.91 73.04,49.99 67.51,49.99 67.2,49.68 64.95,49.68 62.34,52.28 46.13,52.28 44.93,51.09 40.15,51.09 38.07,53.17 38.07,53.19 37.78,53.48 35.43,53.48 v2(26.99,61.91)
TP_FM_OPC_ZVM_N: length 29.4
  TOP w0.102: CPU1.AC38 v2(77.33,205)
  BOTTOM w0.102: v2(77.33,205) 76.52,205.8 76.52,212.11 84.5,220.08 90.36,220.08 92.78,222.5 TP7.1
TP_FPC_VREF: length 1.6
  TOP w0.102: U2.AR19 146.62,75.75 146.62,75.63 v2(146.52,75.53)
  BOTTOM w0.102: TP34.1 146.3,75.53 v2(146.52,75.53)
TP_FPF_MON: length 1.7
  TOP w0.102: U2.AN17 145.95,74.66 145.95,74.31 v2(145.91,74.26)
  BOTTOM w0.102: TP36.1 145.36,73.71 v2(145.91,74.26)
TP_GPP_A_8: length 9.2
  TOP w0.102: U2.AW22 v5(149.24,76.64)
  BOTTOM w0.102: v5(149.24,76.64) 149.64,76.24 152.75,76.24 152.88,76.36 154.81,76.36 155.01,76.57 155.85,76.57 v3(155.97,76.69) 156.14,76.69 156.81,77.37 157.13,77.37 R79766.1
TP_GPP_A_12: length 5.5
  TOP w0.102: TP58.1 155.11,76.58 154.51,76.58 154.32,76.39 153.33,76.39 152.75,75.81 151.73,75.81 151.63,75.71 150.64,75.71 150.51,75.57 150.51,75.14 U2.BB17
TP_GPP_B4: length 4.8
  TOP w0.102: TP41.1 155.67,78.07 153.44,78.07 153.26,78.24 151.5,78.24 U2.BD24
TP_GPP_B_0: length 2.1
  TOP w0.102: v2(147.89,80.26) 147.25,79.62 U2.AR27
  BOTTOM w0.102: TP62.1 147.89,80.32 v2(147.89,80.26)
TP_GPP_B_1: length 2.2
  TOP w0.102: v2(143.77,79.79) 143.85,79.72 144.6,79.72 144.69,79.62 U2.AL27
  BOTTOM w0.102: v2(143.77,79.79) 143.69,79.87 TP61.1
TP_GPP_B_11: length 3.5
  TOP w0.102: U2.AN24 145.75,78.95 v2(145.75,78.96)
  BOTTOM w0.102: TP66.1 144.72,79.8 145.13,79.39 145.32,79.39 v2(145.75,78.96)
TP_GPP_D_2: length 2.4
  TOP w0.102: v2(146.98,83.97) 146.98,84.02 146.75,84.25 146.75,84.47 U2.AN38
  BOTTOM w0.102: TP52.1 146.83,83.82 v2(146.98,83.97)
TP_GPP_D_21: length 4.3
  TOP w0.102: TP56.1 144.28,91.79 144.28,90.27 142.9,88.89 142.9,88.33 U2.AG44
TP_GPP_D_22: length 5.4
  TOP w0.102: TP54.1 145.59,90.33 144.38,89.13 144.38,88.86 144.33,88.81 144.33,88.79 144.12,88.58 143.91,88.58 143.66,88.33 143.66,87.8 U2.AH43
TP_GPP_F6: length 2.4
  TOP w0.102: v2(140.91,86.89) 140.78,87.02 140.78,87.04 U2.AB42
  BOTTOM w0.102: v2(140.91,86.89) 140.94,86.91 140.94,88.02 TP85.1
TP_GPP_F7: length 3.2
  TOP w0.102: v2(141.03,86.21) 141.42,86.6 141.42,87 141.12,87.3 141.06,87.3 140.93,87.43 140.93,87.52 140.67,87.78 U2.AB43
  BOTTOM w0.102: TP266.1 141.67,86.85 v2(141.03,86.21)
TP_GPP_F8: length 2.7
  TOP w0.102: U2.AB36 140.39,84.45 140.02,84.07 v2(139.89,84.07)
  BOTTOM w0.102: v2(139.89,84.07) 140.23,83.73 140.23,82.56 139.97,82.31 TP83.1
TP_GPP_G20: length 1.4
  TOP w0.102: U2.R35 136.84,83.64 136.56,83.92 v2(136.56,83.95)
  BOTTOM w0.102: v2(136.56,83.95) 136.54,83.93 TP217.1
TP_GPP_G21: length 2.9
  TOP w0.102: U2.U35 137.97,83.64 137.66,83.32 137.56,83.32 v2(137.53,83.3)
  BOTTOM w0.102: TP216.1 137.74,81.52 137.99,81.77 137.99,82.84 v2(137.53,83.3)
TP_GPP_G_12: length 4.8
  TOP w0.102: v2(137.56,85.3) 136.99,85.87 U2.R39
  BOTTOM w0.102: v2(137.56,85.3) 136.98,84.72 136.98,84.15 136.99,84.13 136.99,83.77 136.98,83.76 136.98,83.3 TP31.1 136.72,82.09 R99.1
TP_GPP_G_13: length 1.6
  TOP w0.102: v2(136.53,84.71) 136.54,84.7 136.54,84.7 136.84,84.4 U2.R36
  BOTTOM w0.102: TP32.1 136.77,84.95 v2(136.53,84.71)
TP_GPP_G_14: length 8.2
  TOP w0.102: R100.1 134.88,93.27 134.61,93 TP33.1 134.61,92.44 136.09,90.96 136.73,90.28 136.93,90.28 137.31,89.91 137.31,89.19 137.1,88.99 137.1,88.6 136.89,88.39 136.89,87.59 137,87.49 U2.R42
TP_GPP_G_17: length 7.3
  TOP w0.102: U2.N44 136.09,88.32 135.98,88.42 135.98,89.16 134.04,91.1 133.94,91.1 133.34,91.69 133.34,93.89 TP65.1
TP_GPP_H_10: length 7.9
  TOP w0.102: U2.BD34 151.37,83.59 151.65,83.87 152.79,83.87 152.8,83.88 152.86,83.88 153.35,84.37 153.35,84.54 153.36,84.54 153.36,84.92 155.92,87.49 TP55.1
TP_GPP_H_11: length 1.9
  TOP w0.102: U2.AW35 148.86,83.89 148.63,84.11 148.63,84.21 v2(148.61,84.24)
  BOTTOM w0.102: TP53.1 148.61,84.57 v2(148.61,84.24)
TP_GPP_H_12: length 12
  TOP w0.102: R1834.2 R1833.1 159.14,88.06 TP51.1 157.9,88.23 156.13,88.23 154.73,86.83 154.73,86.64 153.15,85.07 153.15,84.63 153.15,84.62 153.15,84.45 152.78,84.08 151.57,84.08 151.54,84.06 U2.BD35
TP_GPP_H_13: length 8.7
  TOP w0.102: U2.BC35 151.07,84.06 151.3,84.29 151.86,84.29 151.86,84.29 152.69,84.29 152.95,84.54 152.95,84.71 152.95,84.71 152.95,85.15 154.53,86.73 154.53,86.95 156.34,88.76 TP49.1
TP_GPP_H_14: length 2.8
  TOP w0.102: v2(149.39,84.44) 149.5,84.44 149.91,84.03 U2.BA35
  BOTTOM w0.102: TP47.1 150.76,85 149.95,85 v2(149.39,84.44)
TP_GPP_H_15: length 1.8
  TOP w0.102: v2(150.86,83.4) 150.86,83.44 150.46,83.83 U2.BB36
  BOTTOM w0.102: v2(150.86,83.4) 151.21,83.04 TP45.1
TP_GPP_H_16: length 9.5
  TOP w0.102: U2.BD39 151.37,85.62 151.53,85.46 152.68,85.46 154.12,86.9 154.12,88.35 156,90.23 156.48,90.23 TP44.1
TP_GPP_H_17: length 8.5
  TOP w0.102: U2.BE34 152.1,83.67 152.88,83.67 152.88,83.68 152.95,83.68 153.56,84.29 153.56,84.46 153.56,84.46 153.56,84.8 155.72,86.96 157.9,86.96 158.31,87.36 TP155.1
TP_GPP_H_18: length 4.3
  TOP w0.102: U2.BC36 v2(150.14,84.57)
  BOTTOM w0.102: TP154.1 152.52,85.33 151.35,84.16 150.55,84.16 v2(150.14,84.57)
TP_H_CATERR_N: length 12.4
  TOP w0.102: CPU1.D13 58.96,180.02 56.51,180.02 55.19,181.34 50.67,181.34 49.6,182.41 v2(49.43,182.41)
  BOTTOM w0.102: TP11.1 49.43,181.89 v2(49.43,182.41)
TP_L_BKLTEN: length 3.1
  TOP w0.102: v2(138.79,83.21) 138.81,83.22 139.1,83.22 139.29,83.41 U2.W35
  BOTTOM w0.102: v2(138.79,83.21) 138.25,82.66 138.25,82.16 TP165.1
TP_L_VDDEN: length 5.2
  TOP w0.102: TP142.1 139.78,92.05 139.78,89.8 139.85,89.73 139.85,88.87 139.78,88.81 139.78,88.36 139.67,88.24 139.67,87.46 139.46,87.25 U2.W42
TP_NGFF_COEX1: length 7
  TOP w0.102: NGFF1.48 133.57,240.5 134.07,240 135.42,240 135.56,240.14 TP113.1
TP_NGFF_COEX2: length 3.3
  TOP w0.102: TP114.1 135.58,239.76 133.8,239.76 133.56,240 NGFF1.46
TP_NGFF_COEX3: length 4.8
  TOP w0.102: NGFF1.44 135.09,239.5 135.61,238.97 136.57,238.97 TP115.1
TP_NGFF_LED1: length 3.7
  TOP w0.102: NGFF1.6 136.23,230 TP118.1
TP_NGFF_LED2: length 3.2
  TOP w0.102: TP116.1 134.74,232.5 NGFF1.16
TP_NGFF_MLDIR: length 3.2
  TOP w0.102: NGFF1.17 123.88,232.75 123.29,232.17 TP117.1
TP_PCH_AB13: length 5.6
  TOP w0.102: v2(139.91,72.3) 140.33,72.72 U2.AB13
  BOTTOM w0.102: v2(139.91,72.3) 139.95,72.3 140.47,71.78 140.47,68.35 TP71.1
TP_PCH_AR22: length 1.5
  TOP w0.102: v2(146.83,77.74) 146.83,77.63 146.95,77.51 U2.AR22
  BOTTOM w0.102: v2(146.83,77.74) 147.06,77.96 147.06,78.42 TP265.1
TP_PCH_BD14: length 3.7
  TOP w0.089: 153.02,73.05 152.83,72.85 152.47,72.85 152.27,73.06 151.73,73.06 151.59,73.21 U2.BD14
  TOP w0.102: 153.02,73.05 153.21,73.23 v2(153.69,73.23)
  BOTTOM w0.102: v2(153.69,73.23) 153.69,73.54 TP164.1
TP_PCH_C1: length 4.7
  TOP w0.102: TP263.1 128.59,64.41 131.1,66.92 U2.C1
TP_PCH_D1: length 4.1
  TOP w0.102: U2.D1 131.53,67.03 131.23,66.73 131.2,66.73 129.86,65.39 TP264.1
TP_SDI: length 6
  TOP w0.102: TP60.1 154.46,67.8 154.07,68.19 154.07,68.35 152.7,69.72 152.56,69.72 152.05,70.22 151.28,70.22 151.04,70.46 U2.BC8
TP_SLP_LAN_N: length 2.4
  TOP w0.102: U2.AV15 148.12,73.75 147.6,74.27 v2(147.36,74.27)
  BOTTOM w0.102: TP68.1 147.85,73.78 v2(147.36,74.27)
TPA3113_SD: length 10.6
  TOP w0.254: Q13.6 185.45,38.59 185.77,38.28 185.77,34.98 185.6,34.81 v1(185.6,34.8) R390.2 184.64,33.89 Q12.G 185.2,30.18 R79871.1
TPA3113_SD1#: length 16
  TOP w0.102: Q12.D 183.39,30.59 181.04,30.59 180.22,31.42 Q9626.G ; Q9626.G 178.81,31.42 178.52,31.71 C245.1 178.24,32.04 R389.2 178.15,32.89 R381.1 176.94,32.89 176.26,33.58 176.26,33.96 175.82,34.4 U10.29 ; Q9626.G 179.1,30.97 179.1,29.96 v1(179.02,29.88) 179.02,29.81 178.89,29.67 R79919.1
