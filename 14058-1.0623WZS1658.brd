# Allegro board 14058-1.0623WZS1658.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_AUD: length 6.1
  TOP w0.203: v1(179.72,63.8) 179.9,63.63 179.9,63.33 179.5,62.94 U9.40
  TOP w0.305: v1(179.72,63.8) 179.69,63.84 179.68,63.84 178.38,65.15 C213.1
  TOP w0.508: C213.1 179.81,65.4 C214.1
P1V0_PCH_VCCDSW: length 3.3
  TOP w0.254: U2.BA29 149.9,80.74 149.59,80.44 v2(149.59,80.24)
  BOTTOM w0.254: v2(149.59,80.24) 149.59,80.27 149.03,80.83 148.96,80.83 148.92,80.87 C11833.1 147.67,80.87 v3(147.39,81.15)
PVCC_3V3: length 160.4
  TOP w0.203: SCA1.49 37.51,49.75 v2(37.53,49.77)
  TOP w0.305: v2(30.04,37.32) 29.91,37.45 SCA1.84
  TOP w0.508: v2(48.81,46.24) 48.61,46.44 47.88,46.44 R79799.1 47.82,46.18 R79800.1 ; v2(23.82,23.61) 24.2,23.99 R9525.2 ; v2(20.8,17.77) 20.06,18.5 20.06,18.62 19.12,19.55 R9503.2 ; v2(45.53,25.08) 45.84,25.08 L9502.1 ; v2(20.39,24.88) 21.91,26.4 R9521.2 R79236.2 ; v2(52.77,8.37) 52.9,8.24 R9507.1 ; v2(39.57,15.99) 38.99,16.56 R9544.1 ; R79798.1 v2(48.63,42.47)
  L3 w0.508: v2(20.8,17.77) 21.07,18.05 21.09,18.05 21.48,18.43 21.48,21.75 20.39,22.85 v2(20.39,24.88) ; v2(36.17,25.66) 36.17,25.35 36.54,24.98 36.54,23.89 35.88,23.23 v4(35.88,22.62) 35.88,22.34 36.71,21.51 36.71,19.99 38.63,18.07 38.63,16.93 v2(39.57,15.99)
  L4 w0.508: v2(27.35,37.42) 29.34,35.43 29.34,24.43 v2(31.06,22.72) ; v2(48.63,42.47) 48.63,44.74 48.84,44.94 48.84,46.21 v2(48.81,46.24)
  BOTTOM w0.508: v2(20.39,24.88) 22.59,24.88 23.82,23.65 v2(23.82,23.61) 24.71,22.72 v2(31.06,22.72) 35.78,22.72 v4(35.88,22.62) 36.33,23.06 42.93,23.06 44.95,25.08 v2(45.53,25.08) ; R9548.2 39.63,27.67 R9528.2 39.63,29.77 39.29,30.11 37.9,30.11 37.05,29.27 37.05,28.6 36.84,28.38 36.84,26.97 36.45,26.59 R79868.1 36.14,25.77 36.17,25.73 v2(36.17,25.66) ; v2(39.57,15.99) 39.54,15.96 39.54,14.42 41.41,12.56 42.87,12.56 43.88,13.58 43.97,13.58 46.98,13.58 49.88,10.67 49.88,10.06 51.59,8.34 52.75,8.34 v2(52.77,8.37) 55.57,8.37 57.22,10.02 63.54,10.02 v2(63.93,9.63) ; 31.95,41.39 29.85,41.39 27.35,38.89 v2(27.35,37.42) 27.39,37.39 C12197.1 29.98,37.39 v2(30.04,37.32) ; v2(48.81,46.24) 48.81,46.69 47.95,47.56 46.07,47.56 45.41,48.22 45.41,49.28 44.26,50.43 v3(40.94,50.43) ; C12191.1 37.22,49.45 v2(37.53,49.77) ; C12191.1 37.09,48.63 C9504.1 37.6,47.36 U9502.8 ; C12191.1 37.15,48.82 36.83,48.82 36.64,48.63 35.88,48.63 35.82,48.56 R79205.2 R9545.2 33.6,48.56 33.09,48.06 33.09,46.85
  BOTTOM w0.635: U9502.8 39.31,47.36 40.46,48.5 40.46,49.95 v3(40.94,50.43)
PVCC_3V3_SDRAM: length 30.3
  TOP w0.305: v2(31.34,28.51) 31.51,28.33 SCA1.106 ; v2(31.01,46.9) SCA1.62
  L3 w0.508: v2(31.01,46.9) 30.52,46.41 30.52,45.69 30.9,45.31 30.9,43.05 30.32,42.47 30.32,40.52 v2(30.3,40.5) 29.38,39.58 29.38,30.97 v2(30.14,30.21)
  BOTTOM w0.508: v2(30.14,30.21) C12184.2 30.99,28.85 v2(31.34,28.51) ; L9503.2 31.18,40.5 v2(30.3,40.5) ; C12244.1 28.77,46.75 29.25,46.27 v3(29.33,46.27) 30.04,46.98 C9518.1 C12194.1 31.06,47.36 31.01,47.31 v2(31.01,46.9)
V1P0_CPU_XDP_S5: length 13.4
  TOP w0.254: R1748.1 R1749.1 33.76,126.22 v1(35.5,126.22) 35.5,125.59 35.1,125.18 v2(34.7,125.18)
  BOTTOM w0.254: v2(34.7,125.18) 34.88,125.01 XDPC1.44 38.12,125.01 39.14,123.98 39.99,123.98 41.02,125.01 XDPC1.43
V1P0_PCH_S5: length 251.9
  TOP w0.254: U2.AD15 141.23,74.04 v2(141.06,74.22) U2.AC17 ; U2.R17 137.13,75.02 137.13,75.05 136.9,75.28 136.67,75.28 136.59,75.35 136.5,75.35 v2(136.49,75.36)
  TOP w0.305: U2.U23 138.31,78.2 138.31,78.22 v2(138.33,78.24) 138.31,78.25 138.31,78.3 138.11,78.51 138.08,78.51 U2.U25 ; U2.AC23 141.06,77.82 141.36,77.52 141.41,77.52 v2(141.45,77.48) 141.47,77.48 U2.AE23 ; U2.AE26 141.47,79.03 v2(141.45,79.03) 141.35,79.03 141.06,79.32 U2.AC26 ; U2.V26 138.37,79.77 v2(138.35,79.77) ; U2.V17 v2(138.74,74.22) ; U2.Y25 139.52,78.62 139.89,78.25 v2(139.89,78.24) ; v2(143.77,79.02) 144.16,78.63 U2.AJ25 U2.AJ23 ; U2.U21 v2(138.34,76.7) 137.94,76.3 U2.U20 137.74,76.08 U2.R19 ; U2.AJ20 144.16,76.32 v5(143.79,76.69) 144.16,77.05 U2.AJ21 ; U2.Y23 139.67,78.01 139.67,78.02 v2(139.89,78.24) ; v2(139.89,78.24) 140.28,77.85 U2.AA23 ; v2(136.49,75.36) 136.49,75.35 U2.N17 ; v2(141.44,79.8) 141.43,79.8 U2.AC28 ; U2.V28 138.35,79.79 v2(138.35,79.77) ; v2(138.35,79.77) 138.33,79.77 U2.U26 ; U2.AA28 140.29,80.17 139.99,79.87 139.99,79.86 v2(139.91,79.78) 139.91,79.77 U2.AA26
  TOP w0.508: v2(130.63,63.61) 132.06,63.61 R890.1 ; v2(133.34,95.46) 132.81,96 v1(131.67,96) C11888.1 130.07,95.52 130.97,94.61 R891.1 ; R1842.2 R79779.2 147.77,57.11 v2(147.82,57.06) ; R68.1 36.9,145.15 35.73,146.32 Q1234.D 33.91,146.32 v2(33.23,145.63) ; v2(145.75,57.15) 145.76,57.16 145.76,57.89 R132.2 ; R1748.2 R1749.2 32.19,125.86 32.52,125.53 R1776.1 v2(31.72,125.08)
  L3 w0.381: v2(123.18,74.31) 123.18,74.46 123.21,74.49 123.21,75.88 123.5,76.17 123.53,76.17 124.18,76.82 131.44,76.82 132.19,76.07 132.91,76.07 132.97,76.01 133.24,76.01 133.3,75.94 134.37,75.94 134.48,76.06 134.95,76.06 134.95,76.06 135.23,76.06 135.24,76.05 135.85,76.05 136.49,75.42 v2(136.49,75.36)
  L3 w0.508: v2(133.67,123.56) 131.72,125.51 126.56,125.51 103.29,148.78 83.79,148.78 81.37,146.36 61.87,146.36 61.75,146.24 33.84,146.24 v2(33.23,145.63) ; v2(145.93,65.05) 145.89,65.01 145.89,61.81 147.82,59.88 v2(147.82,57.06)
  L4 w0.508: 136.34,101.46 136.34,118.6 134.31,120.64 134.31,122.92 v2(133.67,123.56)
  BOTTOM w0.508: v2(33.23,145.63) 33.87,144.99 33.87,141.31 31.25,138.68 31.25,126.21 v3(31.21,126.17) 31.25,126.14 31.25,125.55 v2(31.72,125.08) ; v2(145.75,57.15) 145.76,57.16 147.82,57.16 v2(147.82,57.06) ; v2(123.18,74.31) 123.18,74.27 122.75,73.84 122.75,68.43 124.93,66.25 125.24,66.25 126.72,64.78 126.92,64.78 128.39,63.31 129.61,63.31 ; v3(129.62,63.32) 129.61,63.31 ; 129.61,63.31 130.32,63.31 v2(130.63,63.61) 131.26,62.98 134.39,62.98 134.59,63.18 137.69,63.18 138.24,63.74 143.59,63.74 R1841.2 145.5,65.48 145.92,65.06 145.92,65.06 v2(145.93,65.05)
  vias: v1(155.47,93.61) v2(138.32,99.81) v3(140.48,77.51) v4(157.52,94.12) v4(157.54,95.17) v4(158.6,95.23) v4(158.59,94.17) v4(158.59,93.05) v4(159.75,95.1) v4(159.73,94.04) v4(159.73,92.92)
VBAT1: length 0.8
  BOTTOM w0.254: v3(124.28,106.36) v2(124.28,107.17)
VBAT1_R: length 4.4
  TOP w0.762: D3.A 125.04,99.43 124.02,100.44
  BOTTOM w0.508: TP108.1 v2(123.51,101.46)
VBAT2: length 52.2
  TOP w0.508: R302.2 v1(98.11,66.03) 97.96,66.03 96.87,67.12 96.87,70.44 98.42,72 104.31,72 105.65,73.34 106.06,73.34 111.32,78.6 112.51,78.6 114.03,80.12 115.67,80.12 116.78,81.24 116.78,83.15 119.67,86.03 124.85,86.03 v1(125.29,86.47) 126.56,87.74 126.56,91.43 125.04,92.95 D3.K
VBAT_SIO: length 6.8
  TOP w0.203: U109.66 103.03,62.81 102.61,63.23 102.61,63.56
  TOP w0.254: C190.1 R302.1 100.58,66.03 101.2,65.4 v1(101.29,65.4) 101.56,65.4 101.59,65.37 101.72,65.37 102.61,64.48 102.61,63.56
VCC: length 742.8
  TOP w0.508: R118.1 146.96,100.19 v2(146.69,100.46) ; R741.1 52.01,7.29 v2(52.01,9) ; v2(54.55,21.52) 53.78,20.75 R9541.1 ; v2(47.44,15.06) 47.39,15.01 R79858.1 ; v4(82.71,64.37) 82.71,64.66 81.48,65.9 v1(81.48,68.16) 80.51,69.12 80.51,70.52 80.9,70.9 83.46,70.9 91.03,78.47 92.53,78.47 93.03,77.96 v2(93.03,77.71) ; PR74.1 v2(11.03,186.8) ; v2(105.17,92.95) 105.1,92.87 102.68,92.87 101.33,94.22 v2(100.37,94.22) ; v2(37.26,104.37) 37.84,104.37 37.98,104.51 PR8339.2 ; v2(153.23,30.34) 158.63,30.34 R5217.1 160.08,30.15 v2(160.14,30.09) ; R9540.1 47.44,21.32 v2(48.18,22.06) ; v2(12.05,205.81) 12.01,205.85 11.19,205.85 PR83.1 ; v2(140.48,117.28) 127.25,117.28 124.92,119.61 123.22,119.61 122.83,119.21 122.24,119.21 121.43,120.02 120.41,120.02 v2(120.08,119.69) ; v2(110.36,128.89) 110.36,129.86 PC152.1 109.67,129.91 108.78,129.02 PU5302.6 ; v2(136.34,47.87) 137.67,49.2 R763.1 ; v2(174.15,63.57) 173.87,63.85 171.45,63.85 171.39,63.92 R378.1
  TOP w1.27: PR106.1 v4(94.81,254.49) ; PR98.1 v2(63.06,258.86) ; PR89.1 v2(8.4,234.48)
  L3 w0.508: v2(103.29,106.56) 103.29,103.8 104.11,102.98 104.11,100.62 102.31,98.82 102.31,98.27 105.17,95.41 v2(105.17,92.95) ; v2(47.44,15.06) 47.29,15.21 47.29,17.87 48.15,18.74 48.15,22.03 v2(48.18,22.06) ; v2(164.61,44.62) 163.71,43.72 163.71,41.42 160.14,37.85 v2(160.14,30.09) ; LPC1.8 134.56,49.52 136.21,47.87 v2(136.34,47.87) 136.47,47.74 136.47,33.77 138.12,32.12 v2(138.12,31.23) ; v2(38.68,114.92) 33.09,114.92 31.95,113.78 22.8,113.78 22.04,113.02 21.87,113.02 v4(21.72,112.86) ; v2(93.13,54.34) v2(95.73,54.34)
  L4 w0.508: 20.39,49.64 20.39,47.74 19.6,46.95 19.6,40.61 19.63,40.58 19.63,32.61 22.52,29.71 22.52,27.14 22.91,26.76 24.65,26.76 30.8,20.6 30.8,18.95 41.22,8.54 41.22,8.02 42.92,6.31 49.32,6.31 v2(52.01,9) ; v2(100.37,94.22) 98.49,92.35 98.49,89.09 98.94,88.64 99.66,87.92 99.66,86.71 96.97,84.01 96.97,83.12 93.03,79.19 v2(93.03,77.71) ; v2(138.12,31.23) 138.75,31.86 150.69,31.86 152.22,30.34 v2(153.23,30.34) ; v2(174.24,53.22) 173.66,52.65 173.41,52.65 173.03,52.26 173.03,51.7 171.73,50.41 171.27,50.41 v4(168.47,47.61) 168.47,47.31 167.71,46.55 164.36,46.55 163.77,45.96 163.77,45.2 164.35,44.62 v2(164.61,44.62) ; v2(146.69,100.46) 147.04,100.46 147.52,100.93 147.52,102.37 142.18,107.71 142.18,115.58 v2(140.48,117.28) ; v2(53.28,25.51) 52.01,25.51 51.2,24.7 51.2,24.32 49.98,23.1 49.22,23.1 v2(48.18,22.06) 48.91,21.32 54.35,21.32 v2(54.55,21.52)
  BOTTOM w0.508: PR8313.1 105.61,93.38 v2(105.17,92.95) ; v4(168.47,47.61) 167.66,46.8 167.66,45.76 168.09,45.33 D23.A ; v2(52.01,9) 50.64,10.37 50.64,11.93 49.64,12.93 49.57,12.93 v2(47.44,15.06) ; v2(174.24,53.22) 172.51,54.95 172.51,56.5 173.39,57.37 173.39,63 173.96,63.57 v2(174.15,63.57) ; v2(12.05,205.81) 11.45,205.22 5.7,205.22 ; v2(153.23,30.34) 153.23,30.59 v3(152.49,31.34) 151.01,32.82 C12199.1 151.02,33.91 F7.1 ; R266.2 100.4,52.25 99.49,52.25 98.15,53.58 96.06,53.58 95.73,53.91 v2(95.73,54.34) ; v2(103.29,106.56) 103.7,106.97 103.7,107.68 104.69,108.67 104.69,111.05 104.23,111.51 104.23,112.75 109.71,118.22 118.61,118.22 v2(120.08,119.69) 116.03,123.73 115.8,123.73 114.74,124.79 114.74,125.46 111.31,128.89 v2(110.36,128.89) ; C364.1 84.84,61.9 85.54,61.2 88.91,61.2 90.18,59.93 93.48,59.93 94.43,58.98 94.43,58.66 95.07,58.03 95.07,56.27 v2(93.13,54.34) 93.16,54.32 93.16,53.9 R80239.2 94.83,53.01 95.53,52.31 95.59,52.31 95.61,52.28 96.06,52.28 96.67,51.68 96.67,51.21 96.69,51.19 96.69,51.18 97.6,50.28 v3(102.05,50.28) 104.71,50.28 112.71,42.28 113.22,42.28 113.53,41.97 114.6,41.97 115.77,43.14 115.77,44.43 116.51,45.17 133.65,45.17 v2(136.34,47.87) ; R499.1 52.52,25.89 52.9,25.51 v2(53.28,25.51) ; PR8330.1 100.4,94.19 v2(100.37,94.22) ; v2(38.68,114.92) 38.68,114.54 40.84,112.38 42.77,112.38 43.5,111.64 PR8616.2 43.44,110.98 42.53,110.98 41.09,109.55 41.09,108.2 v2(37.26,104.37)
  BOTTOM w1.27: v4(94.81,254.49) 93.03,254.49 89.99,257.54 89.99,261.3 87.34,263.94 72.64,263.94 71.04,262.34 65.78,262.34 63.06,259.62 v2(63.06,258.86) 62.88,258.69 v3(56.84,258.69) 56.46,259.07 41.98,259.07 40.76,257.85 PR4404.1 38.68,257.03 35.38,260.34 23.06,260.34 8.4,245.68 v2(8.4,234.48) 7.31,234.48 5.7,232.86 5.7,190.7 9.59,186.8 v2(11.03,186.8) 11.03,185.24 15.06,181.22 15.06,170.42 13.79,169.15 12.13,169.15 8.83,165.85 8.83,162.93 10.1,161.66 R80234.1 12.31,157.8 21.53,148.58 v3(21.53,146.09) 21.53,142.61 21.66,142.48 21.66,136.38 23.61,134.43 23.61,114.08
  vias: v2(21.66,58.79) v2(22.42,58.53) v3(82.77,62.17) v4(19.22,50.48) v4(19.22,49.44) v4(21.66,111.75) v4(81.73,64.38) v4(81.73,63.36) v4(82.75,63.36)
VCC3: length 1559.3
  TOP w0.203: U118.37 164.04,46.28 164.28,46.52 164.56,46.52 ; v2(174.44,56.76) 174.93,57.24 U9.11 ; U118.11 158.38,47.87
  TOP w0.305: U2.AD13 141.66,72.72 141.2,73.18 v2(141.2,73.35)
  TOP w0.33: v4(162.95,135.65) 161.75,136.85 DIMM2.199 ; DIMM1.199 146.36,136.85 147.18,136.03 147.18,134.33 147.26,134.25 v2(147.26,133.63)
  TOP w0.406: Q9620.5 183.26,28.82 v2(183.38,28.69)
  TOP w0.508: R79942.2 143.22,99.53 v2(143.08,99.67) ; v2(87.06,130.45) 87.06,130.67 87,130.73 R80054.1 ; R169.2 R170.2 R173.2 159.54,86.94 v2(158.95,86.35) 158.78,86.18 R177.2 R176.2 ; R79720.1 R143.1 4.35,19.44 v2(4.13,19.23) ; R1593.1 151.01,45.33 144.6,45.33 143.71,46.21 U119.3 ; R217.1 162.35,82.92 162.63,82.64 v2(162.73,82.64) 162.06,81.96 161.99,81.96 R162.2 ; v2(20.8,128.38) 22.93,128.38 23.74,129.2 24.97,129.2 25.81,130.03 R79946.1 ; v2(173.9,67.71) 173.9,67.9 173.93,67.93 173.93,68.69 173.28,69.34 171,69.34 169.11,67.45 169.11,62.92 168.26,62.07 168.26,62.03 167.87,61.64 R226.1 ; v4(21.41,23.45) 21.66,23.2 R753.2 ; R1662.1 129.8,99.17 128.9,99.17 128.29,99.79 128.29,100.34 129.07,101.11 129.96,101.11 R199.1 130.05,101.52 130.4,101.87 131.31,101.87 131.59,101.58 131.59,101.13 132.15,100.57 R1687.1 132.72,100.89 133.06,101.23 134.79,101.23 135.51,100.51 R79932.1 ; v2(19.98,139.56) 20.58,138.96 PR4.1 ; v2(95.57,107.43) 95.45,107.56 R1129.2 ; R157.2 164.98,85.33 165.8,85.33 166.11,85.03 166.11,83.88 165.68,83.45 v2(165.68,82.64) ; R6702.1 32.96,108.13 R6701.1 31.64,107.3 v2(30.9,108.04) 30.55,108.04 30.51,108 R6703.1 27.51,106.62 v2(23.23,106.62) 22.9,106.62 22.52,107 22.52,108.37 23.06,108.9 R6704.1 ; v2(170.57,204.46) R475.1 ; 164.56,46.52 166.71,46.52 C12200.1 ; v2(54.55,19.04) 53.85,19.73 R9557.1 ; v2(168.87,55.52) 168.83,55.56 168.83,55.99 169.36,56.53 R374.1 168.92,57.1 168.28,57.73 C11838.1 ; PR135.1 16.9,167.75 v2(15.69,167.75) ; v2(156.28,81.65) 156.3,81.67 156.47,81.67 157.05,82.26 R218.1 ; R734.2 154.12,242.43 v2(155.14,243.45) ; C12200.1 166.76,46.95 v2(167.16,47.36) ; C12200.1 R1596.1 ; R1961.1 20.66,161.71 20.74,161.71 21.56,160.89 21.56,159.22 20.94,158.61 v2(20.9,158.61) ; v2(165.68,82.64) 164.88,82.64 R160.2 ; v2(165.68,82.64) 165.7,82.66 172.41,82.66 173.61,81.46 182.02,81.46 v2(182.41,81.06) ; v2(142.94,92.7) v2(142.94,91.73) ; R1661.1 v2(134.69,97.01) 134.69,97.19 134.03,97.85 134.03,98.43 134.42,98.82 134.99,98.82 135.51,99.34 R79932.1 ; PR4401.1 38.14,249.58 19.46,249.58 v4(19.25,249.8) ; v2(34.87,256.02) 34.8,255.95 PR4402.1 ; v2(17.09,137.84) R738.1 ; v2(158.92,77.61) 158.32,77.61 R156.2 ; R79831.2 67.25,27.67 v2(67.38,27.8) ; R286.2 R255.2 98.02,52.18 97.38,51.54 v2(97.38,51.48) ; R517.1 26.93,51.84 27.03,51.94 v2(27.03,51.98) ; R492.1 53.66,31.86 v2(53.16,32.37) 53.03,32.5 53.03,32.52 52.44,33.1 D13.2 ; R79755.1 45.28,17.64 v2(45.41,17.77) 46.11,17.77 R9533.1 46.23,17.51 R9532.1 46.23,16.18 46.69,15.72 48.48,15.72 49.76,14.44 50.53,14.44 51.39,13.58 R747.1 51.45,12.46 52.04,11.87 52.04,10.83 51.61,10.4 R79771.1 ; R270.2 v2(111.19,70.73) ; v2(22.55,19.8) 22.23,19.48 R748.2 R740.1 ; v4(121.23,49.14) 121.23,48.94 121.04,48.75 R262.2 121.16,46.66 121.49,46.33 122.38,46.33 v2(122.4,46.32) ; C836.2 96.65,116.95 R584.1 97.48,117.14 97.48,117.31 97.89,117.72 98.24,117.72 v2(98.75,118.22) 98.21,118.76 Q54.S 97.55,118.81 R586.2 ; 158.38,47.87 157.57,48.68 154.83,48.68 153.87,49.64 153.87,51.08 C12201.1 153.29,51.23 152.88,50.81 152.27,50.81 v2(152.19,50.74) 151.14,49.68 R2087.1 R1598.1 R2088.1 ; R79932.1 135.73,99.64 135.73,99.8 136.88,100.95 140.4,100.95 v2(141.04,100.32) 140.28,99.55 139.52,99.55 138.94,98.98 R79938.2 ; 151.82,59.04 151.81,59.05 151.81,60.04 R154.2 151.82,60.35 151.78,60.39 151.78,60.84 v2(151.81,60.87) ; v2(174.05,62.72) 173.81,62.72 173.75,62.79 R373.1 ; R1762.1 29.33,124.69 29.33,112.87 29.33,112.24 29.81,111.77 v2(31.03,111.77) ; R436.1 v2(51.5,39.61) ; R426.2 60.65,14.65 60.65,14.74 60.01,15.38 v2(60.04,15.38) ; R391.2 183.13,37.02 v2(182.57,37.58) ; R79174.2 v2(23.31,25.39) ; R79171.1 v2(40.33,17.64) ; v4(19.37,24.04) 19.28,24.04 17.98,22.74 R530.2 ; v2(90.47,63.49) 90.73,63.74 R335.1 91.7,64.16 92.09,64.55 94.66,64.55 95.47,63.74 R265.2 ; v2(113.43,67.94) 113.48,67.99 R249.2 R264.2 ; R133.1 152.28,98.68 v2(152.06,98.89) ; v2(16.63,159.5) 16.63,160.2 R1964.1 ; R161.2 v2(165.55,80.76)
  TOP w0.635: v2(185.49,197.85) 185.49,197.48 183.92,195.91 182.1,195.91 179.39,198.61 v2(178.38,198.61) 177.87,199.12 F20.1 176.98,199.3 R473.1
  L3 w0.508: v2(23.31,25.39) 21.53,23.61 21.53,23.58 v4(21.41,23.45) ; v4(139.9,46.32) 137.97,48.25 137.97,54.27 LPC1.4 ; v2(30.93,85.23) 31.03,85.33 46.58,85.33 47.84,84.08 50.73,84.08 51.63,83.17 51.63,82.16 55.95,77.84 55.95,76.95 58.24,74.66 62.09,74.66 64.59,72.16 69.37,72.16 v2(74.24,67.3) ; v4(29.15,17.89) v2(29.15,21.2) 29.15,24.28 v2(30.01,25.13) ; v4(149.42,38.21) 150.5,39.29 150.5,45.9 v4(150.18,46.21) ; v2(36.77,41.77) 36.71,41.77 35.22,40.28 35.22,33.16 v2(35.63,32.75) ; v2(122.4,46.32) 125.44,46.32 126.89,47.77 126.89,49.92 126.82,49.99 v2(126.82,58.91) ; v2(158.95,86.35) 158.12,85.52 158.12,84.38 157.3,83.55 157.3,82.66 v2(156.28,81.65) 157.57,81.65 158.57,82.64 v2(162.73,82.64) ; v4(158.95,35.04) 159.48,34.5 159.48,28.03 160.27,27.24 v4(160.27,21.1) ; v2(152.44,76.74) 152.44,76.75 153.39,77.69 158.84,77.69 v2(158.92,77.61) ; v2(152.19,50.74) 152.19,54.55 152.29,54.65 152.29,55.56 150.95,56.9 150.95,60.06 151.78,60.9 v2(151.81,60.87) ; v2(17.6,91.17) 20.9,87.87 v2(31.03,87.87) ; v2(27.03,51.98) 26.65,51.6 25.85,51.6 21.96,47.71 21.96,42.58 v2(20.26,40.88) 20.26,36.44 19.63,35.8 v2(19.63,31.67) ; v4(103.96,123.37) 103.96,123.68 101.67,125.97 97.99,125.97 97.22,126.73 94.89,126.73 93.13,128.48 92.76,128.48 92.37,128.87 92.37,129.25 91.97,129.65 87.86,129.65 v2(87.06,130.45) ; v2(20.01,100.72) 23.23,103.95 v2(23.23,106.62) 21.33,106.62 18.41,109.54 18.41,110.68 v2(17.47,111.62) 17.47,114.75 18.87,116.15 18.87,125.21 20.8,127.14 v2(20.8,128.38) ; v2(134.69,97.01) 134.69,96.94 135.37,96.25 135.37,95.11 136.47,94.02 136.8,94.02 v2(136.84,94.05) ; v4(19.25,249.8) 12.01,242.56 10.01,242.56 3.42,235.97 3.42,176.34 v2(9.98,169.79) 12.01,167.75 v2(15.69,167.75) ; v2(152.06,98.89) 152.22,98.74 152.22,97.34 152.21,97.33 152.21,96.78 152.22,96.77 152.22,96.38 154.63,93.97 154.63,93.38 156.03,91.98 v2(156.03,90.69)
  L4 w0.381: v2(152.44,76.74) 152.39,76.74 151.39,75.74 150.6,75.74 150.31,76.03 148.35,76.03 148.33,76.06 147.52,76.06 147.44,76.13 146.95,76.13 146.92,76.1 146.28,76.1 146.19,76.01 146.05,76.01 146.02,75.98 145.54,75.98 145.52,76.01 144.8,76.01 144.42,75.63 144.42,74.95 144.03,74.57 142.78,74.57 142.74,74.6 142.05,74.6 141.65,74.2 141.65,73.98 141.2,73.52 v2(141.2,73.35)
  L4 w0.508: v2(22.55,19.8) 21.41,20.94 v4(21.41,23.45) ; v2(30.1,29.35) 30.38,29.35 33.78,32.75 v2(35.63,32.75) ; 158.92,77.58 v2(158.92,77.61) ; 158.92,77.58 158.92,75.13 v2(159.2,74.85) ; 158.92,77.58 162.63,81.29 162.63,81.32 162.73,81.42 v2(162.73,82.64) ; v4(160.27,21.1) 163.1,21.1 168.24,15.96 172.17,15.96 179.52,23.31 179.52,27.34 180.88,28.69 v2(183.38,28.69) ; v2(40.33,17.64) 40.53,17.64 41.01,17.15 41.01,16.17 40.89,16.04 40.89,15.49 41.65,14.72 44.06,14.72 44.67,15.33 44.67,17.03 v2(45.41,17.77) 46.94,17.77 47.86,18.68 49.75,18.68 50.18,18.25 53.76,18.25 v2(54.55,19.04) 57.07,19.04 57.09,19.06 v2(57.14,19.06) 60.04,16.17 v2(60.04,15.38) ; v2(155.14,243.45) 155.77,242.81 159.74,242.81 170.27,232.27 170.27,229.7 185.49,214.49 v2(185.49,197.85) 186.62,196.72 186.62,150.42 186.79,150.25 v2(186.79,149.81) ; v2(126.82,58.91) 126.82,59.5 125.91,60.4 125.91,60.84 123.5,63.26 120.62,63.26 119.86,64.02 119.86,64.32 118.94,65.24 118.67,65.24 117.02,66.89 115.97,67.94 v2(113.43,67.94) 111.19,70.18 v2(111.19,70.73) ; v2(165.55,80.76) 165.55,82.51 v2(165.68,82.64) ; v2(51.5,39.61) 49.98,39.61 48.63,40.96 41.48,40.96 40.51,41.93 40.51,43.39 v2(40.55,43.44) ; v4(158.95,35.04) 153.36,35.04 150.44,37.96 149.68,37.96 v4(149.42,38.21) ; v2(182.41,81.06) 180.84,81.06 178.67,78.89 178.67,75.49 173.9,70.72 v2(173.9,67.71) 173.45,67.26 173.45,63.32 v2(174.05,62.72) 173.42,62.1 173.42,57.72 174.17,56.98 174.21,56.98 v2(174.44,56.76) 174.44,56.56 173.44,55.56 171.85,55.56 171.29,56.12 169.36,56.12 168.97,55.73 168.97,55.62 v2(168.87,55.52) 168.24,54.89 157.07,54.89 152.92,50.74 v2(152.19,50.74) ; v2(152.06,98.89) 152.04,98.92 151.73,98.92 151.37,98.56 150.16,98.56 148.83,99.9 147.39,99.9 147.36,99.9 147.1,99.63 147.09,99.63 146.46,99 144.32,99 143.64,99.67 v2(143.08,99.67) 141.69,99.67 v2(141.04,100.32) ; v2(19.63,31.67) 21.79,29.51 21.79,26.91 v2(23.31,25.39) 24.15,25.39 26.72,22.82 27.53,22.82 v2(29.15,21.2) ; v2(20.8,128.38) 20.8,129.91 21.37,130.48 21.37,138.17 v2(19.98,139.56) 20.64,140.21 20.64,147.35 20.26,147.73 20.26,157.97 v2(20.9,158.61) 17.52,158.61 v2(16.63,159.5) 16.63,164.91 15.69,165.85 v2(15.69,167.75) ; v2(20.01,100.72) 18.48,99.2 18.48,99.1 18.48,92.06 v2(17.6,91.17) 16.3,91.17 13.71,88.58 13.71,68.89 25.52,57.08 25.52,52.85 26.39,51.98 v2(27.03,51.98)
  L4 w0.762: 170.38,135.75 170.38,131.05 v2(171.39,130.03) ; v2(194.25,135.5) 193.11,135.5 191.28,137.32 191.28,137.93 189.05,140.16 189.05,147.55 v2(186.79,149.81)
  L4 w1.27: v2(95.57,107.43) 94.73,106.59 94.73,105.09 95.98,103.85 95.98,91.72 96.37,91.33 96.37,88.81 96.36,88.8 96.36,87.95 95.44,87.03 95.44,83.75 91.1,79.41 91.1,73.54 91.51,73.14 ; 122.37,129.91 122.37,127.37 118.37,123.37 v4(103.96,123.37) ; 153.87,133.84 153.87,133.21 151.96,131.3 134.44,131.3 133.01,129.88 v4(132.94,129.88)
  BOTTOM w0.203: 190.19,145.15 190.39,144.94 U14.11
  BOTTOM w0.508: D4.K 8.64,168.9 R359.1 9.4,169.21 v2(9.98,169.79) ; 83.25,69.33 83.25,70.22 82.57,70.9 80.35,70.9 79.67,70.22 79.12,70.22 79.08,70.27 77.72,70.27 76.02,68.57 74.95,68.57 74.24,67.85 v2(74.24,67.3) ; R263.2 R324.1 119.53,59.82 R296.2 ; v2(20.26,40.88) 20.14,40.75 17.68,40.75 17.01,41.42 17.01,42.65 R524.1 ; v2(30.9,108.04) 30.24,108.7 30.24,110.86 31.03,111.65 v2(31.03,111.77) ; R79810.1 35.96,41.08 36.65,41.77 ; v2(31.03,87.87) 31.03,85.33 v2(30.93,85.23) ; v2(146.17,133.62) 146.75,134.2 C128.1 146.79,135.52 C129.1 ; v4(158.95,35.04) 159.26,35.36 R1594.1 ; v2(136.84,94.05) 137.08,94.05 R1684.1 138.12,92.76 R1659.1 ; v2(178.38,198.61) 178.99,199.22 178.99,202.79 178.56,203.21 177.64,203.21 177.08,202.65 173.07,202.65 171.27,204.46 ; v2(19.63,31.67) 19.79,31.67 20.45,31.01 R79737.1 ; v2(40.33,17.64) 39.44,17.64 38.17,16.37 33.47,16.37 31.95,17.89 v4(29.15,17.89) ; v4(21.41,23.45) 20.97,23.89 19.53,23.89 v4(19.37,24.04) 18.66,24.04 17.49,22.87 14.95,22.87 12.77,20.69 8.04,20.69 7.63,20.27 R134.1 7.63,19.56 7.3,19.23 v2(4.13,19.23) ; v2(152.06,98.89) 152.22,98.74 152.22,98.09 R133.1 ; v2(53.16,32.37) 53.43,32.09 53.43,29.35 54.22,28.56 54.22,27.23 55.09,26.37 55.09,25.49 55.2,25.38 55.2,23.36 56.22,22.34 56.56,22.34 57.35,21.55 57.35,21.44 57.7,21.1 57.7,19.61 v2(57.14,19.06) 56.84,18.76 56.84,17.11 57.03,16.92 R9543.1 55.9,16.5 55.12,15.72 R79838.1 ; v4(121.23,49.14) 120.02,47.93 R79922.2 117.59,47.93 R80018.2 R269.2 116.52,47.94 R268.2 114.42,47.94 114.41,47.95 R267.2 R257.1 ; v2(19.98,139.56) 19.86,139.43 18.67,139.43 v2(17.09,137.84) ; v2(183.38,28.69) 183.38,28.74 184.35,29.7 184.35,35.8 v2(182.57,37.58) ; 171.27,204.46 172.41,205.6 172.41,206.3 R1955.1 ; 171.27,204.46 v2(170.57,204.46) ; v2(30.01,25.13) 30.1,25.23 R79867.1 30.1,29.34 v2(30.1,29.35) ; 36.65,41.77 v2(36.77,41.77) ; 36.65,41.77 37.66,42.79 39.72,42.79 40.37,43.44 v2(40.55,43.44) ; v2(142.94,91.73) 142.94,91.2 143.4,90.74 R79767.2 R158.2 ; R79766.2 158.56,77.29 158.88,77.61 v2(158.92,77.61) ; v2(60.04,15.38) 60.21,15.38 65.47,20.64 65.47,25.89 v2(67.38,27.8) ; v4(89.54,68.63) v4(88.84,67.93) 88.91,67.87 88.91,65.06 v2(90.47,63.49) 89.96,62.97 89.96,61.05 90.37,60.64 93.67,60.64 95.28,59.02 95.28,58.74 95.7,58.32 95.7,55.74 95.07,55.1 95.07,53.67 95.79,52.95 95.85,52.95 95.88,52.92 96.94,52.92 97.38,52.48 v2(97.38,51.48) 97.82,51.04 v3(99,51.04) 104.85,51.04 112.98,42.91 113.49,42.91 113.79,42.61 114.34,42.61 114.72,42.99 115.13,43.4 115.13,44.69 116.25,45.81 120.39,45.81 121.2,45.81 121.72,46.33 122.38,46.33 v2(122.4,46.32) 122.9,45.81 133.35,45.81 136.07,48.53 137.71,48.53 139.9,46.34 v4(139.9,46.32) ; v2(167.16,47.36) 167.16,47.57 169.49,49.9 174.95,49.9 175.2,50.15 175.2,53.96 C227.1 C220.1 175.65,55.68 C219.1 C228.1 175.33,57.52 174.57,56.76 v2(174.44,56.76) ; R73.2 170.01,136.77 v2(170.09,136.69) ; C104.1 164.6,135.3 164.53,135.37 164.15,135.37 164.09,135.3 C105.1 163.71,135.3 163.52,135.5 163.1,135.5 v4(162.95,135.65) 162.02,136.57 R85.1 ; R290.2 124.23,55.23 126.82,57.82 v2(126.82,58.91) ; v2(165.68,82.64) v2(162.73,82.64) ; v2(34.87,256.02) 34.87,258.05 33.72,259.19 23.56,259.19 18.84,254.47 18.84,250.2 v4(19.25,249.8) ; R79951.1 143.21,99.8 v2(143.08,99.67) 143.08,97.97 R168.2 R79939.2 143.74,95.17 R79941.2 R79940.2 142.96,93.37 142.96,92.71 v2(142.94,92.7) ; v2(17.47,111.62) 16.58,111.62 15.5,110.54 PR5518.1 ; 112.64,61.91 112.64,67.16 v2(113.43,67.94) ; v2(159.2,74.85) 158.18,74.85 R196.1 158.12,74.57 157.61,74.06 R197.1 ; R342.1 154.03,88.7 v2(156.03,90.69) 156.15,90.56 157.5,90.56 157.78,90.28 157.78,90.12 R175.2 R174.2 R172.2 R165.2 158.69,86.47 158.82,86.35 v2(158.95,86.35)
  BOTTOM w0.762: v2(171.39,130.03) 171.73,129.7 191.25,129.7 193.73,132.18 R79842.1 193.73,134.97 v2(194.25,135.5)
  BOTTOM w1.27: v2(95.57,107.43) 96.3,108.16 96.57,108.16 97.31,108.89 97.31,109.76 96.77,110.3 96.77,111.9 98.21,113.35 98.21,117.69 v2(98.75,118.22) 98.75,118.68 103.43,123.37 v4(103.96,123.37) ; v4(181.53,49.9) 181.53,46.85 180.92,46.24 179.14,46.24 178.68,46.7 177.82,46.7 176.57,47.94 176.57,48.78 175.2,50.15
  vias: v3(84.27,68.69) v3(124.66,131.18) v3(131.9,130.75) v4(123.13,130.92)
VCC3_CAM:
  vias: v1(175.96,207.5)
VCC3_CT2: length 3.2
  BOTTOM w0.203: v3(83.46,67.35) 83.03,67.35 82.49,66.81 U21.10
  BOTTOM w0.254: v3(83.46,67.35) 84,67.35 C369.1
VCC3_EN: length 6.2
  TOP w0.102: R506.2 C367.1 77.67,66.79 v2(77.84,66.97)
  BOTTOM w0.102: v2(77.84,66.97) 77.44,66.97 77.18,67.22 v3(77.18,67.73) 77.36,67.91 77.82,67.91 78.92,66.81 U21.5
VCC5_DDC_HDMI: length 5.9
  TOP w0.254: C12443.1 167.84,43.19 v2(167.71,43.32) ; C12443.1 166.95,42.47 R2083.1 ; C12443.1 168.73,42.47 R2084.1
  BOTTOM w0.254: v2(167.71,43.32) 168.09,42.94 D23.K 168.09,40.63 v3(168.22,40.5)
VCC5_PANEL: length 23.5
  TOP w0.508: R1163.1 23.69,52.67 v2(23.56,52.79)
  L4 w0.508: v2(23.56,52.79) 23.15,52.79 22.42,52.06 22.42,50.53 23.44,49.52 23.44,38.09 20.9,35.55 v2(20.64,35.55)
  BOTTOM w0.508: R79729.1 22.17,35.55 v3(22.04,35.67) 21.91,35.8 20.9,35.8 v2(20.64,35.55)
  vias: v4(23.44,55.36) v4(23.56,56.63)
VCC5_USB: length 278.7
  TOP w0.508: v2(82.77,59.6) 82.82,59.55 C373.2
  L3 w0.508: v2(186.94,102.09) 186.94,90 184.37,87.44 181.93,87.44
  L3 w1.27: v4(90.4,35.39) 90.4,35.03 85.96,30.58 85.96,23.4 85.02,22.47 83.69,22.47 79.32,18.1 65.3,18.1 62.45,15.25 62.45,8.14 58.74,4.43 41.22,4.43 37.89,7.76 37.89,9.23 35.73,11.39 28.44,11.39 27.6,12.23 27.6,12.99 26.38,14.21 21.53,14.21 19.53,16.22 17.04,16.22 16.43,16.83 16.43,21.47 15.98,21.92 15.98,30.95 16.63,31.6 16.63,44.39 15,46.01 v4(15,50.58) ; v4(17.98,134.96) 17.85,134.83 17.85,116.57 16.43,115.15 16.43,111.19 17.39,110.22 17.39,107.4 18.13,106.67 18.13,104.53 16.58,102.98 16.58,96.38 16.07,95.87 v4(16.07,89.9)
  BOTTOM w0.305: 182.64,102.17 182.37,102.45 U9625.1
  BOTTOM w0.508: v2(186.94,102.09) 186.87,102.03 C314.1 183.75,102.03 183.69,102.09 182.72,102.09 182.64,102.17
  BOTTOM w1.27: F12.1 16.66,134.96 v4(17.98,134.96) ; v4(90.4,35.39) 90.4,42.82 91.89,44.31 91.89,44.56 ; v4(16.07,89.9) 11.96,85.79 6.55,85.79 3.44,82.67 3.44,67.23 4.97,65.7 12.85,65.7 15,63.55 v4(15,50.58)
  vias: v3(86.2,51.62) v3(93.34,45.45) v3(105.96,44.79) v3(110.36,26.58) v3(111.27,11.09) v4(107.99,37.35) v4(109.06,36.41) v4(110.84,8.88) v4(110.84,7.61) v4(111.7,22.32) v4(111.7,21.17) v4(112.08,8.88) v4(112.08,7.61) v4(179.56,87.85) v4(180,86.93) v4(180.47,87.79)
VCC_CT1: length 3
  BOTTOM w0.203: v3(83.46,65.62) 83.08,65.62 82.69,66.01 U21.12
  BOTTOM w0.254: C370.1 83.69,65.85 v3(83.46,65.62)
VCC_EN: length 4.6
  TOP w0.102: R505.2 C368.1 77.74,65.77 v2(77.84,65.87)
  BOTTOM w0.102: v3(77.01,65.87) v2(77.84,65.87) 77.92,65.95 78.62,65.95 78.67,66.01 U21.3
VCC_RTCEXT_CAP: length 3.8
  TOP w0.254: U2.BA26 149.95,79.14 149.95,79.13 v5(149.95,79.02)
  BOTTOM w0.254: C1935.1 152.19,79.54 151.7,79.05 v3(151.68,79.05) 151.52,79.05 151.05,79.51 150.63,79.51 150.13,79.02 v5(149.95,79.02)
VCCEOPIO_SENSE: length 1.5
  TOP w0.254: v5(82.75,192.26) CPU1.AJ24
  BOTTOM w0.254: TP249.1 82.37,192.65 v5(82.75,192.26)
VCCGT_VCC_SEN: length 58.1
  TOP w0.254: v2(61.8,205.88) 61.82,205.88 CPU1.F39
  L3 w0.254: v2(61.8,205.88) 61.45,205.88 60.93,206.4 60.93,207.4 59.23,209.09 56.32,209.09 53.54,211.87 53.54,220.87 53.28,221.12 53.28,232.35 51.15,234.47 51.15,237.19 51.61,237.64 51.61,238.21 51.15,238.66 51.15,239.22 51.61,239.68 51.61,240.24 51.15,240.69 51.15,241.26 51.61,241.71 51.61,242.27 51.15,242.72 51.15,244.55 51.45,244.85 51.45,245.57 51.15,245.87 51.15,246.59 51.45,246.89 51.45,247.6 51.15,247.9 51.15,250.3 51.79,250.94 52.59,250.94 v2(52.82,250.7)
  BOTTOM w0.254: PR4412.2 51,250.62 R79761.2 52.33,250.94 52.59,250.94 v2(52.82,250.7) 53.31,250.22 v3(53.31,249.93)
VCCGT_VSS_SEN: length 59.3
  TOP w0.254: CPU1.F38 62.24,204.55 v2(61.8,204.99)
  L3 w0.254: v2(52.9,251.64) 52.58,251.32 51.63,251.32 50.77,250.46 50.77,234.32 52.9,232.19 52.9,220.97 53.16,220.71 53.16,211.71 56.16,208.71 59.08,208.71 60.55,207.24 60.55,206.24 v2(61.8,204.99)
  BOTTOM w0.254: v3(53.71,252.29) 53.56,252.29 v2(52.9,251.64) 52.58,251.32 52.33,251.32 R79762.1 51,251.64 PC4412.2 PR4413.1
VCCGTX_SENSE: length 2.1
  TOP w0.254: CPU1.F37 62.24,203.75 61.91,204.08 v2(61.78,204.08)
  BOTTOM w0.254: TP228.1 62.53,204.84 v2(61.78,204.08)
VCCIO_SENSE: length 118.2
  TOP w0.254: CPU1.AF4 80.1,170.77 80.1,167.52 v2(79.57,166.99) ; PR4802.1 24.33,165.53 24.33,169.33 25.14,170.14 25.14,171.51 25.68,172.05 v2(34.64,172.05)
  L3 w0.254: v2(62.83,143.83) 81.55,143.83 v2(84.91,147.18)
  BOTTOM w0.254: 85.95,151.5 85.95,155.82 79.06,162.7 79.06,166.48 v2(79.57,166.99) ; 85.95,151.5 v3(86.18,151.5) ; 85.95,151.5 85.95,148.22 v2(84.91,147.18) ; v2(34.64,172.05) 34.64,172.55 34.89,172.81 39.92,172.81 40.1,172.63 40.1,159.05 40.1,158.73 46.14,152.69 56.25,152.69 60.9,148.04 60.9,145.65 62.17,144.39 62.27,144.39 v2(62.83,143.83)
VCCK_1V2: length 68.9
  TOP w0.305: 38.68,28.82 38.68,28.31 38.51,28.14 SCA1.120 ; v2(31.08,42.15) 30.42,42.15 29.62,42.96 SCA1.73 ; SCA1.60 v2(32.01,46.85)
  TOP w0.508: L9523.1 49.5,41.54 v2(49.5,42.4) ; v2(31.08,42.15) 31.23,42 35.6,42 36.26,42.66 38.45,42.66 v2(40.35,44.56) ; v2(38.17,29.45) 38.68,28.94 38.68,28.82
  L3 w0.508: v2(31.08,42.15) 31.18,42.15 32.01,42.98 32.01,45.5 32.1,45.58 32.1,46.34 32.01,46.42 v2(32.01,46.85)
  L4 w0.508: v2(38.17,29.45) 36.7,30.92 36.7,32.62 35.67,33.64 32.2,33.64 30.17,31.61 v2(30.17,31.48) ; v2(49.5,42.4) 49.5,42.2 48.89,41.59 42.04,41.59 41.27,42.37 41.27,43.65 v2(40.35,44.56)
  BOTTOM w0.508: v2(31.08,42.15) 30.57,42.66 29.41,42.66 C12196.1 28.58,42.72 25.98,40.12 v3(25.98,36.99) 25.98,32.5 26.49,31.99 C12169.1 L9504.2 28.9,31.48 v2(30.17,31.48) ; v2(32.01,46.85) 32.01,47.04 32.07,47.1 C12195.1 ; C12183.2 38.49,27.86 38.8,28.18 38.8,28.82 v2(38.17,29.45)
VCCOPC_SENSE: length 2.5
  TOP w0.254: v2(83.76,189.47) 83.76,189.34 84.11,189 CPU1.AK21
  BOTTOM w0.254: TP250.1 83.38,189.09 v2(83.76,189.47)
VCCSA_SENSE: length 90.2
  TOP w0.254: CPU1.AD5 v2(77.33,171.71) ; v2(25.14,131.1) 24.39,130.35 PR15.2 23.56,130.35 PR16.2 PR17.2
  L3 w0.254: v2(25.14,131.1) 25.57,131.1 26.28,130.39 33.4,130.39 40.03,137.02 43.17,137.02 43.95,136.23 49.41,136.23 50.08,135.56 50.08,134.32 50.83,133.56 58.77,133.56 v2(58.84,133.49)
  L4 w0.254: v2(58.84,133.49) 58.84,133.84 61.77,136.77 62.43,136.77 69.41,143.75 69.41,153.71 76.6,160.89 76.6,170.88 77.33,171.6 v2(77.33,171.71)
  BOTTOM w0.254: v3(25.14,130.19) v2(25.14,131.1)
VCCST_PWRGD: length 236.1
  TOP w0.102: v2(65.6,142.23) 65.6,140.9 62.91,138.21 61.11,138.21 60.65,138.67 R33.1 59.76,137.79 59.76,136.59 56.41,133.23 56.41,129.6 54.55,127.75 51.03,127.75 50.99,127.7 50.99,127.65 48.95,125.61 47.35,125.61 R1777.1 ; v2(19.5,253.22) 20.01,253.73 20.01,253.99 20.77,254.75 R1972.2
  L3 w0.127: v2(65.6,142.23) 65.51,142.31 58.7,142.31 56.88,140.49 47.15,140.49 43.75,143.88 34.06,143.88 32.96,142.78 31.93,142.78 31.65,142.51 31.65,137.29 33.34,135.6 33.34,133.97 31.57,132.19 22.96,132.19 21.6,130.83 20.07,130.83 18.87,132.04 18.87,137.12 17.13,138.85 17.13,156.39 17.56,156.82 17.56,159.77 9.72,167.61 9.58,167.61 2.72,174.47 2.72,236.25 15.06,248.59 16.73,248.59 19.5,251.35 v2(19.5,253.22)
  BOTTOM w0.102: R1971.1 22.94,257.09 v3(21.38,255.53) 19.5,253.65 v2(19.5,253.22)
VCCST_PWRGD_CPU: length 59.7
  TOP w0.102: CPU1.U2 71.5,169.42 71.71,169.21 71.71,168.32 71.7,168.31 71.7,164.13 71.74,164.09 71.74,162.19 79.44,154.49 79.44,144.18 v1(81.28,142.35) 82.16,141.46 82.16,141.02 82.73,140.45 v2(83.25,140.45) ; v2(62.69,140.14) 62.68,140.14 62.68,139.81 62.43,139.55 R35.2 R33.2
  L3 w0.127: v2(83.25,140.45) 82.57,140.45 82.25,140.77 65.86,140.77 64.94,141.68 62.61,141.68 62.34,141.4 62.34,140.49 v2(62.69,140.14)
VCCST_PWRGD_L: length 3.2
  BOTTOM w0.102: U176.3 v3(25.49,257.18) 23.84,257.18 R1971.2
VSS_OPC_EOPIO_SENSE: length 2.6
  TOP w0.254: CPU1.AK22 84.14,189.98 84.02,189.98 83.76,190.23 v2(83.76,190.36)
  BOTTOM w0.254: v2(83.76,190.36) 82.62,190.36 TP248.1
VSS_SA_IO_SENSE: length 208.6
  TOP w0.254: CPU1.AE4 78.62,171.25 v5(78.18,170.81) ; v2(25.99,131.43) 25.77,131.43 25.64,131.56 25.44,131.56 24.96,132.03 24.96,132.64 PR18.1 25.97,133.65 PU28.11 ; PR4803.1 23.31,165.47 23.95,166.1 23.95,169.51 24.73,170.29 24.73,171.64 25.52,172.43 33.8,172.43 v2(33.98,172.6)
  L3 w0.254: v2(59.81,134.02) 59.75,134.09 58.48,134.09 58.46,134.07 51.04,134.07 50.59,134.53 50.59,135.77 49.62,136.74 44.16,136.74 43.38,137.53 39.82,137.53 33.19,130.9 26.53,130.9 v2(25.99,131.43) ; v2(62.78,144.77) 63.34,144.21 81.32,144.21 84.3,147.18 84.3,147.41 v2(85.01,148.12)
  L4 w0.254: v2(59.81,134.02) 59.81,134.09 61.98,136.26 62.64,136.26 67.85,141.46 68.4,141.46 68.9,141.97 68.9,142.52 69.92,143.54 69.92,143.96 69.92,143.96 69.92,153.5 71.72,155.3 71.97,155.3 72.12,155.15 72.39,155.15 72.57,155.33 72.57,155.59 72.42,155.74 72.42,156 72.62,156.19 72.87,156.19 73.02,156.04 73.28,156.04 73.47,156.23 73.47,156.49 73.32,156.64 73.32,156.9 77.11,160.68 77.11,161.1 77.11,164.03 77.08,164.05 77.08,169.71 v5(78.18,170.81)
  BOTTOM w0.254: v2(85.01,148.12) 85.08,148.12 85.57,148.6 85.57,155.54 78.66,162.45 78.66,166.74 78.91,166.99 v3(78.91,168.64) 78.91,170.34 78.45,170.81 v5(78.18,170.81) ; v2(33.98,172.6) 34.56,173.19 40.08,173.19 40.48,172.79 40.48,158.89 46.22,153.15 56.33,153.15 61.28,148.2 61.28,145.81 62.33,144.77 v2(62.78,144.77)
VSSGTX_SENSE: length 1.6
  TOP w0.254: CPU1.F36 v2(61.78,203.17)
  BOTTOM w0.254: v2(61.78,203.17) 62.17,203.17 62.55,203.55 TP229.1
3D3V_RUN_FFS: length 26.9
  TOP w0.305: U6701.8 30.99,113.28 C12239.1 30.87,113.78 U6701.7 ; U6701.14 36.13,113.28 v2(36.39,113.02) ; 35.25,115 U6701.1
  TOP w0.508: 35.25,115 35.71,115.46 35.71,115.56 35.93,115.78 36.16,115.78 36.38,116 C6702.1 36.58,116.19 C12240.1 37.69,116.04 37.69,114.31 v2(36.39,113.02) 36.34,112.97 36.34,110.76 34.94,109.36 34.94,107.76 R6701.2 ; C12239.1 30.04,112.95 30.04,112.61 v1(30.09,112.56) 30.1,112.55 v2(31.08,112.55)
  L3 w0.508: v2(36.39,113.02) 35.88,112.51 31.59,112.51 31.52,112.58 31.11,112.58 v2(31.08,112.55)
3P3V_LAN: length 96.8
  TOP w0.203: C12121.1 64.93,26.95 U9623.11 ; 60.24,30.65 60.66,30.22 U9623.23
  TOP w0.508: R438.1 55,46.24 54.71,45.95 54.71,45.35 54.19,44.84 54.19,40.27 55.36,39.1 55.36,35.8 v2(57.47,33.69) 58.69,33.69 C299.1 ; U9624.5 92.33,28.05 91.5,27.23 C3453.1 88.96,27.23 88.33,26.61 v2(88.33,23.61) ; U9614.5 60.09,20.38 v2(60.14,20.43) ; R79618.1 99.97,27.73 v2(100.6,28.36) ; C12121.1 65.6,26.4 66.19,25.82 66.19,25.51 v2(66.16,25.49) ; v2(64.33,20.43) 64.2,20.31 U11.5
  TOP w0.762: C299.1 C298.1 59.25,31.63 60.24,30.65
  L3 w0.508: v2(88.33,23.61) 88.33,25.26 89.99,26.91 92.27,26.91 93.03,27.67 99.76,27.67 100.4,28.31 100.53,28.31 100.58,28.36 v2(100.6,28.36)
  L4 w0.508: v2(64.33,20.43) 65.6,19.16 78.68,19.16 82.52,23 87.72,23 v2(88.33,23.61)
  BOTTOM w0.508: v2(64.33,20.43) 64.33,21.13 C12128.1 63.51,20.81 C296.1 C297.1 ; 59,23.86 57.47,23.86 56.15,25.18 56.15,26.07 v2(56.05,26.17) 56.05,27.57 55.09,28.54 55.09,28.92 54.3,29.7 54.3,31.53 56.56,33.79 57.37,33.79 v2(57.47,33.69)
  vias: v1(55.3,27.28) v2(58.49,25.26) v3(59.17,20.05)
3P3V_SPI: length 201.4
  TOP w0.305: U2.BE43 U2.BE42 U2.BE41 153.15,86.81 v4(153.23,86.73)
  TOP w0.508: v2(59.84,139.94) 59.33,139.43 59.33,136.84 55.97,133.49 55.97,130.9 v1(54.96,129.88) 53.97,128.89 49.28,128.89 R79874.1 ; v2(168.06,85.41) 168.38,85.09 SRCON1.8 U9622.8 168.92,85.77 168.47,86.22 v2(165.68,86.22) 165.68,87.74 167.01,89.08 C202.1 167.84,90.47 R345.1
  L3 w0.508: v2(150.44,116.93) 142.33,116.93 139.29,119.98 129.91,119.98 110.84,139.05 84.87,139.05 84.49,139.43 62.17,139.43 61.66,139.94 v2(59.84,139.94) ; v2(162.4,84.7) 162.4,85.54 160.59,87.35 158.48,87.35 157.85,86.73 v4(153.23,86.73) ; v2(162.4,84.7) 161.95,84.7 161.87,84.77 161.32,84.77 161.25,84.7 159.23,84.7 v2(158.85,85.08) ; v2(162.4,84.7) 162.45,84.65 162.45,84.65 162.56,84.54 164,84.54 v2(165.68,86.22)
  L4 w0.508: v2(162.4,84.7) 162.4,84.98 162.52,85.1 162.52,85.96 161.79,86.69 161.79,95.24 155.64,101.39 155.64,103.54 151.35,107.83 151.35,111 150.44,111.92 v2(150.44,116.93) ; v2(158.85,85.08) 158.85,84.66 159.67,83.85 159.67,81.53 159.25,81.11 159.01,81.11 158.99,81.09 v2(158.92,81.09)
  BOTTOM w0.254: v2(150.44,116.93) 149.5,116.93 v3(149.45,116.98) ; v3(170.22,84.47) 170.19,84.5 R343.1
  BOTTOM w0.508: R1797.2 159.2,80.89 159,81.09 v2(158.92,81.09) 158.87,81.09 158.54,80.76 R236.2 ; R1828.2 158.27,84.97 158.75,84.97 v2(158.85,85.08) ; R1800.2 160.72,84.63 161.04,84.63 161.23,84.82 162.27,84.82 v2(162.4,84.7) ; v2(168.06,85.41) 168.31,85.41 R343.1
14MHZ_IN_SCALAR: length 6.5
  TOP w0.102: X9502.3 44.73,22.22 C9520.1 44.58,23.49 R9547.2 44.58,24.99 v1(44.32,25.26) 43.77,25.81 43.31,25.81 42.51,26.6 SCA1.128
14MHZ_OUT_SCALAR: length 8.2
  TOP w0.102: X9502.1 43.88,21.41 43.88,23.04 C9522.1 43.69,23.44 R9547.1 43.69,24.56 v1(43,25.26) 42.01,26.24 SCA1.127
1117 ADJ: length 6.2
  TOP w0.102: v1(138.75,47.61) R2081.2 140.15,48.12 R1592.1 142.03,50 U119.1
2136_HPD_C: length 4.8
  TOP w0.102: R79763.2 R79764.1 R530.1 R522.2 16.13,21.51 v1(15.69,21.96)
+OPC_FUSEPRG: length 31.5
  TOP w0.102: CPU1.AB38 76.54,204.87 76.54,208.15 v2(77.16,208.77)
  BOTTOM w0.102: TP252.1 94.3,223.7 90.3,219.7 84.43,219.7 76.75,212.02 76.75,209.18 v2(77.16,208.77)
+V_1P05_VGA: length 24.7
  TOP w0.356: v5(75.9,116.21) 75.87,116.21 75.36,116.72 GPU1.AA21
  TOP w0.381: GPU1.AA13 81.92,116.76 v5(82.34,116.34) 82.72,116.73 GPU1.AA12 82.95,116.55 84.19,116.55 84.4,116.75 GPU1.AA10
  TOP w0.508: PR230.1 92.45,124.9 94.3,123.05 94.3,109.71 v2(94.56,109.46)
  BOTTOM w0.508: C445.1 77.41,116.74 77.39,116.72 77.39,116.44 v5(77.29,116.34) ; v2(94.56,109.46) 94.81,109.71 L28.1 94.3,110.96 L29.1
  vias: v3(81.32,116.29) v4(70.3,125.97) v4(71.57,125.97) v4(90.24,128.13) v4(90.24,126.99) v5(73.17,118.78) v5(74.03,117.92) v5(76.57,116.34) v5(78.98,116.37)
+V_1P05_VGA_DISCHIG: length 3.4
  TOP w0.102: Q9632.6 89.27,128.18 v1(89.24,128.15) 88.4,127.3 R80056.1
+V_1P35_VGA: length 154.5
  TOP w0.178: 54.55,99.43 54.61,99.43 v5(55.24,100.06) ; v5(58.04,105.85) 58.84,105.85 VRAM5.H2 59.24,106.3 58.85,106.69 58.85,107.33 58.74,107.43
  TOP w0.18: VRAM1.H2 81.52,88.68 80.7,88.68 v5(80.4,88.99) ; 80.78,87.88 81.47,87.88
  TOP w0.229: v5(58.79,100.19) 58.34,100.19 58.03,100.5 58.03,101.03 57.64,101.42 VRAM5.K8
  TOP w0.254: RN7502.3 60.19,94.39 59.88,94.09 59.88,93.86 v5(59.84,93.82) ; v5(59.68,104.94) 59.35,104.61 59.35,103.62 59.78,103.19 59.81,103.19 60.1,102.91 60.1,102.43 60.04,102.37 VRAM5.G7
  TOP w0.305: v5(72.4,105.53) 72.4,105.6 72.76,105.96 GPU1.H24 ; v5(66.51,92.92) 66.67,93.08 VRAM2.C1 ; GPU1.B26 70.6,100.44 70.6,100.43 v5(70.59,100.42) ; VRAM1.G7 v5(86.32,89.48)
  TOP w0.356: v5(88.11,89.17) 87.61,89.17 VRAM1.H9 ; VRAM5.N1 55.24,107.77 55.29,107.82 55.29,107.83 55.31,107.86 v5(55.31,107.91) ; v5(81.52,92.68) 81.12,93.08 VRAM1.C1 ; v5(82.32,89.48) 82.31,89.48 81.92,89.08 VRAM1.H2 ; VRAM2.R1 66.38,83.48 v5(66.31,83.41) ; v5(53.68,107.72) 53.64,107.69 VRAM5.R1 ; v5(74.05,92.4) 73.93,92.28 VRAM2.D9 ; v5(58.79,100.19) 59.24,100.64 VRAM5.H9 ; v5(61.64,100.01) VRAM5.E9 ; VRAM1.B2 81.92,93.88 v5(81.51,94.28) 81.51,94.29 81.12,94.68 VRAM1.A1 ; v5(66.52,85.18) 66.61,85.08 VRAM2.N1 ; VRAM5.K2 57.64,106.25 v5(58.04,105.85) ; VRAM6.K2 57.64,120.29 v5(58.03,120.68) ; v5(73.08,94.28) 72.69,94.67 VRAM2.A8 ; v5(80.51,90.68) VRAM1.F1 ; VRAM6.D2 62.44,120.27 v5(62.04,119.88) ; VRAM5.B2 64.05,106.25 v5(64.44,106.65) ; v5(74.17,84.86) 74.17,84.89 73.98,85.08 VRAM2.N9 ; VRAM1.R1 v5(80.46,83.48) ; v5(74.08,91.52) 73.53,91.52 VRAM2.E9 ; VRAM1.N1 v5(80.54,85.08) ; v5(73.98,83.15) 73.96,83.15 73.63,83.48 VRAM2.R9 ; VRAM6.N1 55.24,121.78 v5(55.22,121.8) ; VRAM1.N9 v5(88.11,85.08) ; v5(71.32,89.86) 71.34,89.88 VRAM2.G7 ; v5(80.66,104.66) 81.06,105.06 GPU1.G14 ; VRAM1.D9 v5(87.12,92.68) 87.52,93.08 VRAM1.C9 ; VRAM5.D2 VRAM5.C1 ; VRAM1.K8 v5(87.12,87.88) ; VRAM6.K8 57.64,115.48 v5(58.04,115.08) ; VRAM5.A8 65,101.45 v5(65.32,101.13) ; v5(67.47,89.47) 67.48,89.46 67.51,89.46 67.89,89.08 VRAM2.H2 ; v5(58.84,119.88) 59.24,120.28 VRAM6.H2 ; v5(65.29,120.66) 64.87,121.08 VRAM6.A1 ; v5(60.44,115.91) 60.07,116.28 VRAM6.G7 ; VRAM1.K2 81.87,87.48 81.47,87.88 ; VRAM2.K8 72.73,87.52 v5(73.09,87.88) ; VRAM2.A1 67.49,94.28 v5(67.53,94.28) 67.53,94.24 VRAM2.B2 ; v5(63.64,101.05) 63.25,100.65 VRAM5.C9 ; v5(88.16,83.48) VRAM1.R9 ; v5(63.64,119.9) 63.87,120.13 63.89,120.13 VRAM6.B2 ; VRAM2.C9 v5(74.05,93.08) ; VRAM1.A8 v5(87.12,94.28) ; v5(64.44,115.08) 64.84,115.48 VRAM6.A8 ; v5(63.24,121.64) VRAM6.C1 ; v5(62.83,101.05) 62.44,100.66 VRAM5.D9 ; VRAM6.R1 v5(53.64,121.8) ; VRAM1.E9 v5(88.17,91.48)
  TOP w0.381: GPU1.G18 77.76,105.15 v5(77.41,105.5) 77.21,105.5 76.96,105.24 GPU1.G19
  TOP w0.4: v5(73.19,108.01) 73.19,108.03 72.78,108.44 GPU1.L24 ; GPU1.B26 71.58,101.41 71.58,101.42 GPU1.C25 ; GPU1.E23 v5(73.21,103.05) ; v5(70.65,103.16) 70.72,103.23 70.94,103.23 GPU1.E26 ; GPU1.H26 71.16,105.96 v5(70.78,105.57) ; v5(81.52,92.68) 81.92,92.28 VRAM1.D2 ; v5(71.57,108.05) GPU1.L26 ; VRAM5.N9 v5(55.24,100.06) ; VRAM5.R9 v5(53.64,100.01)
  TOP w0.508: C505.1 47.83,102.03 v5(47.77,101.97) ; C12417.1 v2(47.74,99.87) ; R80058.2 93.1,129.21 v2(93.03,129.15) ; R79995.1 v2(89.6,86.78)
  L3 w0.203: v5(71.32,89.86) 71.41,89.95 72.56,89.95 72.99,89.52 74.28,89.52 v5(74.66,89.9)
  L3 w0.508: v5(88.11,89.17) 87.8,88.86 86.86,88.86 86.32,89.4 v5(86.32,89.48)
  L4 w0.254: v5(59.64,115.08) 59.64,115.11 v5(60.44,115.91) ; v5(80.54,85.08) 80.99,84.62 80.99,83.96 80.59,83.56 80.54,83.56 v5(80.46,83.48)
  L4 w0.508: v5(59.84,93.82) 59.84,93.86 59.5,94.2 59.5,94.21 59.43,94.29 59.43,95.82 v5(59.12,96.13) ; v5(87.12,87.88) 87.12,88.3 86.32,89.1 v5(86.32,89.48) ; 71.42,122.59 71.87,123.05 85.16,123.05 88.33,126.22 90.52,126.22 93.03,128.74 v2(93.03,129.15)
  BOTTOM w0.178: 58.87,100.8 58.87,101.08 VRAM7.H2 ; v5(74.66,89.9) 74.2,89.45 73.06,89.45 VRAM4.H2 73.09,88.68 v5(73.09,87.88) 74.15,87.88 74.19,87.84 ; 66.41,88.28 66.44,88.28 66.71,88.54 66.73,88.54 67.01,88.82 67.01,88.84 67.09,88.93 VRAM4.H9 ; v5(58.84,119.88) 58.03,119.88 VRAM6.K2 ; v5(59.7,119.01) 60.04,119.35 VRAM8.G7
  BOTTOM w0.203: v5(58.79,100.19) 58.24,100.19 58.02,100.4 ; 57.98,100.95 57.64,101.29 VRAM5.K8
  BOTTOM w0.254: 66.36,88.28 66.41,88.28 ; v5(56.48,94.35) 56.43,94.4 55.31,94.4 55.16,94.55 RN7510.3
  BOTTOM w0.305: RN7511.3 56.55,94.28 v5(56.48,94.35)
  BOTTOM w0.356: v5(67.53,94.28) 67.53,94.32 VRAM4.A8 ; VRAM3.H9 80.59,89.08 80.53,89.01 80.42,89.01 v5(80.4,88.99) ; VRAM1.R1 v5(80.46,83.48) ; VRAM2.N1 66.61,85.08 v5(66.52,85.18) ; VRAM8.A1 64.84,114.68 v5(64.44,115.08) VRAM8.B2 ; v5(58.03,120.68) 57.64,120.29 VRAM6.K2 ; VRAM1.N1 v5(80.54,85.08) ; v5(73.09,87.88) 72.69,87.48 VRAM2.K8 ; v5(59.12,96.13) 59.4,96.4 RN7512.4 ; 66.57,91.35 66.7,91.48 VRAM4.E9 ; VRAM3.A1 v5(87.12,94.28) VRAM3.B2 ; VRAM8.E9 61.64,121.5 v5(61.49,121.65) ; v5(62.55,121.63) 62.44,121.52 VRAM8.D9 ; v5(58.04,115.08) 58.02,115.09 58.02,115.1 VRAM6.K8 ; v5(71.32,89.86) 71.13,89.67 68.89,89.67 VRAM4.G7 ; VRAM2.C1 66.67,93.08 v5(66.51,92.92) ; v5(63.64,101.05) 64.04,101.44 VRAM7.B2 ; VRAM6.R9 53.64,114.29 v5(53.49,114.14) 53.49,114.09 53.12,113.72 v5(52.99,113.72) ; VRAM1.K8 v5(87.12,87.88) ; v5(62.83,101.05) 62.44,101.44 VRAM7.D2 ; VRAM3.G7 82.32,89.48 v5(82.32,89.48) ; v5(74.18,90.64) 74.14,90.68 VRAM4.F1 ; v5(55.22,121.8) 55.24,121.78 VRAM6.N1 ; VRAM8.H2 59.64,115.08 v5(59.64,115.08) ; VRAM6.N9 55.24,114.2 v5(55.34,114.11) ; VRAM4.B2 73.08,94.27 v5(73.08,94.28) 73.49,94.68 VRAM4.A1 ; VRAM3.A8 81.91,94.68 v5(81.51,94.28) ; v5(53.68,107.72) 53.64,107.69 VRAM5.R1 ; VRAM6.C9 62.44,115.48 VRAM8.D2 ; VRAM7.G7 59.68,105.09 v5(59.68,104.94) ; VRAM1.R9 v5(88.16,83.48) ; VRAM7.A8 64.84,106.25 v5(64.44,106.65) ; v5(88.17,91.48) 88.17,91.33 VRAM3.F1 ; v5(63.07,107.65) 63.24,107.48 VRAM5.C1 ; VRAM6.R1 v5(53.64,121.8) ; VRAM2.R9 73.63,83.48 73.96,83.15 v5(73.98,83.15) ; VRAM8.A8 64.85,120.28 65.24,120.66 v5(65.29,120.66) ; v5(74.17,84.86) 74.12,84.86 73.9,85.08 VRAM2.N9 ; VRAM3.D2 v5(87.12,92.68) 87.52,93.08 VRAM1.C9 ; v5(61.64,100.01) 61.37,100.01 60.84,100.54 VRAM7.F1 ; VRAM6.C1 v5(63.24,121.64) ; v5(62.4,107.61) 62.4,107.09 VRAM7.D9 ; VRAM8.F1 60.84,114.65 v5(61.24,114.25) ; v5(58.04,105.85) 58.04,105.85 VRAM5.K2 ; VRAM3.H2 v5(86.32,89.48) ; VRAM4.D9 v5(66.51,92.28) ; VRAM1.N9 v5(88.11,85.08)
  BOTTOM w0.4: VRAM5.N9 v5(55.24,100.06) ; VRAM5.R9 v5(53.64,100.01)
  BOTTOM w0.508: v2(89.6,86.09) 89.73,86.09 90.04,85.79 C12406.1 ; C455.1 75.7,115.37 v5(75.43,115.63) ; C12380.1 81.16,104.32 80.81,104.66 v5(80.66,104.66) 80.71,104.71 C6723.1 ; R604.2 76.64,106.64 R608.2 76.94,106.63 77.29,106.29 77.29,105.62 v5(77.41,105.5)
  vias: v1(48.91,122.03) v1(49.4,103.97) v1(54.2,93.97) v1(63.14,81.77) v1(66.13,124.24) v1(84.22,74.61) v2(47.21,100.44) v2(47.31,97.9) v2(47.31,96.25) v2(47.31,95.11) v2(47.54,93.97) v2(47.69,92.57) v2(47.95,103.49) v2(48.25,84.85) v2(48.41,90.61) v2(48.66,89.14) v2(49.29,90.61) v2(50.56,89.32) v2(63.19,123.18) v2(64.97,123.18) v2(67.13,124.19) v2(68.65,77.46) v2(71.57,77.33) v2(78.43,92.72) v5(52.77,96.58) v5(59.24,122.54) v5(60.67,108.06) v5(62.87,114.25) v5(63.72,111.54) v5(64.36,111.54) v5(64.94,108.11) v5(67.49,92.71) v5(67.49,87.84) v5(79.92,77.53) v5(80.03,87.78) v5(80.21,76.82) v5(80.33,92.34) v5(81.02,77.56) v5(81.22,76.57)
+V_1P35_VGA_DISCHG: length 2.8
  TOP w0.102: Q9633.6 94.25,129.89 R80058.1 93.49,130.1 v1(92.88,130.7)
+V_3P3_VGA: length 214.7
  TOP w0.356: GPU1.AA9 85.26,116.72 GPU1.AA8 86.04,116.77 v5(86.43,117.16) 86.04,117.54 GPU1.AB8
  TOP w0.406: U9621.5 101.48,113.71 101.16,114.03 v2(100.91,114.03)
  TOP w0.508: v2(100.07,132.68) 100.07,134.12 100.55,134.61 107.96,134.61 PR583.1 ; v2(92.91,116.57) 92.65,116.32 92.65,108.7 v2(93.29,108.06) ; v2(103.83,98.46) 104.02,98.27 PR8304.2 104.02,97.43 104.27,97.17 PR8327.2 ; R633.1 100.65,91.49 v2(100.65,92.82) 100.53,92.95 R607.1 ; Q59.E 95.75,89.36 95.85,89.27 96.05,89.27 96.37,88.95 C475.1 R602.2 97.92,88.95 98.62,88.25 v2(98.62,87.49) ; v2(102.56,109.33) 102.19,108.96 PR8328.1 ; PR8623.1 37.09,107.49 37.53,107.05 v2(37.53,106.63) 37.57,106.67 PR5525.1 ; v2(95.19,124.19) 95.19,123.35 R586.1 96.59,121.96 Q54.D 95.85,120.26 v2(95.57,120.26)
  L4 w0.508: v2(102.56,109.33) 104.23,107.66 104.23,98.87 v2(103.83,98.46) ; v2(37.53,106.63) 39.15,106.63 43.84,111.32 43.84,113.82 54.98,124.95 60.78,124.95 61.69,125.87 69.16,125.87 69.79,125.23 82.75,125.23 87.31,129.79 87.34,129.79 87.72,130.18 87.72,130.21 88.18,130.67 98.29,130.67 100.07,132.45 v2(100.07,132.68) ; v2(90.59,103.9) 90.59,104.96 93.29,107.66 v2(93.29,108.06)
  BOTTOM w0.508: 95.89,99.55 98.27,99.55 99.57,98.25 R79783.1 ; 95.89,99.55 95.84,99.55 95.33,100.06 95.3,100.06 92.57,102.79 R631.2 91.92,102.79 91.79,102.92 R79983.1 ; 95.89,99.55 R628.1 ; v5(86.43,117.16) 86.47,117.12 C6709.2 88.05,117.12 C440.1 88.84,117.14 ; 88.84,117.14 89.41,117.14 C438.2 C443.2 91.26,116.57 v2(92.91,116.57) 92.91,118.1 93.41,118.6 93.92,118.6 v2(95.57,120.26) ; 88.84,117.14 88.84,118.86 89.6,119.62 R591.1 ; R79783.1 R237.1 R234.1 R240.1 R79991.1 99.57,93.2 99.95,92.82 v2(100.65,92.82) 100.78,92.7 100.78,90.66 101.67,89.78 103.32,89.78 ; R79783.1 101.21,98.03 102.39,99.21 103.24,99.21 103.83,98.62 v2(103.83,98.46) ; R79983.1 90.94,102.92 90.62,103.24 90.62,103.87 v2(90.59,103.9) ; R79983.1 R79990.1 ; U33.7 98.62,90.66 99.76,90.66 100.31,90.12 100.31,88.68 99.12,87.49 v2(98.62,87.49) 98.62,87.28 98.65,87.25 98.65,86.38 95.74,83.48 94.14,83.48 93.59,84.02 93.59,85.06 R79984.2 ; v2(100.07,132.68) 100.07,128.94 v3(98.62,127.49) 95.32,124.19 v2(95.19,124.19) ; 92.59,107.36 v2(93.29,108.06) ; 92.59,107.36 92.27,107.68 91.79,107.68 91.15,108.32 R606.1 ; 92.59,107.36 R79987.2 R630.1 ; v2(102.56,109.33) 102.56,109.36 102.15,108.95 100.64,108.95 PR8308.1 100.5,113.63 v2(100.91,114.03)
+V_VGA_CORE: length 49.6
  TOP w0.508: v2(99.38,130.16) 100.21,130.99 R80057.2
  TOP w0.635: 107.77,118.69 107.77,119.75 ; 107.77,119.75 106.71,119.75 ; 107.77,119.75 107.77,120.8 ; 107.77,119.75 108.82,119.75 ; PT34.1 107.64,112.67 ; PT34.1 107.64,110.56 ; PT34.1 106.58,111.62 ; PT34.1 108.69,111.62
  L3 w0.508: 94.13,108.52 94.79,107.86 94.79,107 v2(95.78,106.01) ; v4(105.99,120.38) 105.99,123.3 99.38,129.91 v2(99.38,130.16)
  L3 w0.635: PT34.1 107.64,112.67 ; PT34.1 107.64,110.56 ; PT34.1 108.69,111.62 ; PT34.1 106.58,111.62 ; 106.71,119.75 107.77,119.75 ; 107.77,119.75 107.77,120.8 ; 107.77,119.75 108.82,119.75 ; 107.77,119.75 107.77,118.69
  L4 w0.635: 107.77,119.75 108.82,119.75 ; 107.77,119.75 107.77,120.8 ; 107.77,119.75 107.77,118.69 ; 107.77,119.75 106.71,119.75 ; 107.64,110.56 PT34.1 ; PT34.1 108.69,111.62 ; PT34.1 106.58,111.62 ; PT34.1 107.64,112.67
  BOTTOM w0.508: v2(95.78,106.01) 95.22,105.45 95.22,104.25 95.7,103.76 PR8329.1
  BOTTOM w0.635: 107.64,110.56 PT34.1 ; PT34.1 106.58,111.62 ; PT34.1 108.69,111.62 ; PT34.1 107.64,112.67
  vias: v3(77.59,115.35) v3(79.61,109.35) v3(117.67,113.02) v4(104.59,117.59) v4(105.23,114.79) v4(105.61,117.08) v4(105.61,116.06) v4(105.73,118.1) v4(105.73,112.13) v4(105.86,119.11) v4(106.88,118.1) v4(106.88,116.83) v4(106.88,110.22) v4(107.38,121.53) v4(107.38,113.65) v4(108.27,117.84) v4(108.4,113.65) v4(108.65,121.53) v4(109.16,110.22) v4(109.92,113.52) v4(111.19,121.14) v4(111.45,110.35) v4(111.78,115.2) v4(111.93,113.32) v4(112.72,120.76) v4(113.3,115.12) v4(113.35,121.53) v4(113.35,118.99) v4(113.99,114.16) v4(114.12,116.57) v4(114.47,111.42) v4(114.88,119.11) v4(115.26,115.07) v4(115.39,116.32) v4(115.41,113.19) v4(115.99,111.34) v4(116.66,119.11) v4(117.95,111.29) v4(120.97,113.91) v4(121.23,115.68) v5(76.45,115.45) v5(77.61,110.36) v5(77.74,108.44) v5(78.71,115.42) v5(79.59,108.38) v5(80.58,113.41) v5(80.56,111.43) v5(80.61,109.45) v5(80.69,115.39) v5(81.6,108.38) v5(82.71,115.43) v5(83.5,106.51) v5(83.61,115.42) v5(83.56,113.39) v5(83.61,112.42) v5(83.58,110.39) v5(83.58,108.38) v5(85.59,113.39) v5(85.61,111.64) v5(85.64,112.47) v5(85.74,115.24) v5(85.82,108.61) v5(86.32,114.76) v5(86.32,111.63) v5(86.35,112.45)
