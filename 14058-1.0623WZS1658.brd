# Allegro board 14058-1.0623WZS1658.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_DATA_B55: length 111.6
  TOP w0.14: CPU1.AM7 85.07,174 v5(84.59,173.51) ; v5(166.44,143.12) 167.07,143.75 DIMM2.176
  L3 w0.102: 83.99,168.95 83.99,172.32 84.15,172.48 84.15,173.07 v5(84.59,173.51)
  L3 w0.191: v5(166.44,143.12) 165.96,142.64 164.63,142.64 163.55,143.72 161.67,143.72 160.18,142.23 160.18,141.23 153.93,134.98 145.22,134.98 145.19,134.94 142.86,134.94 142.16,135.65 138.65,135.65 126.59,147.71 113.17,147.71 97.96,162.93 88.42,162.93 88.18,163.16 83.85,167.5 83.85,168.81 83.99,168.95
  BOTTOM w0.14: v3(166.92,144.03) 166.92,143.6 v5(166.44,143.12)
M_DATA_B56: length 123.1
  TOP w0.14: v5(163.59,141.19) 162.91,141.86 161.63,141.86 161.25,142.25 DIMM2.181 ; v5(81.86,174.48) 81.87,174.48 CPU1.AJ7
  L3 w0.102: 81.52,170.84 81.52,172.75 81.86,173.09 82.07,173.09 82.36,173.38 82.36,173.98 v5(81.86,174.48)
  L3 w0.191: 81.52,170.84 81.46,170.78 81.46,164.41 81.46,164.06 86.02,159.5 95.69,159.5 95.88,159.69 95.88,160.53 96.07,160.72 96.45,160.72 96.64,160.53 96.64,159.69 96.83,159.5 98.6,159.5 112.59,145.5 124.64,145.5 133.6,136.54 133.6,136.27 133.23,135.9 133.23,135.63 133.5,135.36 133.77,135.36 134.14,135.73 134.41,135.73 134.68,135.46 134.68,135.19 134.31,134.82 134.31,134.55 134.58,134.28 134.85,134.28 135.22,134.65 135.49,134.65 135.76,134.38 135.76,134.12 135.39,133.74 135.39,133.48 135.66,133.21 135.93,133.21 136.3,133.58 136.57,133.58 136.84,133.31 136.84,133.04 136.47,132.67 136.47,132.4 136.74,132.13 137,132.13 137.38,132.5 137.64,132.5 138.31,131.83 153.66,131.83 162.29,140.45 162.87,140.45 163.59,141.17 v5(163.59,141.19)
  BOTTOM w0.14: v3(163.31,141.95) 163.31,141.46 v5(163.59,141.19)
M_DATA_B57: length 122.6
  TOP w0.14: CPU1.AH6 81.49,173.08 v5(81.96,172.61) ; v5(162.16,141.13) 161.86,141.13 161.35,141.65 DIMM2.183
  L3 w0.102: 81.98,171.06 82.33,171.4 82.33,172.11 81.96,172.48 v5(81.96,172.61)
  L3 w0.191: v5(162.16,141.13) 153.26,132.23 138.58,132.23 124.91,145.91 112.77,145.91 97.4,161.28 95.17,161.28 94.98,161.09 94.98,160.51 94.75,160.29 94.44,160.29 94.21,160.51 94.21,161.09 94.02,161.28 93.64,161.28 93.45,161.09 93.45,160.09 93.26,159.9 92.88,159.9 92.69,160.09 92.69,161.09 92.5,161.28 92.12,161.28 91.93,161.09 91.93,160.09 91.74,159.9 91.36,159.9 91.17,160.09 91.17,161.09 90.98,161.28 90.59,161.28 90.4,161.09 90.4,160.09 90.21,159.9 89.83,159.9 89.64,160.09 89.64,161.09 89.45,161.28 89.07,161.28 88.88,161.09 88.88,160.09 88.69,159.9 88.31,159.9 88.12,160.09 88.12,161.09 87.93,161.28 87.55,161.28 87.36,161.09 87.36,160.09 87.17,159.9 86.78,159.9 86.59,160.09 86.59,161.09 86.4,161.28 84.83,161.28 81.86,164.24 81.86,168.36 81.98,168.48 81.98,171.06
  BOTTOM w0.14: v5(162.16,141.13) 161.58,140.55 v3(161.38,140.55)
M_DATA_B58: length 124.9
  TOP w0.14: v5(80.08,174.41) 79.68,174.01 79.63,174.01 CPU1.AF7 ; v5(165.54,137.88) 165.54,137.92 164.21,139.25 DIMM2.191
  L3 w0.102: v5(80.08,174.41) 79.57,173.9 79.57,173.72 78.33,172.48 78.33,171.27 78.68,170.91 78.68,170.49
  L3 w0.191: v5(165.54,137.88) 165.06,138.36 163.16,138.36 162.88,138.08 162.88,138.07 154.55,129.73 135.8,129.73 122.84,142.69 122.84,142.69 122.13,143.41 111.69,143.41 97.73,157.36 87.32,157.36 87.13,157.17 87.13,156.87 86.94,156.68 86.56,156.68 86.37,156.87 86.37,157.17 86.18,157.36 84.98,157.36 78.17,164.17 78.17,169.09 78.68,169.6 78.68,170.49
  BOTTOM w0.14: v3(80.84,174.71) 80.38,174.71 v5(80.08,174.41)
M_DATA_B59: length 124.9
  TOP w0.14: DIMM2.193 163.54,138.65 164.07,138.12 v5(164.07,137.86) ; CPU1.AE7 78.75,174.05 78.76,174.05 v5(79.19,174.48)
  L3 w0.102: 77.74,170.04 77.74,171 78.05,171.31 78.05,172.49 79.06,173.5 79.06,174.36 v5(79.19,174.48)
  L3 w0.191: 77.74,170.04 77.19,169.49 77.19,164.58 77.77,164 85.62,156.15 87.8,156.15 87.99,156.34 87.99,156.77 88.18,156.96 88.56,156.96 88.75,156.77 88.75,156.34 88.94,156.15 89.32,156.15 89.51,156.34 89.51,156.77 89.7,156.96 90.09,156.96 90.28,156.77 90.28,156.34 90.47,156.15 90.85,156.15 91.04,156.34 91.04,156.77 91.23,156.96 97.55,156.96 111.51,143 121.96,143 122.44,142.52 135.64,129.33 154.84,129.33 162.79,137.27 163.48,137.27 v5(164.07,137.86)
  BOTTOM w0.14: v5(164.07,137.86) 164.07,138.58 v3(163.8,138.85)
M_DATA_B60: length 123.4
  TOP w0.14: v5(165.03,141.13) 165.58,141.68 166.23,141.68 167.09,142.55 DIMM2.180 ; CPU1.AH7 81,173.56 v5(80.97,173.56)
  L3 w0.102: 80.46,171.18 80.59,171.31 80.59,171.94 80.84,172.2 80.84,173.43 v5(80.97,173.56)
  L3 w0.191: 80.46,171.18 80.46,168.77 80.71,168.52 80.71,164.22 85.84,159.09 98.42,159.09 112.41,145.1 124.44,145.1 124.99,144.55 129.5,140.04 129.5,139.77 129.04,139.31 129.04,139.04 129.31,138.77 129.58,138.77 130.04,139.23 130.31,139.23 130.58,138.96 130.58,138.69 130.12,138.23 130.12,137.96 130.39,137.69 130.66,137.69 131.12,138.15 131.39,138.15 131.66,137.88 131.66,137.61 131.2,137.15 131.2,136.88 131.47,136.61 131.73,136.61 132.17,137.04 132.48,137.04 132.7,136.82 132.7,136.5 132.27,136.07 132.27,135.8 136.66,131.42 153.83,131.42 154.07,131.66 162.46,140.05 163.95,140.05 v5(165.03,141.13)
  BOTTOM w0.14: v3(165.27,142) 165.27,141.37 v5(165.03,141.13)
M_DATA_B61: length 122.3
  TOP w0.14: CPU1.AJ6 81.96,173.48 v5(81.96,173.55) ; v5(166.46,141.16) 167.25,141.95 DIMM2.182
  L3 w0.102: 79.65,171.4 79.65,171.83 80.01,172.2 80.17,172.2 80.54,172.56 80.54,173.7 80.8,173.96 81.54,173.96 v5(81.96,173.55)
  L3 w0.191: v5(166.46,141.16) 165.77,140.47 165.02,140.47 164.19,139.64 162.63,139.64 154.48,131.49 154,131.02 136.49,131.02 128.18,139.33 128.18,139.6 128.35,139.77 128.35,140.08 128.12,140.31 127.81,140.31 127.64,140.14 127.37,140.14 127.1,140.4 127.1,140.67 127.56,141.14 127.56,141.41 124.28,144.69 112.24,144.69 98.24,158.69 85.67,158.69 80.31,164.04 80.31,168.03 79.98,168.36 79.98,171.07 79.65,171.4
  BOTTOM w0.14: v3(166.79,141.97) 166.79,141.5 v5(166.46,141.16)
M_DATA_B62: length 124.2
  TOP w0.14: DIMM2.192 166.69,138.95 166.25,138.51 v5(166.25,137.91) ; v5(78.3,173.55) 79.14,173.55 CPU1.AF6
  L3 w0.102: 76.68,171.46 76.68,171.67 77.15,172.14 77.45,172.14 77.84,172.54 77.84,173.09 v5(78.3,173.55)
  L3 w0.191: 76.68,171.46 76.68,164.52 77.36,163.83 85.45,155.74 91.28,155.74 91.99,156.45 97.46,156.45 111.32,142.59 112.2,142.59 112.2,142.59 121.79,142.59 122.03,142.36 135.47,128.92 157.26,128.92 v5(166.25,137.91)
  BOTTOM w0.14: v5(78.3,173.55) 79.2,173.55 v3(79.27,173.62)
M_DATA_B63: length 123.7
  TOP w0.14: v5(167.19,137.83) 167.2,137.84 167.26,137.84 167.77,138.35 DIMM2.194 ; CPU1.AE6 78.25,172.63 v5(77.36,172.63)
  L3 w0.102: 76.13,171.3 76.13,171.41 77.35,172.63 v5(77.36,172.63)
  L3 w0.191: 76.13,171.3 76.13,164.49 76.95,163.66 84.21,156.41 85.29,155.33 86.3,155.33 92.67,155.33 92.86,155.52 92.86,155.68 93.05,155.87 93.43,155.87 93.62,155.68 93.62,155.52 93.81,155.33 94.19,155.33 94.38,155.52 94.38,155.68 94.57,155.87 94.95,155.87 95.14,155.68 95.14,155.52 95.33,155.33 98.01,155.33 111.15,142.19 111.7,142.19 112.37,142.19 121.63,142.19 135.3,128.51 157.87,128.51 v5(167.19,137.83)
  BOTTOM w0.14: v5(167.19,137.83) 167.71,138.35 v3(167.71,138.43)
M_DQS_A_DN0: length 102.8
  TOP w0.102: 80.84,207.42 80.89,207.37 80.89,205.82 CPU1.AF39
  TOP w0.14: v5(80.08,207.45) 80.31,207.68 80.58,207.68 80.84,207.42 ; v5(150.49,196.29) 150.39,196.19 150.39,195.9 150.52,195.76 152.28,195.76 152.46,195.95 DIMM1.10
  L4 w0.191: v5(150.49,196.29) 150.28,196.5 150.28,196.84 150.03,197.09 143.39,197.09 142.52,197.97 142.52,198.24 142.87,198.59 142.87,199.15 142.48,199.54 141.92,199.54 141.56,199.19 141.3,199.19 138.98,201.51 125.27,201.51 103.69,223.09 88.97,223.09 79.3,213.42 79.3,211.85 79.58,211.57 79.58,210.65 79.3,210.36 79.3,208.23 v5(80.08,207.45)
  BOTTOM w0.14: v5(80.08,207.45) 80.99,206.54 v3(80.99,206.26)
M_DQS_A_DN1: length 98.5
  TOP w0.14: DIMM1.27 150.76,190.85 151.15,190.46 151.15,189.85 v5(151.24,189.75) ; v5(83.7,204.96) 83.7,204.99 84.17,205.46 CPU1.AK39
  L4 w0.191: v5(83.7,204.96) 84.71,205.96 84.71,212.79 90.72,218.81 98.72,218.81 120.29,197.24 137.04,197.24 142.8,191.48 150.79,191.48 151.24,191.03 v5(151.24,189.75)
  BOTTOM w0.14: v5(151.24,189.75) v3(151.24,190.66)
M_DQS_A_DN2: length 80.6
  TOP w0.14: CPU1.AP39 87.84,205.49 88.08,205.73 88.21,205.73 88.33,205.6 88.33,204.97 v5(88.34,204.97) ; DIMM1.45 146.25,185.45 146.71,184.99 147.83,184.99 147.95,185.12 147.95,185.36 147.83,185.48 147.31,185.48 147.19,185.61 147.19,185.81 147.36,185.99 v5(147.46,185.99)
  L4 w0.102: v5(88.34,204.97) 88.59,205.22 88.59,205.95 89.84,207.2
  L4 w0.191: v5(147.46,185.99) 147.65,185.8 147.65,185.53 147.55,185.43 145.11,185.43 144.92,185.62 144.92,186.15 144.56,186.51 143.94,186.51 143.58,186.15 143.58,185.62 143.39,185.43 141.17,185.43 134.33,192.26 118.58,192.26 102.79,208.05 92.55,208.05 92.29,208.31 90.94,208.31 89.84,207.2
  BOTTOM w0.14: v3(146.02,185.66) 146.35,185.33 147.06,185.33 147.46,185.73 v5(147.46,185.99)
M_DQS_A_DN3: length 75.5
  TOP w0.14: CPU1.AU36 90.58,202.74 91.02,203.18 v5(91.02,203.19) ; DIMM1.62 152.57,180.35 152.38,180.16 152.04,180.16 151.71,179.84 151.07,179.84 v5(150.71,180.2)
  L4 w0.102: 93.72,204 93.7,204 93.65,203.95 91.49,203.95 91.22,203.69 91.22,203.38 v5(91.02,203.19)
  L4 w0.191: 93.72,204 94.27,204 94.79,203.49 94.79,202.47 99.18,198.08 106.46,198.08 116.63,187.91 132.15,187.91 139.22,180.84 149.9,180.84 150.18,180.57 150.35,180.57 v5(150.71,180.2)
  BOTTOM w0.14: v3(91.51,204.05) 91.02,203.56 v5(91.02,203.19)
M_DQS_A_DN4: length 73.4
  TOP w0.14: v5(148.1,157.69) 148.1,157.31 148.23,157.19 148.5,157.19 148.62,157.06 148.62,156.63 147.69,155.69 146.56,155.69 146.2,156.05 DIMM1.135 ; CPU1.AW7 91.91,174.41 v5(91.93,174.41)
  L4 w0.102: 92.83,173.95 92.82,173.95 92.77,173.91 92.73,173.91 92.72,173.9 92.58,173.9 92.45,174.02 92.45,174.68 92.3,174.83 91.93,174.83 91.86,174.76 91.86,174.48 v5(91.93,174.41)
  L4 w0.191: 92.83,173.95 94.88,173.95 104.43,164.4 114.57,164.4 122.29,156.68 148.37,156.68 148.65,156.95 148.65,157.22 148.18,157.69 v5(148.1,157.69)
  BOTTOM w0.14: v3(92.78,173.62) 91.99,174.41 v5(91.93,174.41)
M_DQS_A_DN5: length 77.3
  TOP w0.14: v5(90.11,170.8) 89.67,170.36 CPU1.AU3 ; DIMM1.152 151.45,150.95 150.69,150.19 150.69,149.64 v5(150.51,149.46)
  L4 w0.102: v5(90.11,170.8) 89.9,170.59 89.62,170.59 89.43,170.4 89.43,169.4 89.8,169.03 92.07,169.03 92.12,168.98 92.14,168.98
  L4 w0.191: 92.14,168.98 92.87,168.98 102.16,159.7 110.48,159.7 119.48,150.7 150.06,150.7 150.23,150.53 150.69,150.07 150.69,149.64 v5(150.51,149.46)
  BOTTOM w0.14: v3(150.44,150.43) 150.44,149.53 v5(150.51,149.46)
M_DQS_A_DN6: length 83.5
  TOP w0.14: DIMM1.169 146.21,145.85 146.57,145.49 147.74,145.49 147.9,145.66 147.9,145.76 147.71,145.95 v5(147.56,145.95) ; v5(86.38,169.89) 86.01,170.25 CPU1.AN3
  L4 w0.191: v5(147.56,145.95) 147.74,145.77 147.74,145.45 147.45,145.15 145.39,145.15 145.2,145.34 145.2,145.67 144.84,146.03 144.22,146.03 143.86,145.67 143.86,145.34 143.67,145.15 143.29,145.15 143.09,145.34 143.09,145.67 142.73,146.03 142.11,146.03 141.75,145.67 141.75,145.34 141.56,145.15 141.18,145.15 140.99,145.34 140.99,145.67 140.63,146.03 140,146.03 139.64,145.67 139.64,145.34 139.45,145.15 139.07,145.15 138.88,145.34 138.88,145.67 138.52,146.03 137.89,146.03 137.53,145.67 137.53,145.34 137.34,145.15 119.16,145.15 108.7,155.61 98.79,155.61 87.37,167.03 87.37,167.67 86.73,168.31 86.73,168.63 86.91,168.81 86.91,169.18 86.73,169.35 86.73,169.4 86.38,169.76 v5(86.38,169.89)
  BOTTOM w0.14: v5(147.56,145.95) 146.86,145.25 v3(146.4,145.25)
M_DQS_A_DN7: length 90.7
  TOP w0.102: CPU1.AJ3 82.12,170.11 82.02,170.11 81.78,169.87 81.78,167.93 81.73,167.88 81.73,167.63
  TOP w0.14: DIMM1.186 152.64,140.75 152.24,140.34 151.18,140.34 151.01,140.51 151.01,140.83 v5(151.04,140.85) ; v2(82.49,165.34) 82.23,165.61 82.07,165.61 81.73,165.94 81.73,167.63
  L4 w0.191: v2(82.49,165.34) 82.97,165.34 83.13,165.18 83.13,163.74 96.7,150.16 104.89,150.16 115.37,139.69 150.47,139.69 150.92,140.14 150.92,140.73 v5(151.04,140.85)
  BOTTOM w0.14: v5(151.04,140.85) 151.68,140.21 v3(151.68,140.02)
M_DQS_A_DP0: length 102.5
  TOP w0.102: CPU1.AF38 81.1,205.11 81.1,207.5
  TOP w0.14: v5(80.08,208.16) 80.32,207.92 80.68,207.92 81.1,207.5 ; v5(149.73,196.29) 150.1,195.92 150.1,195.84 150.42,195.52 152.28,195.52 152.45,195.35 DIMM1.12
  L4 w0.191: v5(149.73,196.29) 149.99,196.55 149.99,196.71 149.91,196.8 143.27,196.8 142.23,197.85 142.23,198.36 142.58,198.71 142.58,199.03 142.36,199.25 142.04,199.25 141.69,198.9 141.17,198.9 138.85,201.22 125.14,201.22 103.57,222.79 89.09,222.79 79.59,213.3 79.59,211.97 79.88,211.69 79.88,210.53 79.59,210.24 79.59,208.35 79.78,208.16 v5(80.08,208.16)
  BOTTOM w0.14: v3(80.87,207.86) 80.38,207.86 v5(80.08,208.16)
M_DQS_A_DP1: length 98.8
  TOP w0.14: v5(150.51,189.75) 150.91,190.15 150.91,190.36 150.66,190.61 146.5,190.61 146.14,190.25 DIMM1.29 ; v5(83.7,204.1) 83.75,204.1 CPU1.AK38
  L4 w0.191: v5(83.7,204.1) 84.26,204.66 84.26,205.1 85,205.84 85,212.67 90.84,218.51 98.6,218.51 120.17,196.95 136.92,196.95 142.68,191.18 150.67,191.18 150.95,190.9 150.95,190.19 v5(150.51,189.75)
  BOTTOM w0.14: v5(83.7,204.1) 84.54,204.94 v3(84.6,204.94)
M_DQS_A_DP2: length 79.9
  TOP w0.14: DIMM1.47 146.47,184.85 146.57,184.75 147.93,184.75 148.2,185.02 v5(148.2,185.99) ; v5(88.31,204.08) 88.28,204.1 CPU1.AP38
  L4 w0.102: v5(88.31,204.08) 88.79,204.56 88.79,205.87 89.7,206.78 89.88,206.96 89.94,206.96 89.98,207 90.04,207
  L4 w0.191: 90.04,207 91.07,208.02 92.17,208.02 92.43,207.76 102.67,207.76 118.46,191.97 134.21,191.97 141.04,185.14 143.51,185.14 143.87,185.5 143.87,186.03 144.06,186.22 144.44,186.22 144.63,186.03 144.63,185.5 144.99,185.14 147.68,185.14 147.95,185.41 147.95,185.74 v5(148.2,185.99)
  BOTTOM w0.14: v5(88.31,204.08) 88.28,204.08 87.45,203.24 v3(87.34,203.24)
M_DQS_A_DP3: length 75.4
  TOP w0.14: CPU1.AV36 91.5,202.8 v5(91.89,203.19) ; DIMM1.64 152.49,179.75 152.32,179.92 152.14,179.92 151.81,179.6 150.63,179.6 150.1,180.13 v5(149.95,180.13)
  L4 w0.102: v5(91.89,203.19) 91.53,203.19 91.42,203.3 91.42,203.6 91.57,203.75 93.65,203.75 93.7,203.71 93.72,203.71
  L4 w0.191: 93.72,203.71 94.15,203.71 94.49,203.36 94.49,202.35 99.06,197.79 106.34,197.79 116.51,187.62 132.03,187.62 139.1,180.55 149.78,180.55 149.95,180.38 v5(149.95,180.13)
  BOTTOM w0.14: v3(92.73,203.44) 92.14,203.44 v5(91.89,203.19)
M_DQS_A_DP4: length 73.2
  TOP w0.14: CPU1.AV7 91,174.41 v5(91.04,174.41) ; DIMM1.137 147.79,155.45 148.87,156.53 v5(148.87,157.69)
  L4 w0.102: v5(91.04,174.41) 91.28,174.41 91.69,174 92.19,174 92.49,173.7 92.78,173.7 92.82,173.66 92.83,173.66
  L4 w0.191: 92.83,173.66 94.76,173.66 104.31,164.11 114.45,164.11 122.17,156.39 148.49,156.39 148.94,156.83 148.94,157.62 v5(148.87,157.69)
  BOTTOM w0.14: v3(90.67,175.17) 91.04,174.81 v5(91.04,174.41)
M_DQS_A_DP5: length 77.7
  TOP w0.14: v5(151.22,149.44) 150.93,149.73 150.93,150.09 151.55,150.71 152.06,150.71 152.42,150.35 DIMM1.154 ; CPU1.AU2 89.67,169.47 v5(90.11,169.91)
  L4 w0.102: v5(90.11,169.91) 90.11,170.27 89.99,170.39 89.7,170.39 89.63,170.32 89.63,169.49 89.89,169.23 92.07,169.23 92.12,169.28 92.14,169.28
  L4 w0.191: 92.14,169.28 92.99,169.28 102.28,159.99 110.6,159.99 119.6,150.99 150.18,150.99 150.98,150.19 150.98,149.68 v5(151.22,149.44)
  BOTTOM w0.14: v3(152.19,150.25) 151.99,150.25 151.22,149.49 v5(151.22,149.44)
M_DQS_A_DP6: length 83.2
  TOP w0.14: CPU1.AN2 86.03,169.42 v5(86.46,168.99) ; v5(148.27,146.04) 148.14,145.92 148.14,145.55 147.84,145.25 DIMM1.171
  L4 w0.191: v5(148.27,146.04) 148.04,145.81 148.04,145.33 147.57,144.86 145.27,144.86 144.91,145.22 144.91,145.55 144.72,145.74 144.34,145.74 144.15,145.55 144.15,145.22 143.79,144.86 143.16,144.86 142.8,145.22 142.8,145.55 142.61,145.74 142.23,145.74 142.04,145.55 142.04,145.22 141.68,144.86 141.06,144.86 140.69,145.22 140.69,145.55 140.5,145.74 140.12,145.74 139.93,145.55 139.93,145.22 139.57,144.86 138.95,144.86 138.59,145.22 138.59,145.55 138.4,145.74 138.01,145.74 137.82,145.55 137.82,145.22 137.46,144.86 119.04,144.86 108.58,155.32 98.67,155.32 87.08,166.91 87.08,167.55 86.44,168.19 86.44,168.98 v5(86.46,168.99)
  BOTTOM w0.14: v3(147.82,146.93) 147.82,146.9 148.27,146.46 v5(148.27,146.04)
M_DQS_A_DP7: length 90.6
  TOP w0.102: 81.98,167.75 81.98,169.79 82.1,169.9 82.25,169.9 82.36,169.79 CPU1.AJ2
  TOP w0.14: 81.98,167.75 81.97,167.74 81.97,166.04 82.17,165.85 82.37,165.85 82.49,165.98 v2(82.49,166.23) ; DIMM1.188 152.44,140.15 152.39,140.1 151.08,140.1 v5(150.33,140.85)
  L4 w0.191: v2(82.49,166.23) 83.42,165.3 83.42,163.86 96.82,150.46 105.01,150.46 115.49,139.98 150.35,139.98 150.63,140.26 150.63,140.56 v5(150.33,140.85)
  BOTTOM w0.14: v5(150.33,140.85) 150.33,140.59 149.88,140.14 v3(149.88,140.12)
M_DQS_B_DN0: length 121
  TOP w0.14: v5(80.12,200.48) CPU1.AF34 ; DIMM2.10 167.11,195.95 v5(166.48,196.58)
  L3 w0.102: 79.79,204.78 79.79,204.77 79.83,204.72 79.83,204.68 79.85,204.66 79.85,202.06 79.57,201.78 79.57,201.15 80.12,200.6 v5(80.12,200.48)
  L3 w0.191: 79.79,204.78 79.79,205 79.28,205.5 79.28,211.66 89.36,221.74 112.76,221.74 128.95,205.55 152.02,205.55 153.94,203.63 156.55,203.63 156.9,203.28 157.17,203.28 157.5,203.61 158.01,203.61 158.45,203.17 158.45,202.66 158.12,202.33 158.12,202.06 158.39,201.79 158.66,201.79 158.99,202.12 159.5,202.12 159.95,201.68 159.95,201.17 159.61,200.84 159.61,200.57 161.11,199.08 161.11,198.11 161.74,197.47 166.06,197.47 166.36,197.17 166.36,196.69 v5(166.48,196.58)
  BOTTOM w0.14: v3(79.29,200.49) 79.31,200.48 v5(80.12,200.48)
M_DQS_B_DN1: length 112.8
  TOP w0.14: CPU1.AK33 84.44,199.97 84.64,199.77 v5(84.64,199.51) ; v5(162.71,191.38) 162.74,191.38 163.15,190.97 163.15,190.81 162.83,190.49 161.7,190.49 161.34,190.85 DIMM2.27
  L3 w0.102: v5(84.64,199.51) 84.64,199.82 85.29,200.47 85.29,202.45 84.87,202.87 84.87,205.31 84.98,205.42 84.98,206.12 85.45,206.58 85.45,207.21 85.49,207.25
  L3 w0.191: v5(162.71,191.38) 162.71,191.39 162.71,191.69 162.56,191.84 160.68,191.84 154.22,198.31 132.29,198.31 131.93,198.67 131.93,199.56 131.7,199.78 131.39,199.78 131.16,199.56 131.16,198.67 130.8,198.31 130.18,198.31 129.82,198.67 129.82,199.58 129.6,199.81 129.28,199.81 129.06,199.58 129.06,198.67 128.7,198.31 127.35,198.31 108.69,216.98 91.46,216.98 85.49,211.01 85.49,207.25
  BOTTOM w0.14: v3(162.38,192.21) 162.71,191.88 v5(162.71,191.38)
M_DQS_B_DN2: length 96.4
  TOP w0.14: DIMM2.45 161.41,185.45 161.64,185.22 164.13,185.22 164.66,185.75 v5(164.66,186.3) ; CPU1.AN33 86.93,199.98 v5(87.37,200.43)
  L3 w0.102: v5(87.37,200.43) 87.84,200.9 90.38,200.9 92.22,202.73 92.45,202.97 92.45,203.34 92.4,203.39 92.4,203.41
  L3 w0.191: 92.4,203.41 92.4,203.73 92.77,204.09 93.27,204.09 94.3,205.12 114.66,205.12 127.82,191.96 153.33,191.96 154.65,190.65 155.75,190.65 156.8,189.59 156.8,189.08 156.62,188.9 156.62,188.58 156.84,188.36 157.16,188.36 157.34,188.54 157.86,188.54 160.41,185.99 163.48,185.99 163.77,185.7 164.42,185.7 164.66,185.95 v5(164.66,186.3)
  BOTTOM w0.14: v3(86.02,200.21) 86.24,200.43 v5(87.37,200.43)
M_DQS_B_DN3: length 95.9
  TOP w0.14: CPU1.AN29 v5(86.47,195.86) ; DIMM2.62 166.64,180.35 166.46,180.54 v5(166.46,180.71)
  L3 w0.102: 94.39,199.59 94.39,199.53 94.26,199.4 93.36,199.4 93.11,199.15 91.72,199.15 90.78,198.21 90.73,198.21 90.72,198.2 90.36,198.2 89.75,197.58 89.36,197.58 88.63,196.86 87.34,196.86 86.74,196.26 86.74,195.94 86.66,195.86 v5(86.47,195.86)
  L3 w0.191: v5(166.46,180.71) 165.9,181.26 165.55,181.61 164.59,181.61 163.94,180.96 157.03,180.96 152.96,185.03 145.68,185.03 144.22,186.49 125.49,186.49 111.64,200.34 95.14,200.34 94.39,199.59
  BOTTOM w0.14: v5(166.46,180.71) 166.46,180.88 166.72,181.14 167.05,181.47 167.58,181.47 v3(167.96,181.09)
M_DQS_B_DN4: length 101.8
  TOP w0.14: v5(162.7,156.63) 163.03,156.3 163.03,155.79 162.93,155.69 161.86,155.69 161.5,156.05 DIMM2.135 ; CPU1.AN13 v5(86.47,181.22)
  L3 w0.102: v5(86.47,181.22) 86.47,180.89 86.95,180.41 86.95,179.25 87.2,179 87.56,179 87.79,179.23 90.93,179.23 91.48,178.68 94.8,178.68 95.03,178.91 96.27,178.91 96.29,178.89
  L3 w0.191: v5(162.7,156.63) 162.86,156.47 162.86,156.09 162.72,155.96 159.99,155.96 154.59,150.56 154.3,150.27 143.21,150.27 142.85,149.91 142.85,149.28 142.63,149.06 142.31,149.06 142.09,149.28 142.09,149.91 141.73,150.27 141.01,150.27 140.6,150.27 140.46,150.27 129.24,161.49 115.46,161.49 98.27,178.68 97.28,178.68 97.28,178.68 96.76,178.68 96.56,178.89 96.29,178.89
  BOTTOM w0.14: v5(86.47,181.22) 86,181.7 86,182.64 v3(85.59,183.04)
M_DQS_B_DN5: length 102.5
  TOP w0.14: v5(165.69,150.28) 165.58,150.4 165.58,150.86 165.7,150.99 166.44,150.99 166.55,150.87 167.41,150.87 167.49,150.95 DIMM2.152 ; CPU1.AR8 87.6,174.91 87.38,175.14 v5(87.38,175.34)
  L3 w0.102: 94.53,175.22 93.78,175.98 91.34,175.98 90.48,175.12 87.6,175.12 v5(87.38,175.34)
  L3 w0.191: 94.53,175.22 95.51,174.25 96.12,174.25 115.35,155.01 127.73,155.01 139.99,142.75 150.29,142.75 150.68,143.14 153.33,143.14 153.79,143.6 160.92,150.72 163.75,150.72 164.75,149.72 165.72,149.72 165.88,149.88 165.88,150.09 v5(165.69,150.28)
  BOTTOM w0.14: v3(165.37,149.52) 165.37,149.96 v5(165.69,150.28)
M_DQS_B_DN6: length 112.3
  TOP w0.14: CPU1.AM8 84.7,174.51 v5(84.7,174.48) ; DIMM2.169 161.27,145.85 161.7,145.42 162.97,145.42 163.41,144.98 v5(163.41,144.65)
  L3 w0.102: v5(84.7,174.48) 84.7,174.28 85.21,173.77 85.21,172.22 85.51,171.91 85.51,169.19 85.06,168.74 85.06,168.39 85.07,168.38
  L3 w0.191: 85.07,168.38 85.07,167.97 88.92,164.12 98.45,164.12 112.74,149.83 114.56,149.83 114.93,149.47 114.93,149.11 115.12,148.92 115.5,148.92 115.69,149.11 115.69,149.47 116.05,149.83 116.67,149.83 117.03,149.47 117.03,149.11 117.22,148.92 117.61,148.92 117.8,149.11 117.8,149.47 118.16,149.83 118.78,149.83 119.14,149.47 119.14,149.11 119.33,148.92 119.71,148.92 119.9,149.11 119.9,149.47 120.27,149.83 120.89,149.83 121.25,149.47 121.25,149.31 121.47,149.08 121.79,149.08 122.54,149.83 126.17,149.83 139.15,136.85 144.26,136.85 144.94,136.17 152.39,136.17 161.64,145.42 162.64,145.42 v5(163.41,144.65)
  BOTTOM w0.14: v5(163.41,144.65) 163.41,144.91 v3(164,145.5)
M_DQS_B_DN7: length 123.1
  TOP w0.14: CPU1.AG6 80.48,173.08 v5(80.09,172.69) ; DIMM2.186 167.62,140.75 167.26,140.39 165.82,140.39 165.59,140.16 v5(165.59,139.6)
  L3 w0.102: v5(80.09,172.69) 80.09,173.03 80.01,173.11 79.65,173.11 78.73,172.19 78.73,171.48 79.35,170.86 79.35,170.22 79.4,170.18 79.4,170.06
  L3 w0.191: 79.4,170.06 79.4,168.73 78.96,168.29 78.96,164.5 85.27,158.19 98.03,158.19 112.03,144.19 122.61,144.19 123.35,143.45 123.61,143.45 123.96,143.8 124.47,143.8 124.91,143.36 124.91,142.84 124.57,142.5 124.57,142.23 124.84,141.96 125.11,141.96 125.45,142.31 125.96,142.31 126.4,141.86 126.4,141.35 126.06,141.01 126.06,140.74 136.28,130.52 154.22,130.52 162.09,138.39 162.09,138.41 162.83,139.15 165.41,139.15 165.59,139.33 v5(165.59,139.6)
  BOTTOM w0.14: v3(165.25,140.37) 165.25,139.95 v5(165.59,139.6)
M_DQS_B_DP0: length 121.4
  TOP w0.14: DIMM2.12 167.73,195.35 167.38,195.71 167.01,195.71 166.59,196.12 165.93,196.12 165.74,196.31 v5(165.74,196.58) ; CPU1.AF35 80.67,201.8 80.79,201.67 80.79,201.4 80.67,201.28 v5(80.08,201.28)
  L3 w0.102: v5(80.08,201.28) 79.97,201.28 79.77,201.47 79.77,201.7 80.05,201.97 80.05,204.63 80.08,204.66 80.08,204.78
  L3 w0.191: 80.08,204.78 80.08,205.12 79.58,205.63 79.58,211.54 89.48,221.45 112.64,221.45 128.83,205.26 151.9,205.26 153.82,203.34 156.43,203.34 156.78,202.99 157.29,202.99 157.62,203.32 157.89,203.32 158.16,203.05 158.16,202.78 157.83,202.45 157.83,201.94 158.27,201.5 158.78,201.5 159.11,201.83 159.38,201.83 159.65,201.56 159.65,201.29 159.32,200.96 159.32,200.45 160.81,198.95 160.81,197.98 161.62,197.18 165.94,197.18 166.07,197.05 166.07,196.85 165.8,196.58 v5(165.74,196.58)
  BOTTOM w0.14: v5(80.08,201.28) v3(80.08,202.25)
M_DQS_B_DP1: length 112.8
  TOP w0.14: CPU1.AL33 85.06,199.97 v5(84.61,200.42) ; DIMM2.29 162.93,190.25 163.39,190.71 163.39,191.33 v5(163.44,191.38)
  L3 w0.102: v5(84.61,200.42) 85.08,200.88 85.08,202.36 84.66,202.78 84.66,205.39 84.78,205.51 84.78,206.2 85.24,206.67 85.24,207.21 85.2,207.25
  L3 w0.191: v5(163.44,191.38) 162.68,192.14 160.81,192.14 154.34,198.6 132.41,198.6 132.22,198.79 132.22,199.68 131.82,200.07 131.27,200.07 130.87,199.68 130.87,198.79 130.68,198.6 130.3,198.6 130.11,198.79 130.11,199.71 129.72,200.1 129.16,200.1 128.76,199.71 128.76,198.79 128.57,198.6 127.48,198.6 108.81,217.27 91.34,217.27 85.2,211.13 85.2,207.25
  BOTTOM w0.14: v5(163.44,191.38) 163.44,191.9 v3(163.68,192.15)
M_DQS_B_DP2: length 97.2
  TOP w0.14: v5(88.22,200.4) 87.84,200.03 CPU1.AP33 ; DIMM2.47 161.48,184.85 161.6,184.97 164.23,184.97 165.42,186.17 v5(165.42,186.3)
  L3 w0.102: 92.7,203.41 92.65,203.37 92.65,202.88 92.36,202.59 90.47,200.7 88.51,200.7 88.22,200.4 v5(88.22,200.4)
  L3 w0.191: v5(165.42,186.3) 164.54,185.41 163.65,185.41 163.36,185.7 160.29,185.7 157.73,188.25 157.46,188.25 157.28,188.07 156.72,188.07 156.33,188.46 156.33,189.02 156.51,189.2 156.51,189.47 155.63,190.35 154.53,190.35 154.24,190.64 153.73,191.16 153.21,191.67 127.7,191.67 114.54,204.82 94.42,204.82 93.4,203.8 92.89,203.8 92.7,203.61 92.7,203.41
  BOTTOM w0.14: v5(88.22,200.4) 87.83,200.01 87.83,199.02 v3(88.21,198.64)
M_DQS_B_DP3: length 94.9
  TOP w0.14: DIMM2.64 167.64,179.75 167.28,180.11 165.95,180.11 165.69,180.36 v5(165.69,180.71) ; CPU1.AN28 86.94,195.4 v5(87.37,195.83)
  L3 w0.102: 94.6,199.39 94.41,199.2 93.45,199.2 93.19,198.94 91.8,198.94 90.86,198 90.45,198 89.83,197.38 89.44,197.38 88.72,196.66 87.43,196.66 86.95,196.18 86.95,196 87.11,195.83 v5(87.37,195.83)
  L3 w0.191: 94.6,199.39 95.26,200.05 111.51,200.05 125.37,186.19 144.1,186.19 145.56,184.74 152.83,184.74 156.9,180.67 164.06,180.67 164.71,181.32 165.43,181.32 165.69,181.06 v5(165.69,180.71)
  BOTTOM w0.14: v5(165.69,180.71) 165.69,180.4 v3(166.13,179.96)
M_DQS_B_DP4: length 100.8
  TOP w0.14: v5(86.47,180.31) 86.49,180.31 86.93,180.75 CPU1.AN12 ; v5(163.41,156.6) 163.27,156.46 163.27,155.69 163.03,155.45 DIMM2.137
  L3 w0.102: 96.24,178.59 96.17,178.59 96.06,178.71 95.12,178.71 94.88,178.48 91.4,178.48 90.85,179.03 87.88,179.03 87.64,178.79 87.11,178.79 86.74,179.16 86.74,180.04 86.7,180.08 v5(86.47,180.31)
  L3 w0.191: v5(163.41,156.6) 163.15,156.35 163.15,155.97 162.84,155.66 160.11,155.66 154.88,150.44 154.42,149.98 143.34,149.98 143.14,149.79 143.14,149.16 142.75,148.77 142.19,148.77 141.8,149.16 141.8,149.79 141.61,149.98 141.13,149.98 140.48,149.98 140.48,149.98 140.34,149.98 129.11,161.2 115.34,161.2 98.15,178.39 97.4,178.39 97.4,178.39 96.64,178.39 96.44,178.59 96.24,178.59
  BOTTOM w0.14: v5(86.47,180.31) 85.84,179.69 v3(85.84,179.44)
M_DQS_B_DP5: length 102.5
  TOP w0.14: CPU1.AP8 86.93,174.98 v5(86.54,175.37) ; v5(166.43,150.23) 166.84,150.63 167.49,150.63 167.77,150.35 DIMM2.154
  L3 w0.102: 94.32,175.02 94.24,175.1 94.24,175.23 93.69,175.77 91.43,175.77 90.57,174.92 87.09,174.92 86.63,175.37 v5(86.54,175.37)
  L3 w0.191: v5(166.43,150.23) 166.18,149.97 166.18,149.76 165.84,149.43 164.63,149.43 163.63,150.43 161.04,150.43 153.46,142.85 150.8,142.85 150.41,142.46 139.87,142.46 127.61,154.72 115.23,154.72 96,173.96 95.39,173.96 94.32,175.02
  BOTTOM w0.14: v3(166.46,151.09) 166.46,150.26 v5(166.43,150.23)
M_DQS_B_DP6: length 112.2
  TOP w0.14: v5(162.67,144.64) 162.13,145.18 161.6,145.18 161.52,145.25 DIMM2.171 ; v2(84.68,175.4) 84.19,174.91 CPU1.AL8
  L3 w0.102: 84.78,168.38 84.78,168.74 85.31,169.28 85.31,171.83 85.01,172.13 85.01,173.69 84.62,174.08 84.53,174.08 84.24,174.37 84.24,174.97 v2(84.68,175.4)
  L3 w0.191: v5(162.67,144.64) 162.67,144.97 162.52,145.13 161.76,145.13 152.51,135.88 144.82,135.88 144.14,136.56 139.03,136.56 126.05,149.54 122.66,149.54 121.91,148.79 121.35,148.79 120.96,149.19 120.96,149.35 120.77,149.54 120.39,149.54 120.2,149.35 120.2,148.99 119.83,148.63 119.21,148.63 118.85,148.99 118.85,149.35 118.66,149.54 118.28,149.54 118.09,149.35 118.09,148.99 117.73,148.63 117.1,148.63 116.74,148.99 116.74,149.35 116.55,149.54 116.17,149.54 115.98,149.35 115.98,148.99 115.62,148.63 114.99,148.63 114.63,148.99 114.63,149.35 114.44,149.54 112.62,149.54 98.33,163.83 88.79,163.83 84.78,167.84 84.78,168.38
  BOTTOM w0.14: v3(162.53,145.55) 162.67,145.41 v5(162.67,144.64)
M_DQS_B_DP7: length 123.1
  TOP w0.14: v5(80.08,173.55) 80.08,173.55 CPU1.AG7 ; DIMM2.188 166.94,140.15 v5(166.35,139.56)
  L3 w0.102: 79.1,170.06 79.15,170.1 79.15,170.78 78.53,171.4 78.53,172.28 79.57,173.31 79.84,173.31 v5(80.08,173.55)
  L3 w0.191: v5(166.35,139.56) 166.24,139.56 165.53,138.85 162.95,138.85 162.39,138.29 162.39,138.27 154.34,130.23 136.16,130.23 125.77,140.62 125.77,141.13 126.11,141.47 126.11,141.74 125.84,142.01 125.57,142.01 125.23,141.67 124.72,141.67 124.28,142.11 124.28,142.62 124.62,142.97 124.62,143.23 124.35,143.5 124.08,143.5 123.74,143.16 123.22,143.16 122.48,143.9 111.91,143.9 97.91,157.9 85.15,157.9 78.67,164.37 78.67,168.41 79.1,168.85 79.1,170.06
  BOTTOM w0.14: v3(166.85,140.35) 166.85,140.05 v5(166.35,139.56)
M_MAA_A0: length 76
  TOP w0.165: v5(91.92,183.98) 92.39,183.51 CPU1.AW15
  TOP w0.216: DIMM1.98 152.13,167.15 151.25,168.03 150.61,168.03 v5(149.72,168.92)
  L4 w0.102: 92.37,187.18 91.85,187.18 91.53,186.87 91.53,185.33 91.92,184.95 v5(91.92,183.98)
  L4 w0.292: 92.37,187.18 92.47,187.08 93.16,187.08 94.28,185.96 98.32,185.96 108.35,175.93 124.55,175.93 132.78,167.71 143.91,167.71 144.62,168.41 149.22,168.41 149.72,168.91 v5(149.72,168.92)
  BOTTOM w0.216: v5(149.72,168.92) 149.72,168.43 v3(149.45,168.16)
M_MAA_A1: length 77
  TOP w0.216: DIMM1.97 146.8,167.45 v5(148.3,168.95) ; v5(91.03,185.81) CPU1.AU18
  L4 w0.102: 93.59,187.77 93.31,188.05 92.43,188.05 91.28,186.9 91.28,186.63 91.03,186.37 v5(91.03,185.81)
  L4 w0.292: 93.59,187.77 94.4,186.96 98.61,186.96 108.75,176.82 127.15,176.82 133.37,170.6 133.37,170.04 132.89,169.56 132.89,169.1 133.39,168.6 137.13,168.6 137.42,168.89 137.42,169.33 137.72,169.62 138.3,169.62 138.59,169.33 138.59,168.89 138.88,168.6 139.47,168.6 139.76,168.89 139.76,169.33 140.05,169.62 140.64,169.62 140.93,169.33 140.93,168.89 141.22,168.6 143.53,168.6 144.52,169.58 147.97,169.58 148.3,169.26 v5(148.3,168.95)
  BOTTOM w0.216: v3(148.1,169.71) 148.3,169.52 v5(148.3,168.95)
M_MAA_A2: length 76.2
  TOP w0.216: v5(90.16,185.8) 90.58,185.38 CPU1.AU17 ; DIMM1.96 152.29,167.75 v5(151.17,168.87)
  L4 w0.102: v5(90.16,185.8) 91.05,186.7 91.05,186.96 92.35,188.25 93.67,188.25 94.07,187.84
  L4 w0.292: v5(151.17,168.87) 151.17,168.93 150.62,169.48 148.81,169.48 148.22,170.06 136.44,170.06 136.19,169.81 136.19,169.33 135.98,169.12 134.99,169.12 134.77,169.35 134.77,169.89 127.3,177.35 108.98,177.35 98.91,187.43 94.49,187.43 94.07,187.84
  BOTTOM w0.216: v3(151.96,167.98) 151.17,168.77 v5(151.17,168.87)
M_MAA_A3: length 76.6
  TOP w0.216: v5(146.88,168.95) 146.88,168.59 146.34,168.05 DIMM1.95 ; v5(92.73,187.64) 92.7,187.64 92.54,187.8 92.13,187.8 CPU1.AV19
  L4 w0.292: v5(146.88,168.95) 144.52,168.95 143.73,168.15 132.96,168.15 131.91,169.2 131.91,169.61 132.57,170.27 132.57,170.68 132.16,171.1 131.74,171.1 131.09,170.44 130.67,170.44 130.26,170.85 130.26,171.27 130.92,171.92 130.92,172.34 130.5,172.75 130.09,172.75 129.43,172.09 129.02,172.09 128.61,172.51 128.61,172.92 129.26,173.58 129.26,173.99 128.85,174.4 128.44,174.4 127.78,173.75 127.37,173.75 126.96,174.16 126.96,174.57 127.61,175.23 127.61,175.64 127.2,176.06 126.79,176.06 126.13,175.4 125.72,175.4 124.74,176.38 108.57,176.38 98.43,186.51 94.29,186.51 93.16,187.64 v5(92.73,187.64)
  BOTTOM w0.216: v3(146.5,169.71) 146.88,169.33 v5(146.88,168.95)
M_MAA_A4: length 77.3
  TOP w0.216: v5(90.12,186.69) 90.12,186.95 89.9,187.17 CPU1.AT19 ; DIMM1.92 152.54,168.95 151.73,169.76 151.35,169.76 150.66,170.45 v5(150.66,170.57)
  L4 w0.102: v5(90.12,186.69) 90.12,187.25 90.89,188.02 91.81,188.02 92.25,188.45 94.02,188.45 94.23,188.25
  L4 w0.292: 94.23,188.25 94.61,187.87 99.1,187.87 109.16,177.81 127.55,177.81 131.41,173.95 131.82,173.95 132.12,174.25 132.53,174.25 132.95,173.84 132.95,173.42 132.65,173.13 132.65,172.71 133.06,172.3 133.48,172.3 133.77,172.6 134.19,172.6 134.6,172.19 134.6,171.77 134.3,171.47 134.3,171.06 134.85,170.51 148.41,170.51 148.85,170.06 150.15,170.06 v5(150.66,170.57)
  BOTTOM w0.216: v5(150.66,170.57) 151.17,170.57 v3(151.45,170.29)
M_MAA_A5: length 78.7
  TOP w0.216: DIMM1.91 146.47,169.25 146.86,169.65 148.28,169.65 v5(149.22,170.59) ; CPU1.AU20 91.04,188.54 93.12,188.54 v2(93.52,188.94)
  L4 w0.292: v2(93.52,188.94) 94.1,188.94 94.72,188.31 99.28,188.31 109.34,178.26 117.36,178.26 117.65,178.55 117.65,178.68 117.95,178.97 118.53,178.97 118.82,178.68 118.82,178.55 119.11,178.26 119.7,178.26 119.99,178.55 119.99,178.68 120.28,178.97 120.87,178.97 121.16,178.68 121.16,178.55 121.45,178.26 122.03,178.26 122.33,178.55 122.33,178.68 122.62,178.97 123.2,178.97 123.5,178.68 123.5,178.55 123.79,178.26 124.37,178.26 124.66,178.55 124.66,178.68 124.96,178.97 125.54,178.97 125.83,178.68 125.83,178.55 126.12,178.26 126.71,178.26 127,178.55 127,178.68 127.29,178.97 128.58,178.97 129.25,178.3 129.25,177.88 128.89,177.52 128.89,177.11 129.3,176.69 129.71,176.69 130.08,177.06 130.49,177.06 130.9,176.64 130.9,176.23 130.54,175.87 130.54,175.45 130.95,175.04 131.37,175.04 131.73,175.4 132.14,175.4 136.57,170.97 148.84,170.97 v5(149.22,170.59)
  BOTTOM w0.216: v3(94.13,188.28) 94.13,188.33 v2(93.52,188.94)
M_MAA_A6: length 76.8
  TOP w0.102: v5(92.8,189.72) 93.65,189.72 94,189.37 94,188.76 93.32,188.08 CPU1.AV20
  TOP w0.216: DIMM1.90 152.6,169.55 151.96,170.19 151.96,170.67 151.57,171.06 150.4,171.06 v5(149.75,171.72)
  L4 w0.292: v5(92.8,189.72) 92.94,189.86 94.42,189.86 95.08,189.2 99.99,189.2 108.49,180.71 116.1,180.71 116.39,180.41 116.39,180.15 116.68,179.86 117.27,179.86 117.56,180.15 117.56,180.41 117.85,180.71 118.44,180.71 118.73,180.41 118.73,180.15 119.02,179.86 128.95,179.86 136.91,171.9 144.45,171.9 145.02,172.47 148.01,172.47 148.27,172.22 149.25,172.22 149.75,171.72 v5(149.75,171.72)
  BOTTOM w0.216: v3(93.59,190.13) 93.21,190.13 v5(92.8,189.72)
M_MAA_A7: length 77.8
  TOP w0.216: v5(151.32,171.72) 151.44,171.72 152.41,170.75 DIMM1.86 ; v5(90.14,189.45) 90.14,189.45 90.58,189.01 CPU1.AU21
  L4 w0.102: 94.61,190.66 94.51,190.56 91.25,190.56 v5(90.14,189.45)
  L4 w0.292: v5(151.32,171.72) 151.47,171.86 151.47,173.28 150.84,173.9 147.07,173.9 146.99,173.98 140.15,173.98 139.57,173.39 138.7,173.39 137.12,174.97 136.71,174.97 136.42,174.69 136.01,174.69 135.59,175.1 135.59,175.51 135.88,175.8 135.88,176.21 135.47,176.63 135.05,176.63 134.77,176.34 134.35,176.34 133.94,176.75 133.94,177.17 134.23,177.45 134.23,177.87 129.99,182.1 109.42,182.1 100.86,190.66 94.61,190.66
  BOTTOM w0.216: v5(151.32,171.72) v3(152.16,171.72)
M_MAA_A8: length 76.5
  TOP w0.216: v5(148.29,171.57) 148.26,171.57 146.55,169.85 DIMM1.89 ; v5(90.12,188.55) 89.67,188.1 CPU1.AT20
  L4 w0.292: v5(148.29,171.57) 147.83,172.03 145.31,172.03 144.74,171.46 136.72,171.46 128.76,179.41 116.41,179.41 116.12,179.12 116.12,178.99 115.82,178.7 115.24,178.7 114.95,178.99 114.95,179.73 114.66,180.02 114.07,180.02 113.78,179.73 113.78,178.99 113.49,178.7 112.9,178.7 112.61,178.99 112.61,179.73 112.32,180.02 111.73,180.02 111.44,179.73 111.44,178.99 111.15,178.7 110.57,178.7 110.27,178.99 110.27,179.12 109.98,179.41 108.96,179.41 99.61,188.76 94.83,188.76 94.13,189.46 93.3,189.46 92.59,188.75 92.12,188.75 91.92,188.55 v5(90.12,188.55)
  BOTTOM w0.216: v3(89.68,187.77) 89.68,188.12 90.11,188.55 v5(90.12,188.55)
M_MAA_A9: length 79.3
  TOP w0.216: v5(150.23,172.79) 149.66,172.22 147.42,172.22 146.25,171.05 DIMM1.85 ; CPU1.AT22 89.67,189.87 v2(89.22,189.42)
  L4 w0.102: 95.29,190.16 95.09,190.36 91.42,190.36 90.65,189.6 90.65,189.4 90.3,189.05 89.75,189.05 89.38,189.42 v2(89.22,189.42)
  L4 w0.292: v5(150.23,172.79) 150.23,172.82 149.66,173.39 146.96,173.39 146.88,173.46 146.81,173.53 140.67,173.53 140.02,172.88 137.18,172.88 132.62,177.44 132.62,177.86 132.91,178.15 132.91,178.56 132.49,178.97 132.08,178.97 131.79,178.68 131.38,178.68 130.97,179.1 130.97,179.51 131.25,179.8 131.25,180.21 129.81,181.66 109.23,181.66 100.74,190.16 95.29,190.16
  BOTTOM w0.216: v5(150.23,172.79) 150.23,173.06 v3(150.72,173.54)
M_MAA_A10: length 73.9
  TOP w0.216: v5(93.95,181.88) 93.95,181.98 CPU1.AY14 ; DIMM1.107 146.73,164.45 v5(146.96,164.22)
  L4 w0.292: v5(146.96,164.22) 145.53,164.22 145.35,164.04 128.93,164.04 121.74,171.23 118.66,171.23 118.36,171.52 118.36,171.96 118.07,172.25 117.49,172.25 117.2,171.96 117.2,171.52 116.9,171.23 116.32,171.23 116.03,171.52 116.03,171.96 115.74,172.25 115.15,172.25 114.86,171.96 114.86,171.52 114.57,171.23 113.98,171.23 113.69,171.52 113.69,171.96 113.4,172.25 112.81,172.25 112.52,171.96 112.52,171.52 112.23,171.23 111.65,171.23 111.35,171.52 111.35,171.96 111.06,172.25 110.48,172.25 110.19,171.96 110.19,171.52 109.89,171.23 109.31,171.23 109.02,171.52 109.02,171.96 108.72,172.25 108.14,172.25 107.85,171.96 107.85,171.52 107.56,171.23 106.34,171.23 105.85,171.73 105.85,172.14 106.22,172.52 106.22,172.93 105.81,173.34 105.39,173.34 105.02,172.97 104.61,172.97 104.19,173.38 104.19,173.79 104.57,174.17 104.57,174.58 104.15,175 103.74,175 103.37,174.62 102.95,174.62 95.7,181.88 v5(93.95,181.88)
  BOTTOM w0.216: v5(93.95,181.88) v3(94.79,181.88)
M_MAA_A11: length 77.6
  TOP w0.216: DIMM1.84 152.51,171.35 151.9,171.96 151.9,172.52 150.21,174.21 149.39,174.21 148.89,174.7 v5(148.89,174.94) ; CPU1.AU22 91.03,190.35 v2(91.03,191.31)
  L4 w0.102: 95.16,191.17 94.51,191.17 94.13,190.79 91.55,190.79 v2(91.03,191.31)
  L4 w0.292: v5(148.89,174.94) 148.89,174.88 148.36,174.35 147.25,174.35 147.18,174.42 138.3,174.42 130.14,182.59 109.62,182.59 104.73,187.48 104.73,187.89 105.12,188.28 105.12,188.69 104.7,189.1 104.29,189.1 103.9,188.72 103.49,188.72 103.08,189.13 103.08,189.54 103.46,189.93 103.46,190.34 103.05,190.76 102.64,190.76 102.25,190.37 101.84,190.37 101.03,191.17 95.16,191.17
  BOTTOM w0.216: v3(91,192.14) 91,191.34 v2(91.03,191.31)
M_MAA_A12: length 76.1
  TOP w0.165: CPU1.AV22 91.63,189.91 92.09,189.44 v5(92.14,189.44)
  TOP w0.216: v5(148.79,172.77) 147.45,172.77 146.33,171.65 DIMM1.83
  L4 w0.102: 95.24,189.67 94.76,190.16 92.66,190.16 92.14,189.64 v5(92.14,189.44)
  L4 w0.292: 95.24,189.67 100.37,189.67 108.83,181.22 119.4,181.22 119.69,180.92 119.69,180.59 119.98,180.3 120.57,180.3 120.86,180.59 120.86,180.92 121.15,181.22 121.74,181.22 122.03,180.92 122.03,180.59 122.32,180.3 122.91,180.3 123.2,180.59 123.2,180.92 123.49,181.22 124.07,181.22 124.37,180.92 124.37,180.59 124.66,180.3 125.24,180.3 125.53,180.59 125.53,180.92 125.83,181.22 126.31,181.22 126.6,180.92 126.6,180.59 126.89,180.3 127.48,180.3 127.77,180.59 127.77,180.92 128.06,181.22 129.43,181.22 130.05,180.59 130.05,180.18 129.86,179.99 129.86,179.58 137.01,172.43 140.2,172.43 140.86,173.09 146.63,173.09 146.8,172.92 148.64,172.92 v5(148.79,172.77)
  BOTTOM w0.216: v3(149.22,173.65) 148.79,173.22 v5(148.79,172.77)
M_MAA_A13: length 73
  TOP w0.216: CPU1.AV12 91.44,180.7 91.4,180.7 v5(91,180.3) ; DIMM1.119 147.71,160.85 148.5,161.64 v5(148.5,161.81)
  L4 w0.292: v5(148.5,161.81) 148.01,161.32 123.75,161.32 118.87,166.2 118.87,166.61 119.13,166.87 119.13,167.28 118.72,167.7 118.3,167.7 118.04,167.44 117.63,167.44 117.32,167.75 107.68,167.75 107.39,168.05 107.39,168.12 107.09,168.41 106.51,168.41 106.14,168.05 105.44,168.05 95.11,178.38 92.27,178.38 91,179.64 v5(91,180.3)
  BOTTOM w0.216: v5(91,180.3) 91,179.34 v3(90.95,179.28)
M_MAA_A14: length 75.6
  TOP w0.216: v5(92.02,191.32) 92.01,191.32 91.98,191.28 91.96,191.28 CPU1.AV23 ; v5(148.31,176.03) 148.89,175.45 149.67,175.45 152.57,172.55 DIMM1.80
  L4 w0.292: v5(92.02,191.32) 92.53,191.83 92.92,191.83 93.19,192.09 103.55,192.09 104.09,191.56 104.09,191.14 104.62,190.61 105.08,190.61 105.45,190.99 105.87,190.99 106.27,190.58 106.27,190.17 105.81,189.7 105.81,189.29 106.22,188.88 106.63,188.88 107.09,189.33 107.5,189.33 111.24,185.59 111.24,185.18 110.95,184.89 110.95,184.48 111.36,184.07 111.78,184.07 112.06,184.35 112.48,184.35 113.26,183.56 127.54,183.56 130.42,183.56 138.48,175.5 147.82,175.5 148.3,175.98 148.3,176.02 v5(148.31,176.03)
  BOTTOM w0.216: v5(148.31,176.03) 148.31,176.53 v3(148.02,176.82)
M_MAA_A15: length 77
  TOP w0.216: v5(90.1,192.22) 90.58,191.74 CPU1.AU24 ; v5(149.92,176.08) 149.92,175.73 152.5,173.15 DIMM1.78
  L4 w0.292: v5(90.1,192.22) 92.76,192.22 93.34,192.8 94.84,192.8 95.69,193.65 96.62,193.65 97.27,193 98.29,193 98.58,193.29 98.58,193.72 98.88,194.02 99.46,194.02 99.75,193.72 99.75,193.29 100.04,193 100.63,193 100.92,193.29 100.92,193.72 101.21,194.02 101.8,194.02 102.09,193.72 102.09,193.29 102.38,193 106.82,193 115.23,184.59 130.75,184.59 138.76,176.59 149.42,176.59 v5(149.92,176.08)
  BOTTOM w0.216: v5(149.92,176.08) 149.92,175.9 v3(150.46,175.37)
M_MAA_B0: length 99.4
  TOP w0.216: DIMM2.98 166.3,167.15 v5(164.98,168.46) ; v5(84.67,187.65) 85.1,187.22 CPU1.AL19
  L3 w0.102: v5(84.67,187.65) 85.08,188.07 85.08,188.94 86.09,189.95 86.68,189.95 86.94,190.21 88.13,190.21 88.31,190.39 93.23,190.39 93.61,190
  L3 w0.292: v5(164.98,168.46) 164.65,168.79 160.37,168.79 159.94,168.36 157.52,168.36 156.62,167.46 141.06,167.46 135.22,173.29 120.16,173.29 106.53,186.92 106.53,187.33 106.85,187.66 106.85,188.07 106.44,188.48 106.03,188.48 105.7,188.16 105.29,188.16 104.78,188.67 96.11,188.67 95.67,189.11 94.5,189.11 93.61,190
  BOTTOM w0.216: v5(84.67,187.65) 84.7,187.69 v3(85.59,187.69)
M_MAA_B1: length 100.2
  TOP w0.216: v5(164.65,169.38) 163.81,168.54 163.06,168.54 162.23,167.71 161.64,167.71 161.38,167.45 DIMM2.97 ; v2(84.63,190.38) CPU1.AL22
  L3 w0.102: v2(84.63,190.38) 85.08,189.93 85.69,189.93 86.06,190.3 86.06,190.48 86.34,190.76 86.69,190.76 86.81,190.63 87.98,190.63 88.14,190.79 88.53,190.79 93.73,190.79 94.12,190.4 94.26,190.4
  L3 w0.292: v5(164.65,169.38) 164.43,169.6 164.43,169.63 163.69,170.38 160.63,170.38 159.53,169.28 157.17,169.28 156.24,168.34 141.79,168.34 135.57,174.57 120.14,174.57 115.39,179.32 115.39,179.73 115.54,179.87 115.54,180.28 115.12,180.7 114.71,180.7 114.57,180.55 114.15,180.55 113.74,180.97 113.74,181.38 114.21,181.85 114.21,182.27 106.63,189.85 94.81,189.85 94.26,190.4
  BOTTOM w0.216: v5(164.65,169.38) 164.65,170.16 v3(164.69,170.19)
M_MAA_B2: length 98.4
  TOP w0.216: DIMM2.96 167.09,167.75 166.45,168.39 v5(166.45,168.41) ; CPU1.AM22 86.01,189.92 v2(85.54,190.39)
  L3 w0.102: v2(85.54,190.39) 86.11,190.96 87.12,190.96 87.25,190.84 87.59,190.84 87.82,191.08 87.82,191.42 88.18,191.78 92.71,191.78 92.86,191.63 94.04,191.63 94.61,191.06 94.61,190.66
  L3 w0.292: 94.61,190.66 94.91,190.36 106.75,190.36 117.21,179.9 117.21,179.48 116.83,179.1 116.83,178.68 117.24,178.27 117.65,178.27 118.04,178.66 118.45,178.66 122.09,175.02 136.29,175.02 141.45,169.86 144.72,169.86 144.98,169.6 156.4,169.6 157.26,170.46 160.08,170.46 160.44,170.82 164.08,170.82 166.45,168.45 v5(166.45,168.41)
  BOTTOM w0.216: v5(166.45,168.41) 166.45,168.65 166.64,168.85 166.64,169.18 v3(166.59,169.23)
M_MAA_B3: length 98.6
  TOP w0.216: DIMM2.95 161.46,168.05 161.48,168.08 161.81,168.08 163.13,169.4 v5(163.15,169.4) ; CPU1.AM23 86.04,190.83 v5(86.51,190.35)
  L3 w0.102: v5(86.51,190.35) 86.65,190.35 86.71,190.41 88.05,190.41 88.22,190.59 93.64,190.59 94.79,189.44 96,189.44 96.11,189.34
  L3 w0.292: 96.11,189.34 106.5,189.34 108.13,187.7 108.13,187.29 107.67,186.83 107.67,186.41 108.08,186 108.49,186 108.96,186.47 109.37,186.47 109.79,186.05 109.79,185.64 109.32,185.17 109.32,184.76 109.73,184.35 110.15,184.35 110.61,184.81 111.02,184.81 111.44,184.4 111.44,183.99 110.97,183.52 110.97,183.11 111.52,182.56 111.93,182.56 112.11,182.73 112.52,182.73 112.93,182.32 112.93,181.91 112.76,181.73 112.76,181.32 119.95,174.13 135.04,174.13 141.27,167.9 156.43,167.9 157.36,168.83 159.74,168.83 160.84,169.93 162.66,169.93 163.13,169.46 163.13,169.43 v5(163.15,169.4)
  BOTTOM w0.216: v3(85.59,191.32) 85.67,191.32 86.51,190.48 v5(86.51,190.35)
M_MAA_B4: length 97.2
  TOP w0.216: v5(164.02,172.03) 164.02,171.03 166.1,168.95 DIMM2.92 ; v5(87.42,191.24) 87.45,191.21 87.46,191.21 87.84,190.83 CPU1.AP23
  L3 w0.102: 95.14,191.07 94.36,191.86 93.77,191.86 93.52,192.11 90.78,192.11 90.26,192.63 88.74,192.63 87.42,191.3 v5(87.42,191.24)
  L3 w0.292: 95.14,191.07 95.35,190.87 106.87,190.87 107.74,190 108.15,190 108.62,190.47 109.03,190.47 109.44,190.05 109.44,189.64 108.98,189.17 108.98,188.76 122.24,175.5 136.59,175.5 141.72,170.37 145.08,170.37 145.4,170.05 156.16,170.05 157.72,171.61 163.59,171.61 v5(164.02,172.03)
  BOTTOM w0.216: v5(164.02,172.03) 164.02,172.03 163.47,171.49 v3(163.29,171.49)
M_MAA_B5: length 99.8
  TOP w0.216: DIMM2.91 161.4,169.25 163.41,171.26 163.41,172.19 164.18,172.96 v5(164.25,172.96) ; CPU1.AL23 84.65,191.27 v5(84.65,191.3)
  L3 w0.102: 93.87,192.19 93.72,192.34 90.98,192.34 90.49,192.83 88.27,192.83 87.14,191.71 85.06,191.71 v5(84.65,191.3)
  L3 w0.292: v5(164.25,172.96) 163.86,172.56 163.8,172.56 163.29,172.05 157.17,172.05 155.8,170.68 154.62,170.68 154.18,171.13 149.01,171.13 148.86,170.97 141.75,170.97 136.77,175.96 122.41,175.96 112.23,186.13 112.23,186.93 111.8,187.37 111,187.37 110.58,187.78 110.58,188.2 111.05,188.67 111.05,189.08 108.81,191.32 95.45,191.32 94.58,192.19 93.87,192.19
  BOTTOM w0.216: v5(164.25,172.96) 164.82,172.96 165,172.77 v3(165.03,172.77)
M_MAA_B6: length 91.2
  TOP w0.216: CPU1.AW26 92.41,193.57 v2(92.88,194.04) ; v5(166.43,170.14) 167.02,169.55 DIMM2.90
  L3 w0.102: 97.15,192.82 96.41,193.56 95.93,193.56 95.53,193.17 93.76,193.17 v2(92.88,194.04)
  L3 w0.292: 97.15,192.82 97.31,192.66 109.39,192.66 119.2,182.85 119.2,181.06 122.73,177.53 137.94,177.53 141.63,173.84 153.3,173.84 153.86,174.4 163.58,174.4 165.26,172.73 165.26,171.8 165.04,171.59 165.04,170.91 165.81,170.14 v5(166.43,170.14)
  BOTTOM w0.216: v2(92.88,194.04) 91.97,194.96 v3(91.86,194.96)
M_MAA_B7: length 89.3
  TOP w0.216: CPU1.AY26 93.33,193.6 v5(93.72,193.99) ; DIMM2.86 166.79,170.75 v5(166.35,171.18)
  L3 w0.292: v5(93.72,193.99) 93.93,193.78 93.93,193.76 94.22,193.46 95.41,193.46 95.8,193.86 97.13,193.86 97.88,193.1 109.57,193.1 120.72,181.95 120.72,181.54 120.24,181.06 120.24,180.64 120.66,180.23 121.07,180.23 121.55,180.71 121.96,180.71 124.64,178.04 138.37,178.04 142.13,174.28 153.1,174.28 153.67,174.85 163.77,174.85 165.77,172.84 165.77,171.77 v5(166.35,171.18)
  BOTTOM w0.216: v3(93.74,194.85) 93.72,194.83 v5(93.72,193.99)
M_MAA_B8: length 92.1
  TOP w0.216: DIMM2.89 161.31,169.85 162.95,171.49 162.95,172.49 v5(163.42,172.96) ; v5(90.1,194) 90.53,193.57 CPU1.AU26
  L3 w0.102: v5(90.1,194) 91.53,192.57 94.84,192.57
  L3 w0.292: v5(163.42,172.96) 162.58,172.96 162.25,172.63 151.55,172.63 151.17,172.24 147.39,172.24 147.05,171.9 141.57,171.9 137.03,176.44 122.56,176.44 114.85,184.15 114.85,184.56 115.17,184.88 115.17,185.3 114.75,185.71 114.34,185.71 114.02,185.39 113.61,185.39 113.19,185.8 113.19,186.22 113.68,186.7 113.68,187.11 109.02,191.77 95.64,191.77 94.84,192.57
  BOTTOM w0.216: v3(162.71,172.58) 163.04,172.58 v5(163.42,172.96)
M_MAA_B9: length 89.1
  TOP w0.102: v5(91.92,194.04) 91.99,194.12 91.99,194.13 92.34,194.48 CPU1.AW27
  TOP w0.216: v5(162.84,173.68) 162.54,173.38 162.54,171.83 161.76,171.05 DIMM2.85
  L3 w0.102: 95.73,192.67 95.52,192.87 93.76,192.87 93.02,193.61 92.35,193.61 v5(91.92,194.04)
  L3 w0.292: 95.73,192.67 96.18,192.21 109.21,192.21 116.89,184.53 116.89,184.11 116.41,183.63 116.41,183.21 116.82,182.8 117.24,182.8 117.72,183.29 118.13,183.29 118.55,182.87 118.55,182.46 118.06,181.98 118.06,181.56 122.68,176.95 137.74,176.95 141.29,173.39 154.2,173.39 154.76,173.96 162.57,173.96 v5(162.84,173.68)
  BOTTOM w0.216: v3(162.76,174.51) 162.73,174.48 162.73,173.82 162.84,173.71 v5(162.84,173.68)
M_MAA_B10: length 97.4
  TOP w0.216: v5(88.3,186.68) 87.87,186.25 CPU1.AP18 ; DIMM2.107 161.25,164.45 v5(161.95,165.15)
  L3 w0.102: v5(88.3,186.68) 88.34,186.68 88.97,187.3 90.75,187.3 90.88,187.17 92.18,187.17 92.37,186.98 94.46,186.98 95.85,185.58
  L3 w0.292: 95.85,185.58 101.92,185.58 107.85,179.65 108.27,179.65 108.53,179.91 108.95,179.91 109.36,179.5 109.36,179.09 109.09,178.82 109.09,178.41 109.41,178.09 109.82,178.09 110.09,178.36 110.5,178.36 110.91,177.95 110.91,177.53 110.65,177.27 110.65,176.85 111.06,176.44 111.47,176.44 111.74,176.71 112.15,176.71 112.57,176.29 112.57,175.88 112.3,175.61 112.3,175.2 112.71,174.79 113.13,174.79 113.39,175.05 113.81,175.05 114.22,174.64 114.22,174.23 113.95,173.96 113.95,173.55 114.37,173.13 114.78,173.13 115.05,173.4 115.46,173.4 115.87,172.99 115.87,172.58 115.6,172.31 115.6,171.9 116.02,171.48 116.43,171.48 116.7,171.75 117.11,171.75 118.8,170.06 132,170.06 139.6,162.46 144.18,162.46 144.48,162.17 144.48,161.31 144.77,161.02 145.35,161.02 145.64,161.31 145.64,162.17 145.94,162.46 152.74,162.46 153.16,162.88 158.05,162.88 160.32,165.15 v5(161.95,165.15)
  BOTTOM w0.216: v3(162.22,164.22) 161.95,164.5 v5(161.95,165.15)
M_MAA_B11: length 92
  TOP w0.216: DIMM2.84 167.02,171.35 v5(166.4,171.97) ; v5(90.1,194.96) 90.58,194.48 CPU1.AU27
  L3 w0.102: 96.49,194.37 93.91,194.37 93.81,194.47 91.77,194.47 91.51,194.21 91.51,193.95 91.17,193.61 90.83,193.61 90.59,193.85 90.59,194.46 v5(90.1,194.96)
  L3 w0.292: 96.49,194.37 96.71,194.59 108.71,194.59 124.76,178.55 138.68,178.55 141.74,175.48 160.13,175.48 160.29,175.33 163.91,175.33 166.4,172.84 v5(166.4,171.97)
  BOTTOM w0.216: v5(166.4,171.97) 166.4,172.11 v3(167.05,172.76)
M_MAA_B12: length 91.9
  TOP w0.216: CPU1.AV27 91.47,194.48 v5(91,194.02) ; v5(163.79,176.01) 163.79,175.76 162.16,174.13 162.16,172.24 161.57,171.65 DIMM2.83
  L3 w0.127: v5(91,194.02) 91.86,194.88 91.94,194.88
  L3 w0.292: v5(163.79,176.01) 163.55,175.77 160.47,175.77 160.28,175.97 153.52,175.97 152.76,176.72 141.34,176.72 139.06,179.01 127.2,179.01 126.9,179.3 126.9,180.29 126.61,180.58 126.03,180.58 125.74,180.29 125.74,179.3 125.44,179.01 124.93,179.01 108.9,195.04 95.79,195.04 95.46,194.71 94.44,194.71 94.27,194.88 91.94,194.88
  BOTTOM w0.216: v5(163.79,176.01) 164.2,176.42 164.2,176.72 v3(164.25,176.77)
