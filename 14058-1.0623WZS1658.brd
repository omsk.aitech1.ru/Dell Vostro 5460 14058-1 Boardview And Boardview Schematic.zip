# Allegro board 14058-1.0623WZS1658.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWROK3_2: length 4.8
  TOP w0.102: U109.75 102.85,59.21 102.69,59.04 101.23,59.04 v1(100.9,58.71) 99.83,57.64 R295.1
PWROK3_2_R: length 10
  TOP w0.102: R295.2 98.62,57.52 98.29,57.19 96.69,57.19 96.13,57.74 96.13,60.67 97.05,61.58 v1(97.2,61.58) 97.2,61.92 R340.1 R265.1
Q28_B: length 3.8
  BOTTOM w0.254: R1801.2 174.25,207.76 v3(173.04,207.76) 171.11,207.76 Q76.B
Q28_C: length 5.1
  BOTTOM w0.254: Q76.C 169.04,205.03 168.22,204.2 v3(167.84,204.2) 167.84,204.25 167.33,204.76 R1957.1
QSA0: length 21.9
  TOP w0.127: v5(70.24,90.94) 69.91,90.61 69.52,90.61 69.31,90.4 68.97,90.4 VRAM2.F3 ; GPU1.E19 76.55,103.01 v5(76.53,103.01)
  L3 w0.152: v5(76.53,103.01) 76.64,103.12 76.81,103.12 77,102.92 77,102.01 76.73,101.74 76.65,101.74 75.84,100.93 75.84,100.08 75.96,99.96 75.96,98.77 75.85,98.66 75.85,95.83 75.29,95.27 75.11,95.27 74.91,95.48 74.73,95.48 74.49,95.24 74.49,95.06 74.61,94.93 74.61,94.59 74.16,94.14 73.9,94.14 73.46,93.7 73.03,93.7 72.77,93.45 72.77,93.01 71.38,91.62 71.38,91.15 70.81,90.59 70.59,90.59 v5(70.24,90.94)
  BOTTOM w0.127: v5(70.24,90.94) 70.68,90.5 71.02,90.5 71.1,90.59 71.8,90.59 VRAM4.F3
QSA1: length 18.7
  TOP w0.127: v5(84.33,90.63) 84.1,90.4 83,90.4 VRAM1.F3 ; v5(80.68,102.22) 80.64,102.22 GPU1.C15
  L3 w0.152: v5(84.33,90.63) 83.95,91.01 83.95,91.37 83.68,91.64 83.68,92.09 83.94,92.34 83.94,92.95 83.91,92.98 83.91,98.05 83.27,98.69 82.31,98.69 82.18,98.82 82.18,99.42 81.81,99.8 81.15,99.8 80.91,100.04 80.91,100.65 81.15,100.89 81.15,101.75 v5(80.68,102.22)
  BOTTOM w0.127: v5(84.33,90.63) 84.57,90.38 85.62,90.38 VRAM3.F3
QSA2: length 18.1
  TOP w0.127: GPU1.B16 79.08,100.66 79.08,100.07 80.79,98.36 80.94,98.22 v5(80.94,97.78) ; VRAM1.C7 85.69,93.31 84.55,93.31 v5(84.34,93.1)
  L4 w0.152: v5(80.94,97.78) 80.94,96.44 81.26,96.11 84.41,96.11 84.57,95.95 84.57,95.53 84.41,95.36 83.68,95.36 83.3,94.98 83.3,93.55 83.75,93.1 v5(84.34,93.1)
  BOTTOM w0.127: v5(84.34,93.1) 84.15,93.29 82.93,93.29 VRAM3.C7 ; v3(80.4,98) v5(80.94,97.78)
QSA3: length 15.2
  TOP w0.127: VRAM2.C7 71.89,93.24 71.72,93.41 v5(70.32,93.41) ; v5(74.06,100.63) 74.1,100.63 74.48,101.01 GPU1.B22
  L4 w0.152: v5(74.06,100.63) 74.23,100.63 74.87,99.99 74.87,98.91 74.14,98.17 73.77,98.17 73.3,97.7 72.78,97.7 72.35,97.27 72.35,96.99 71.95,96.58 71.95,96.02 71.67,95.74 71.67,95.36 71.79,95.23 71.79,93.59 71.46,93.26 70.47,93.26 v5(70.32,93.41)
  BOTTOM w0.127: VRAM4.C7 69.01,93.4 70.31,93.4 v5(70.32,93.41)
QSA4: length 24.5
  TOP w0.127: VRAM5.F3 60.44,105.06 60.42,105.03 60.42,103.64 v5(60.47,103.59) ; v5(72.38,111.34) 72.38,111.36 GPU1.R25
  L3 w0.152: v5(72.38,111.34) 71.78,111.94 69.89,111.94 69.24,111.29 68,111.29 67.27,110.55 66.07,110.55 65.54,110.03 63.75,110.03 61.63,107.91 61.63,107.34 61.27,106.97 61.27,104.66 61.02,104.41 59.76,104.41 59.4,104.05 59.4,103.64 59.65,103.39 60.26,103.39 v5(60.47,103.59)
  BOTTOM w0.127: v5(60.47,103.59) 60.46,103.59 60.34,103.47 60.34,103.31 60.57,103.07 60.57,102.79 60.68,102.68 60.94,102.68 61.07,102.56 61.07,102.38 60.94,102.25 VRAM7.F3
QSA5: length 23.5
  TOP w0.127: VRAM6.F3 60.6,119.24 60.6,118.02 v5(60.79,117.84) ; v5(74,114.67) 73.63,115.04 GPU1.W23
  L3 w0.152: v5(74,114.67) 73.72,114.67 73.6,114.79 73.6,115.34 73.47,115.46 72.18,115.46 70.66,116.98 70.66,118.96 69.92,119.7 66.13,119.7 65.6,119.16 65.6,118.55 65.29,118.25 64.51,118.25 64.2,118.55 64.2,118.73 64.07,118.86 60.75,118.86 60.62,118.73 60.62,118 v5(60.79,117.84)
  BOTTOM w0.127: VRAM8.F3 60.52,116.6 60.52,117.57 v5(60.79,117.84)
QSA6: length 14.4
  TOP w0.127: VRAM6.C7 63.48,116.52 63.48,117.67 v5(63.29,117.87) ; GPU1.AB26 70.95,117.52 70.4,118.07 68.93,118.07 68.75,118.25 v5(68.75,118.52)
  L4 w0.152: v5(63.29,117.87) 63.49,118.07 63.49,118.53 64.05,119.09 66.95,119.09 67.37,119.51 68.46,119.51 68.75,119.21 v5(68.75,118.52)
  BOTTOM w0.127: v5(63.29,117.87) 63.51,118.1 63.51,119.2 VRAM8.C7 ; v3(68.74,119.12) v5(68.75,118.52)
QSA7: length 20.4
  TOP w0.127: v5(67.92,111.88) 68.11,112.07 68.11,112.37 68.45,112.71 69.34,112.71 69.89,113.26 70.69,113.26 71.18,112.77 GPU1.T26 ; VRAM5.C7 63.49,102.25 63.6,102.36 63.6,103.11 63.79,103.29 63.79,103.53 v5(63.62,103.69)
  L4 w0.152: v5(67.92,111.88) 68.19,111.61 68.19,110.65 67.62,110.08 67.62,108.15 66.99,107.53 66.99,104.83 66.38,104.21 64.07,104.21 63.62,103.77 v5(63.62,103.69)
  BOTTOM w0.127: v5(67.92,111.88) v3(67.87,112.48) ; VRAM7.C7 63.51,105.18 63.51,103.8 v5(63.62,103.69)
QSA#0: length 21.8
  TOP w0.127: VRAM2.G3 68.69,90.05 68.78,90.14 69.41,90.14 69.63,90.36 70.17,90.36 v5(70.29,90.25) ; v5(76.55,103.81) 76.96,104.22 GPU1.F19
  L3 w0.152: v5(76.55,103.81) 77.31,103.05 77.31,101.89 76.86,101.44 76.78,101.44 76.15,100.81 76.15,100.2 76.26,100.09 76.26,98.65 76.16,98.54 76.16,95.71 74.29,93.84 74.03,93.84 71.68,91.49 71.68,91.03 70.94,90.29 70.33,90.29 v5(70.29,90.25)
  BOTTOM w0.127: v5(70.29,90.25) 71.12,90.25 71.21,90.33 71.43,90.33 VRAM4.G3
QSA#1: length 18.7
  TOP w0.127: GPU1.C14 81.06,101.82 v5(80.66,101.42) ; v5(84.32,89.91) 84.09,90.14 82.98,90.14 VRAM1.G3
  L3 w0.152: v5(80.66,101.42) 80.74,101.34 80.85,101.23 80.85,101.02 80.61,100.78 80.61,99.91 81.02,99.5 81.68,99.5 81.88,99.3 81.88,98.69 82.18,98.39 83.15,98.39 83.61,97.93 83.61,92.8 83.63,92.77 83.63,92.47 83.38,92.21 83.38,91.51 83.64,91.25 83.64,90.59 83.83,90.4 83.83,90.14 84.06,89.91 v5(84.32,89.91)
  BOTTOM w0.127: v5(84.32,89.91) 84.55,90.13 85.67,90.13 VRAM3.G3
QSA#2: length 18
  TOP w0.127: GPU1.A16 79.44,100.08 81.4,98.12 81.88,98.12 82.03,97.97 82.03,97.69 81.88,97.54 v5(81.65,97.54) ; VRAM1.B7 85.6,93.56 84.57,93.56 v5(84.34,93.79)
  L4 w0.152: v5(84.34,93.79) 84.01,93.46 83.82,93.46 83.61,93.67 83.61,94.86 83.81,95.06 84.54,95.06 84.88,95.4 84.88,96.08 84.54,96.42 81.39,96.42 81.24,96.57 81.24,97.34 81.44,97.54 v5(81.65,97.54)
  BOTTOM w0.127: v5(84.34,93.79) 84.1,93.55 83.05,93.55 VRAM3.B7 ; v3(81.7,98.12) v5(81.65,97.54)
QSA#3: length 16.6
  TOP w0.127: v5(74.08,99.62) 74.34,99.62 74.48,99.76 GPU1.A22 ; VRAM2.B7 71.89,93.78 71.77,93.66 70.66,93.66 70.32,94 v5(70.32,94.06)
  L4 w0.152: v5(70.32,94.06) 70.32,94.02 70.77,93.57 71.34,93.57 71.49,93.72 71.49,94.07 71.31,94.25 71.31,94.5 71.49,94.68 71.49,94.98 71.36,95.11 71.36,95.87 71.64,96.15 71.64,96.71 72.05,97.12 72.05,97.39 72.66,98 73.17,98 73.64,98.48 74.01,98.48 74.57,99.03 74.57,99.86 74.39,100.04 74.17,100.04 74.08,99.94 v5(74.08,99.62)
  BOTTOM w0.127: v5(74.08,99.62) 74.19,99.51 v3(74.19,98.39) ; VRAM4.B7 68.92,93.65 69.97,93.65 70.32,94 v5(70.32,94.06)
QSA#4: length 24.5
  TOP w0.127: v5(71.57,111.36) 71.63,111.43 71.83,111.43 71.96,111.3 71.96,110.94 GPU1.P25 ; VRAM5.G3 60.07,105.45 60.16,105.36 60.16,103.89 60.03,103.76 59.89,103.76 v5(59.83,103.82)
  L3 w0.152: v5(59.83,103.82) 59.83,104.05 59.89,104.11 61.15,104.11 61.57,104.53 61.57,106.84 61.94,107.21 61.94,107.78 62.42,108.27 62.6,108.27 62.78,108.09 63.1,108.09 63.3,108.29 63.3,108.48 63.06,108.72 63.06,108.9 63.88,109.72 65.67,109.72 66.19,110.25 66.66,110.25 66.79,110.12 66.79,109.84 66.92,109.71 67.22,109.71 67.35,109.84 67.35,110.2 68.13,110.98 68.38,110.98 68.53,110.83 68.96,110.83 69.11,110.98 69.37,110.98 70.02,111.63 70.37,111.63 70.47,111.53 70.47,111.22 70.53,111.16 70.89,111.16 70.98,111.25 70.98,111.57 71.04,111.63 71.45,111.63 71.57,111.51 v5(71.57,111.36)
  BOTTOM w0.127: VRAM7.G3 60.24,102.25 60.32,102.33 60.32,102.97 59.96,103.32 59.96,103.69 v5(59.83,103.82)
QSA#5: length 23.5
  TOP w0.127: VRAM6.G3 60.34,119.17 60.34,118.08 v5(60.1,117.84) ; GPU1.W22 74.01,115.45 v5(74.01,115.46)
  L3 w0.152: v5(60.1,117.84) 60.31,118.05 60.31,118.86 60.62,119.16 64.2,119.16 64.5,118.86 64.5,118.68 64.63,118.55 65.16,118.55 65.29,118.68 65.29,119.29 66,120 70.05,120 70.96,119.09 70.96,117.11 72.3,115.77 73.7,115.77 v5(74.01,115.46)
  BOTTOM w0.127: v5(60.1,117.84) 60.26,117.67 60.26,116.37 60.17,116.28 VRAM8.G3
QSA#6: length 14.6
  TOP w0.127: v5(67.93,118.52) 67.68,118.52 67.55,118.39 67.55,118.17 67.65,118.07 68.57,118.07 68.83,117.81 70.3,117.81 70.38,117.73 GPU1.AB27 ; v5(63.92,117.87) 63.74,117.68 63.74,116.58 VRAM6.B7
  L4 w0.152: v5(67.93,118.52) 68.16,118.74 68.33,118.74 68.45,118.86 68.45,119.09 68.33,119.2 67.49,119.2 67.07,118.78 64.17,118.78 63.79,118.4 63.79,117.99 v5(63.92,117.87)
  BOTTOM w0.127: v3(67.4,118.83) v5(67.93,118.52) ; VRAM8.B7 63.77,119.21 63.77,118.02 v5(63.92,117.87)
QSA#7: length 20.4
  TOP w0.127: v5(64.25,103.78) 64.25,103.26 64.12,103.14 63.99,103.14 63.86,103.01 63.86,102.43 VRAM5.B7 ; v5(68.96,111.82) 68.95,111.81 68.53,111.81 68.37,111.97 68.37,112.27 68.56,112.46 69.44,112.46 69.99,113 70.58,113 70.82,112.76 70.82,112.48 70.72,112.38 70.49,112.38 70.38,112.48 GPU1.T27
  L4 w0.152: v5(68.96,111.82) 68.5,111.35 68.5,110.52 67.92,109.95 67.92,108.02 67.3,107.4 67.3,104.71 66.5,103.91 64.38,103.91 v5(64.25,103.78)
  BOTTOM w0.127: v5(64.25,103.78) 63.77,104.27 63.77,105.18 VRAM7.B7 ; v3(68.56,111.37) 68.95,111.82 v5(68.96,111.82)
RASA#: length 101.6
  TOP w0.102: VRAM6.J3 57.72,118.76 57.72,117.54 v5(57.59,117.41) ; VRAM2.J3 69.14,87.83 69.8,87.83 70.02,87.62 70.71,87.62 v5(70.86,87.46) ; VRAM5.J3 58.44,105.32 58.03,104.91 58.03,104.61 v5(57.98,104.56) ; GPU1.G24 72.38,104.72 v5(72.37,104.72) ; v5(84.09,87.69) 83.31,87.69 VRAM1.J3
  L3 w0.127: v5(57.98,104.56) 57.6,104.93 57.6,107.53 57.81,107.74 57.81,109.09 57.99,109.28 57.99,111.05 57.75,111.29 57.75,111.67 57.9,111.83 v5(57.9,112.1) ; v5(84.09,87.69) 82.9,87.69 82.57,87.36 79.37,87.36 79.13,87.6 78.61,87.6 78.6,87.62 v5(77.59,87.62) 77.48,87.73 76.03,87.73 75.74,87.44 74.19,87.44 73.6,86.85 71.87,86.85 71.27,87.46 v5(70.86,87.46)
  L4 w0.127: v5(57.59,117.41) 58.33,117.41 58.94,116.8 58.94,115.85 58.84,115.74 58.66,115.74 58.56,115.64 58.56,115.44 58.66,115.34 58.84,115.34 58.94,115.24 58.94,114.54 58.69,114.29 58.69,112.61 58.18,112.1 v5(57.9,112.1) 57.9,111.68 57.95,111.63 57.95,110.96 58.36,110.56 58.36,108.32 59.55,107.12 60.78,107.12 61.16,106.74 61.16,105.24 61.97,104.43 61.97,101.11 61.22,100.36 61.22,99.84 61.47,99.59 62.05,99.59 v5(64.86,96.79) 65.83,95.82 65.83,94.86 66.95,93.74 66.95,92.59 67.25,92.29 67.66,92.29 67.69,92.26 68.48,92.26 68.78,92.56 69.73,92.56 70.01,92.85 70.5,92.85 70.89,92.46 70.89,91.99 71.14,91.75 71.55,91.75 71.87,91.43 71.87,90.91 72.12,90.66 72.4,90.66 72.67,90.39 72.67,90.11 72.92,89.86 73.45,89.86 73.74,89.57 74.24,89.57 74.45,89.36 74.45,88.85 75.58,87.73 77.48,87.73 v5(77.59,87.62)
  BOTTOM w0.102: v5(84.09,87.69) 85.33,87.69 VRAM3.J3 ; VRAM7.J3 58.44,102.76 57.85,103.35 57.85,103.58 57.68,103.76 57.68,104.16 57.98,104.46 v5(57.98,104.56) ; v5(57.59,117.41) 58.44,116.56 VRAM8.J3 ; v5(70.86,87.46) 71.07,87.46 71.34,87.73 VRAM4.J3
  BOTTOM w0.127: 63.54,96.12 63.54,96.07 63.22,95.75 RN7512.2 ; 63.54,96.12 63.26,96.4 RN7512.1 ; 63.54,96.12 63.85,96.12 64.22,95.76 64.56,95.76 64.86,96.06 v5(64.86,96.79) 64.86,98.41 v3(67.33,100.87) 67.56,101.11 67.56,102.56 68.72,103.72 68.72,104.15 69.05,104.48 70.12,104.48 70.32,104.28 71.93,104.28 v5(72.37,104.72)
REMOTE1+: length 200.9
  TOP w0.127: v2(38.04,158.48) 38.27,158.71 39.47,158.71 43.76,154.42 45.73,154.42 RT3.2 ; v2(97.26,54.35) 97.48,54.56 97.98,54.56 R79623.1 98.61,54.1 98.91,54.41 C12063.1 100.34,54.85 100.82,54.85 100.93,54.74 101.88,54.74 101.9,54.76 102.15,54.51 102.9,54.51 103,54.41 U109.87
  L4 w0.127: v2(47.08,57.36) 46.98,57.26 46.98,57.06 47.14,56.91 73.92,56.91 74.15,56.68 74.16,56.68 74.42,56.42 84.99,56.42 85.54,55.87 96.8,55.87 97.23,55.44 97.23,54.38 v2(97.26,54.35)
  BOTTOM w0.127: 30.49,144.57 v3(30.3,144.77) ; 30.49,144.57 28.69,142.77 28.69,137.12 28.16,136.59 28.16,114.14 26.84,112.82 26.84,106.73 25.85,105.74 25.85,101.99 26.36,101.48 26.36,88.24 26.35,88.23 26.35,88.23 20.25,82.13 20.25,82.12 20.16,82.03 20.16,69.71 34.34,55.52 46.08,55.52 46.81,56.24 46.81,57.09 v2(47.08,57.36) ; 30.49,144.57 37.65,151.72 37.65,157.02 38.3,157.67 38.3,158.23 v2(38.04,158.48)
REMOTE1-: length 197.9
  TOP w0.127: RT3.1 45.73,154.67 43.87,154.67 39.58,158.97 38.32,158.97 v2(38.04,159.24) ; C12063.2 99.83,55.36 R79619.2 98.68,55.17 98.33,54.81 97.07,54.81 96.56,54.3 v2(96.5,54.3)
  L4 w0.127: v2(96.5,54.3) 96.97,54.77 96.97,55.33 96.69,55.61 85.44,55.61 84.88,56.17 74.31,56.17 74.06,56.42 74.04,56.42 73.81,56.66 47.03,56.66 v2(46.32,57.36)
  BOTTOM w0.127: v2(38.04,159.24) 38.55,158.74 38.55,157.56 37.9,156.92 37.9,152.41 ; v2(46.32,57.36) 46.32,57.29 46.55,57.06 46.55,56.35 45.98,55.78 34.45,55.78 20.41,69.81 20.41,81.93 20.5,82.02 20.5,82.02 26.6,88.12 26.6,88.12 26.61,88.14 26.61,88.35 26.61,101.59 26.1,102.09 26.1,105.64 27.09,106.63 27.09,112.71 28.42,114.03 28.42,136.49 28.95,137.02 28.95,142.66 37.9,151.62 37.9,152.41 ; 37.9,152.41 v3(38.19,152.41)
REXT: length 4
  TOP w0.102: R2082.1 156.45,43.39 v1(156.56,43.39) 156.79,43.62 156.79,43.9 157.57,44.68 U118.18
RING2: length 27.1
  TOP w0.203: 183.1,59.24 U9.31
  TOP w0.762: v4(183.89,58.84) 183.5,58.84 183.1,59.24
  TOP w1.016: Q15.2 186.09,78.25 v2(186.63,77.71) 186.54,77.62 R80227.1
  L3 w0.762: v2(186.63,77.71) 184.47,75.55 184.47,70.06 183.41,69 183.41,59.32 v4(183.89,58.84)
  BOTTOM w0.254: v3(183.26,58.21) v4(183.89,58.84)
RING2_CON: length 10.6
  TOP w1.016: UHS1.3 201.84,78.19 199.97,76.31 194.25,76.31
  BOTTOM w0.254: v3(190.39,76.19) v2(191.2,76.19)
ROM_CS*: length 27.8
  TOP w0.102: R609.1 96.78,93.52 97.25,93.99 v2(97.83,93.99) ; GPU1.D12 83.07,102.62 83.48,103.03 v5(83.99,103.03)
  BOTTOM w0.102: v2(97.83,93.99) 97.68,94.14 97.38,94.14 v3(97,93.76) 96.36,93.76 95.57,92.98 95.57,91.8 94.7,90.92 91.89,90.92 91.59,91.22 91.59,92.98 90.11,94.45 90.11,97.17 89.62,97.66 89.62,98.01 88.77,98.87 88.77,99.19 88.54,99.41 88.54,100.22 86.99,101.77 85.49,101.77 85.21,102.05 85.21,102.37 84.94,102.64 84.38,102.64 v5(83.99,103.03)
ROM_CS_R*: length 7.6
  TOP w0.102: v1(102.91,92.11) 102.51,92.11 v2(101.92,92.7) 101.21,93.41 99.21,93.41 98.76,92.96 R607.2 97.8,92.95 R609.2
  BOTTOM w0.102: v2(101.92,92.7) 102.3,92.32 U33.1
ROM_SCLK: length 24.9
  TOP w0.102: R79993.1 R626.1 97.67,90.16 96.22,90.16 95.95,90.42 91.75,90.42 91.33,90.84 90.94,90.84 90.49,91.29 90.49,93.18 90.11,93.56 v1(90.11,94.56) 90.11,94.7 88.15,96.66 86.34,96.66 83.8,99.2 83.79,99.2 83.27,99.72 83.27,100.45 83.13,100.59 83.13,101.21 82.72,101.61 GPU1.C12
ROM_SCLK_R: length 5.8
  TOP w0.102: v2(95.33,90.9) 95.32,90.91 95.57,90.91 95.57,90.92 R626.2
  BOTTOM w0.102: v2(95.33,90.9) 95.33,90.53 96.08,89.78 v3(96.63,89.78) 98.24,89.78
ROM_SI: length 28
  TOP w0.102: GPU1.B12 82.72,100.71 83.06,100.36 83.06,99.63 83.7,98.99 83.7,98.97 85.13,97.54 85.13,97.5 86.18,96.46 87.57,96.46 89.5,94.52 89.5,93.1 89.78,92.82 89.78,91.17 90.41,90.54 91.31,90.54 91.66,90.19 95.86,90.19 96.12,89.93 98.47,89.93 v1(98.49,89.9) 99.45,89.9 R79986.1 100.02,89.97 R633.2 101.59,89.41 R625.1
ROM_SI_R: length 4.2
  TOP w0.102: R625.2 v1(100.7,89.32) 99.81,89.32 v2(99.64,89.14)
  BOTTOM w0.102: U33.5 99.21,88.51 99.64,88.94 v2(99.64,89.14)
ROM_SO: length 32.8
  TOP w0.102: GPU1.A12 82.72,99.63 84.91,97.45 84.91,97.4 86.05,96.25 87.3,96.25 89.22,94.33 89.22,91.4 90.34,90.28 91.24,90.28 91.61,89.92 95.81,89.92 96.03,89.7 97.78,89.7 98.23,89.25 98.23,89.25 99.12,88.37 99.12,88.37 99.57,87.91 99.88,87.91 100.3,87.49 101.83,87.49 102.35,88.01 102.35,88.88 R79982.1 103,89.83 102.65,90.18 v1(101.92,90.18) v2(101.92,91.05)
  BOTTOM w0.102: v2(101.92,91.05) U33.2
RREF: length 4.3
  BOTTOM w0.203: 188.89,143.83 U14.9
  BOTTOM w0.305: 188.89,143.83 187.7,145.02 v3(186.96,145.02) R79840.1
RSMRST*_R: length 2.7
  TOP w0.102: Q10.2 94.94,61.84 94.43,62.34 v1(94.43,62.6) 94.56,62.72 R340.2
RSMRST_N: length 214.1
  TOP w0.102: U2.BA11 149.98,72.04 v2(149.77,72.24) ; R1778.1 46.87,127.18 47.82,126.22 v2(48.73,126.22) ; R291.2 98.61,56.83 96.41,56.83 96.11,56.53 95.6,56.53 95,55.93 R1993.1 93.89,55.93 93.44,56.38 93.44,58.3 93.62,58.48 v2(93.62,58.53)
  L3 w0.127: v2(102.37,70.22) 102.26,70.11 102.26,69.49 96.64,63.87 96.64,61.56 v2(93.62,58.53)
  L4 w0.127: v2(93.62,58.53) 93.62,58.83 93.74,58.95 93.74,59.4 93.17,59.97 89.65,59.97 89.46,59.78 84.07,59.78 82.71,61.14 80.08,61.14 78.81,62.41 78.31,62.41 76.99,63.72 76.99,69.71 77.11,69.83 77.11,72.16 76,73.27 66.2,73.27 58.61,80.86 57.15,80.86 49.34,88.67 36.99,88.67 34.99,90.67 34.99,95.3 33.61,96.68 33.61,101.35 34.14,101.88 34.14,106.3 34.42,106.58 34.42,108.94 35.11,109.62 35.11,112.4 36.2,113.49 36.71,113.49 37.29,114.07 39.96,114.07 43.61,117.72 43.98,117.72 46.3,120.04 46.3,123.79 v2(48.73,126.22)
  BOTTOM w0.102: Q9635.C 94.11,58.04 v2(93.62,58.53) ; v2(149.77,72.24) 150.46,71.56 150.46,71.27 R1994.1 150.61,70.83 149.53,70.83 149.17,70.47 148.94,70.47 148.66,70.19 148.66,69.84 149.12,69.38 149.57,69.38 149.83,69.13 149.83,68.55 150.11,68.27 150.11,66.81 148.73,65.44 148.73,64.84 145.23,61.33 140.71,61.33 140.69,61.3 140.43,61.3 v3(139.92,60.79) 139.67,60.54 128.82,60.54 128.03,61.33 127.22,61.33 124.28,64.27 124.11,64.27 121.57,66.81 117.86,66.81 114.76,69.91 105.91,69.91 104.54,71.29 104.02,71.29 102.96,70.22 v2(102.37,70.22)
RSMRST_N_B: length 3.4
  BOTTOM w0.102: Q9635.B 91.54,55.87 v3(90.62,55.87) 90.11,56.37 R80222.2
RSVD_AE17: length 3.4
  TOP w0.102: U2.AE17 141.84,74.48 v2(142.29,74.03)
  BOTTOM w0.102: v2(142.29,74.03) 142.04,73.78 140.23,73.78 TP153.1
RSVD_AF17: length 1.9
  TOP w0.102: U2.AF17 142.61,74.75 v2(143,75.15)
  BOTTOM w0.102: v2(143,75.15) 142.18,75.97 TP152.1
RSVD_AG14: length 2.3
  TOP w0.102: v2(143.37,73.04) 142.93,73.48 U2.AG14
  BOTTOM w0.102: TP151.1 144.09,73.67 143.46,73.04 v2(143.37,73.04)
RSVD_AG15: length 2.3
  TOP w0.102: v2(143.38,73.8) 143.27,73.8 143.03,74.04 U2.AG15
  BOTTOM w0.102: v2(143.38,73.8) 142.31,74.87 TP150.1
RT: length 3.8
  TOP w0.102: R79708.1 16.33,17.77 16.6,18.05 v1(16.75,18.05) 16.81,18.05 17.47,17.39 v2(17.47,17.26)
  BOTTOM w0.102: U120.10 17.04,16.7 17.47,17.13 v2(17.47,17.26)
RTCX_L: length 7.2
  TOP w0.102: X2.4 167.96,71.06 167.86,71.16 166.75,71.16 165.75,70.15 C159.1 164.98,70.15 R180.2 163.97,70.6 v1(163.43,70.05) 163.34,69.96 R179.1
RTD2482_VREF: length 5.6
  TOP w0.254: C12190.1 43,50.84 v1(42.89,50.74) 42.89,50.74 41.72,49.57 40.36,49.57 40.01,49.22 SCA1.44
RTD_PIN2: length 6.8
  TOP w0.305: 47.57,28.56 46.68,28.56 46.28,28.95 SCA1.2
  TOP w0.508: 48.84,29.45 R9519.2 ; 48.84,29.45 48.84,28.5 R9531.2 ; 48.84,29.45 48.76,29.45 47.9,28.59 47.72,28.59 ; v1(47.72,28.61) 47.72,28.59 ; 47.72,28.59 47.69,28.56 47.57,28.56
RTD_PIN105: length 9.4
  TOP w0.102: v2(26.61,29.32) 26.82,29.12 26.82,28.32 R79236.1 26.29,27.04 27.6,27.04 28.64,28.08 SCA1.102
  BOTTOM w0.102: R79832.1 R79237.2 25.34,29.2 v3(25.72,29.58) 26.36,29.58 v2(26.61,29.32)
RTD_PIN119: length 16.1
  TOP w0.102: SCA1.119 38.01,26.06 38.25,25.83 38.25,25.45 36.1,23.31 27.17,23.31 v2(26.99,23.48) 26.49,23.99 R9525.1
  BOTTOM w0.102: v3(27.81,23.47) 27.77,23.47 27.76,23.48 v2(26.99,23.48)
RTD_PIN121: length 5
  TOP w0.102: v1(38.8,25.26) 39.16,25.26 ; 39.16,25.26 39.16,24.77 38.72,24.33 38.72,23.07 R9527.2 ; 39.16,25.26 39.16,25.91 39.01,26.05 SCA1.121
RTD_PIN122: length 5.1
  TOP w0.102: SCA1.122 39.51,26.05 39.37,25.91 39.37,24.68 38.93,24.24 38.93,23.74 ; 38.93,23.74 38.93,23.29 R9530.2 ; 38.93,23.74 v1(39.31,23.74)
RTD_PIN123: length 4.6
  TOP w0.102: SCA1.123 40.01,25.98 39.91,25.87 39.91,24.41 v1(40.58,23.74) R9536.2
RTD_PIN124: length 3.7
  TOP w0.102: SCA1.124 40.51,26.1 40.33,25.92 40.33,25.16 v1(40.47,25.02) 41.23,24.26 R9546.2
RTD_RESETB: length 6
  TOP w0.102: v2(41.05,25.67) 41.01,25.7 SCA1.125
  BOTTOM w0.102: R9548.1 39.57,26.2 v3(39.95,25.82) 40.25,25.82 40.58,26.15 40.58,26.73 C12174.1 41.05,27.13 v2(41.05,25.67)
RTL_ISOLATE_N: length 20.6
  TOP w0.102: Q23.6 52.79,42.03 53.22,41.6 R439.1 R436.2 53.22,39.55 53.92,38.85 v2(54.04,38.85) ; U9623.20 61.86,30.54 61.89,30.57 61.89,34 62.48,34.58 v1(62.48,36.22) 62.48,36.4 61.68,37.2 56.13,37.2 v2(56.03,37.3)
  L3 w0.127: v2(56.03,37.3) 54.48,38.85 v2(54.04,38.85)
RTL_ISOLATE_N_1: length 10.2
  TOP w0.102: Q23.5 52.14,42.91 51.76,43.29 51.47,43.29 51.11,43.65 51.11,44.88 51.63,45.4 51.63,46.28 R440.1 C282.1 51.95,47.61 53.92,47.61 54.11,47.8 R438.2 54.11,48.72 v1(53.51,49.31)
RTL_ISOLATE_N_2: length 5.9
  TOP w0.102: v1(52.96,46.09) 53.03,46.02 53.03,45.66 52.14,44.77 Q23.2 ; v1(52.96,46.09) 52.96,46.09 52.96,46.2 52.96,46.2 R435.2 ; v1(52.96,46.09) 52.94,46.06 52.62,46.06 51.49,44.93 Q23.3
RTN1: length 15.4
  TOP w0.254: v1(20.9,9.03) 22.75,9.03 23.58,8.2 CONVT1.1A ; v1(20.9,9.03) 20.9,9.83 R79693.2 ; v1(20.9,9.03) 20.9,8.37 v2(21.53,7.73) ; v2(23.58,3.42) CONVT1.1B
  L3 w0.254: v2(23.58,3.42) 23.58,5.96 22.95,6.59 22.19,6.59 21.53,7.25 v2(21.53,7.73)
RTN2: length 13.2
  TOP w0.254: v2(24.45,3.42) 24.58,3.54 CONVT1.2B ; R79696.2 22.73,10.51 v1(22.73,10.12) 22.95,9.89 23.31,9.89 v2(23.69,9.51) 23.93,9.27 23.93,9.02 24.58,8.37 CONVT1.2A
  L3 w0.254: v2(24.45,3.42) 24.45,8.75 v2(23.69,9.51)
RTN3: length 13.5
  TOP w0.254: R79699.2 24.77,11.1 24.77,11.08 25.96,9.89 v1(26.61,9.89) 27,9.89 v2(27.58,9.31) CONVT1.5A ; CONVT1.5B v2(27.58,3.42)
  L3 w0.254: v2(27.58,3.42) v2(27.58,9.31)
RTN4: length 13.2
  TOP w0.254: CONVT1.6B v2(28.58,3.42) ; CONVT1.6A v2(28.58,8.75) 28.58,9.96 v1(28.54,9.99) 28.01,10.53 26.17,10.53 R79705.2
  L3 w0.254: v2(28.58,3.42) v2(28.58,8.75)
S_LVDS_BL_EN: length 6
  TOP w0.102: R143.2 6.48,19.04 v1(7.31,19.04) 8.51,19.04 R79722.1 8.64,18.91 R79724.2 9.66,19.93 R135.1 R79719.1
S_TXE0+: length 13.4
  TOP w0.089: SCA1.82 27.64,38.46 27.56,38.38 26.75,38.38 26.49,38.38 25.76,37.65 25.63,37.65 25.42,37.86 25.42,37.98 26.15,38.71 26.15,39.12 25.75,39.53 25.34,39.53 24.6,38.8 24.48,38.8 24.27,39.01 24.27,39.13 25,39.86 25,40.27 24.39,40.88 23.82,40.88 23.76,40.82 ; LVDS1.18 22.42,40.5 22.75,40.17 23.11,40.17 23.76,40.82 ; 23.76,40.82 v1(23.48,41.11)
S_TXE0-: length 13
  TOP w0.089: SCA1.83 27.65,37.96 27.57,38.04 26.75,38.04 26.63,38.04 25.9,37.3 25.49,37.3 25.08,37.71 25.08,38.12 25.81,38.85 25.81,38.98 25.6,39.19 25.48,39.19 24.75,38.46 24.34,38.46 23.93,38.86 23.93,39.27 24.66,40 24.66,40.13 24.25,40.54 23.96,40.54 23.25,39.83 22.75,39.83 22.42,39.5 LVDS1.19
S_TXE1+: length 13.1
  TOP w0.089: SCA1.80 27.88,39.46 27.8,39.37 27.1,39.37 24.94,41.53 24.94,44.96 24.58,45.33 23.69,45.33 23.31,44.94 23.31,43.43 23.06,43.17 22.8,43.17 22.47,43.5 LVDS1.15
S_TXE1-: length 13.6
  TOP w0.089: 24.6,42.58 24.6,44.82 24.44,44.98 23.83,44.98 23.65,44.8 23.65,43.28 23.2,42.83 22.8,42.83 22.47,42.5 LVDS1.16 ; 24.6,42.58 24.6,41.39 26.96,39.03 27.76,39.03 27.83,38.95 SCA1.81 ; 24.6,42.58 v1(24.19,42.58)
S_TXE2+: length 13.4
  TOP w0.089: LVDS1.12 22.47,46.5 22.8,46.17 23.06,46.17 23.83,46.95 ; 23.83,46.95 v1(23.54,47.24) ; 23.83,46.95 24.22,47.34 25.01,47.34 25.76,46.59 25.76,41.87 27.24,40.38 27.76,40.38 27.82,40.45 SCA1.78
S_TXE2-: length 13.4
  TOP w0.089: LVDS1.13 22.47,45.5 22.8,45.83 23.2,45.83 24.36,47 24.87,47 25.41,46.45 25.41,45.97 ; 25.41,45.97 25.41,41.72 27.1,40.04 27.76,40.04 27.84,39.96 SCA1.79 ; 25.41,45.97 v1(25.02,45.97)
S_TXE3+: length 13.6
  TOP w0.089: LVDS1.8 22.47,50.5 22.8,50.17 25.17,50.17 26.51,48.83 ; v1(26.74,49.06) 26.51,48.83 ; 26.51,48.83 27.38,47.96 27.38,42.54 27.56,42.37 27.76,42.37 27.84,42.45 SCA1.74
S_TXE3-: length 13.7
  TOP w0.089: LVDS1.9 22.41,49.5 22.73,49.83 23.56,49.83 ; 23.56,49.83 v1(23.56,49.41) ; 23.56,49.83 25.03,49.83 27.04,47.82 27.04,42.4 27.41,42.02 27.76,42.02 27.82,41.95 SCA1.75
S_TXEC+: length 13.7
  TOP w0.089: LVDS1.10 22.47,48.5 22.8,48.17 23.11,48.17 23.56,48.63 24.85,48.63 ; 24.85,48.63 25.57,48.63 26.57,47.62 26.57,42.2 27.4,41.38 27.74,41.38 27.82,41.46 SCA1.76 ; 24.85,48.63 v1(24.85,49.03)
S_TXEC-: length 13.6
  TOP w0.089: 25.85,47.86 25.42,48.28 23.71,48.28 23.25,47.83 22.77,47.83 22.44,47.5 LVDS1.11 ; 25.85,47.86 26.23,47.48 26.23,42.06 27.26,41.03 27.76,41.03 27.83,40.95 SCA1.77 ; 25.85,47.86 v1(25.57,47.59)
S_TXO0+: length 8.8
  TOP w0.089: 23.64,29.17 22.7,29.17 22.37,29.5 LVDS1.29 ; 23.64,29.17 24.25,29.17 26.68,31.6 26.68,31.94 27.12,32.38 27.56,32.38 27.63,32.45 SCA1.94 ; 23.64,29.17 v1(23.64,29.58)
S_TXO0-: length 8.8
  TOP w0.089: LVDS1.30 22.49,28.5 22.82,28.83 24.39,28.83 25.55,29.99 ; v1(25.84,29.7) 25.55,29.99 ; 25.55,29.99 27.02,31.46 27.02,31.8 27.26,32.04 27.53,32.04 27.61,31.95 SCA1.95
S_TXO1+: length 8.2
  TOP w0.089: LVDS1.27 22.4,31.5 22.73,31.17 24.18,31.17 25.16,32.16 ; 25.16,32.16 26.39,33.38 27.55,33.38 27.63,33.46 SCA1.92 ; 25.16,32.16 v1(24.88,32.42)
S_TXO1-: length 8.2
  TOP w0.089: 24.8,31.3 26.53,33.03 27.52,33.03 27.6,32.96 SCA1.93 ; 24.8,31.3 24.32,30.83 22.78,30.83 22.45,30.5 LVDS1.28 ; 24.8,31.3 v1(25.08,31.02)
S_TXO2+: length 7.8
  TOP w0.089: v1(23.64,33.58) 23.64,33.17 ; 23.64,33.17 24.02,33.17 25.23,34.38 27.55,34.38 27.63,34.46 SCA1.90 ; 23.64,33.17 22.76,33.17 22.44,33.5 LVDS1.25
S_TXO2-: length 7.8
  TOP w0.089: LVDS1.26 22.42,32.5 22.75,32.83 24.16,32.83 25.37,34.03 25.82,34.03 ; 25.82,34.03 v1(25.82,33.63) ; 25.82,34.03 27.52,34.03 27.6,33.95 SCA1.91
S_TXO3+: length 8
  TOP w0.089: LVDS1.20 22.39,38.5 22.72,38.17 23.92,38.17 25.72,36.37 26.45,36.37 ; v1(26.45,36.77) 26.45,36.37 ; 26.45,36.37 27.52,36.37 27.6,36.46 SCA1.86
S_TXO3-: length 8
  TOP w0.089: LVDS1.21 22.47,37.5 22.8,37.83 23.78,37.83 24.08,37.53 ; 24.08,37.53 25.58,36.03 27.55,36.03 27.63,35.95 SCA1.87 ; 24.08,37.53 v1(23.81,37.25)
S_TXOC+: length 7.6
  TOP w0.089: 24.96,35.38 27.56,35.38 27.64,35.45 SCA1.88 ; 24.96,35.38 v1(24.96,35.79) ; 24.96,35.38 24.28,35.38 23.49,36.17 22.81,36.17 22.48,36.5 LVDS1.22
S_TXOC-: length 7.6
  TOP w0.089: 23.88,35.3 24.14,35.04 27.55,35.04 27.63,34.96 SCA1.89 ; 23.88,35.3 v1(23.59,35.01) ; 23.88,35.3 23.35,35.83 22.7,35.83 22.37,35.5 LVDS1.23
SA0_DIM0: length 10.1
  TOP w0.102: v2(148.18,133.6) 148.05,133.73 148.05,134.35 147.52,134.87 147.52,136.17 146.24,137.45 DIMM1.197
  BOTTOM w0.102: v2(148.18,133.6) 148.18,133.82 149.19,134.83 149.57,134.83 v3(150.13,135.39) 149.7,135.83 149.05,135.83 R75.1
SA0_DIM1: length 5.5
  TOP w0.102: v5(162.98,136.79) 162.28,137.49 160.49,137.49 DIMM2.197
  BOTTOM w0.102: R86.1 162.05,137.72 v3(162.26,137.51) v5(162.98,136.79)
SA1_DIM0: length 6.6
  TOP w0.102: DIMM1.201 146.22,136.25 146.67,135.8 146.67,134.91 145.41,133.65 v2(145.28,133.65)
  BOTTOM w0.102: v2(145.28,133.65) 145.41,133.65 145.74,133.98 145.74,134.35 v3(145.73,134.36) 145.74,134.36 R74.1
SA1_DIM1: length 4.8
  TOP w0.102: v5(161.78,135.19) 161.78,135.98 161.51,136.25 DIMM2.201
  BOTTOM w0.102: v5(161.78,135.19) 161.29,135.69 R85.2 159.44,135.69 v3(159.4,135.72)
SATA__RXN2_C: length 5.7
  BOTTOM w0.102: v3(11.24,77.71) 11.02,77.94 ; 11.02,77.94 11.97,78.89 13.25,78.89 C495.2 ; 11.02,77.94 10.88,77.8 9.56,77.8 HDD1.5
SATA__RXN3_C: length 6.2
  BOTTOM w0.102: C499.2 14.07,96.8 11.37,96.8 ; 11.37,96.8 9.56,96.8 ODD2.5 ; 11.37,96.8 v3(11.37,96.48)
SATA__RXP2_C: length 5.8
  BOTTOM w0.102: 12.64,79.11 13.14,79.11 C494.2 ; 12.64,79.11 11.88,79.11 10.79,78.01 9.56,78.01 HDD1.6 ; 12.64,79.11 v3(12.64,79.44)
SATA__RXP3_C: length 6.2
  BOTTOM w0.102: v3(13.42,97.36) 13.42,97.01 ; 13.42,97.01 14.1,97.01 C498.2 ; 13.42,97.01 9.56,97.01 ODD2.6
SATA__TXN2_C: length 5.3
  BOTTOM w0.102: v3(12.64,74.54) 12.64,74.2 ; 12.64,74.2 9.56,74.2 HDD1.3 ; 12.64,74.2 13.26,74.2 C496.2
SATA__TXN3_C: length 6.2
  BOTTOM w0.102: C500.2 14.08,93.44 11.42,93.44 ; ODD2.3 9.56,93.2 10.12,93.2 10.36,93.44 11.42,93.44 ; 11.42,93.44 v3(11.42,93.74)
SATA__TXP2_C: length 5.3
  BOTTOM w0.102: 10.61,73.99 9.56,73.99 HDD1.2 ; 10.61,73.99 v3(10.61,73.65) ; 10.61,73.99 13.23,73.99 C497.2
SATA__TXP3_C: length 6.3
  BOTTOM w0.102: ODD2.2 9.56,92.99 10.21,92.99 10.45,93.22 13.51,93.22 ; 13.51,93.22 v3(13.51,92.89) ; 13.51,93.22 14.08,93.22 C501.2
SATA_LED_N_C_1: length 8.5
  TOP w0.254: R80201.2 40.4,6.51 40.07,6.84 v2(40.07,7.23) 39.77,7.53 39.77,8.75 40.2,9.18 Q9646.3 ; v2(42.76,8.11) 42.12,7.47 Q9646.6
  BOTTOM w0.254: v2(40.07,7.23) 40.2,7.23 40.96,7.99 v3(41.73,7.99) 42.64,7.99 v2(42.76,8.11)
SATAHDR_RX_DN2: length 132.8
  TOP w0.102: v2(132.91,85.97) 132.48,86.4 U2.F41
  L3 w0.127: v2(132.91,85.97) 132.76,86.12 132.21,86.12 131.8,86.53 129.79,86.53 129.2,85.94 129.2,85.75 128.93,85.48 128.74,85.48 128.47,85.21 128.47,85.01 128.2,84.74 128.01,84.74 127.74,84.48 127.74,84.28 127.47,84.01 127.28,84.01 127.01,83.74 125.88,83.74 125.56,83.43 121.68,83.43 120.19,81.93 105.78,81.93 103.34,79.49 90.2,79.49 84.35,73.63 65.2,73.63 59.26,79.58 58.04,79.58 58.04,79.58 57.82,79.58 50.58,86.82 27.84,86.82 25.88,84.85 25.88,84.66 25.61,84.39 25.41,84.39 25.14,84.12 25.14,83.93 24.87,83.66 24.68,83.66 23.8,82.78 21.45,82.78 21.32,82.64 20.93,82.64 20.8,82.78 20.42,82.78 20.28,82.64 19.9,82.64 19.76,82.78 19.38,82.78 19.24,82.64 18.86,82.64 18.72,82.78 17.43,82.78 v6(17.04,82.38)
  BOTTOM w0.102: L4102.1 16.49,81.61 16.26,81.84 16.26,82.57 16.46,82.78 16.64,82.78 17.04,82.38 v6(17.04,82.38)
SATAHDR_RX_DN2_EMI: length 3.1
  BOTTOM w0.102: L4102.2 16.49,79.91 16.41,79.82 16.41,79.27 15.97,78.83 14.76,78.83 C495.1
SATAHDR_RX_DN3: length 134.6
  TOP w0.102: U2.D43 131.72,87.84 v5(131.46,87.59)
  L3 w0.127: v2(22.17,96.48) 22.44,96.75 25.23,96.75 33.61,88.37 52.54,88.37 56.47,84.44 58.04,84.44 59.9,82.57 59.9,81.13 65.73,75.3 83.82,75.3 89.56,81.04 93.94,81.04 98.73,85.83 106.29,85.83 107.9,84.21 125.25,84.21 125.55,84.52 125.88,84.52 127.72,86.36 127.92,86.36 128.19,86.63 128.19,86.83 129.49,88.14 131.5,88.14 131.71,87.94 131.71,87.83 v5(131.46,87.59)
  BOTTOM w0.102: 20.69,96.78 21.87,96.78 v2(22.17,96.48) ; 20.69,96.78 15.77,96.78 C499.1 ; 20.69,96.78 v3(20.69,96.48)
SATAHDR_RX_DP2: length 132.8
  TOP w0.102: U2.E41 132.24,86.89 132.89,86.89 v2(132.99,86.79)
  L3 w0.127: v2(17.06,83.4) 17.42,83.04 23.69,83.04 27.73,87.08 50.69,87.08 57.93,79.84 59.37,79.84 65.31,73.9 84.24,73.9 90.09,79.75 103.23,79.75 105.67,82.19 120.08,82.19 121.57,83.69 125.45,83.69 125.76,84.01 126.9,84.01 129.68,86.8 131.91,86.8 132.32,86.39 132.59,86.39 v2(132.99,86.79)
  BOTTOM w0.102: v2(17.06,83.4) 16.66,82.99 16.38,82.99 16.04,82.66 16.04,81.84 15.81,81.61 L4102.4
SATAHDR_RX_DP2_EMI: length 3
  BOTTOM w0.102: L4102.3 15.81,79.9 16.19,79.51 16.19,79.35 15.88,79.04 15,79.04 C494.1
SATAHDR_RX_DP3: length 134.7
  TOP w0.102: U2.E42 131.94,87.61 v5(132.2,87.87)
  L3 w0.127: v5(132.2,87.87) 132.15,87.87 131.62,88.4 129.38,88.4 125.76,84.78 125.44,84.78 125.14,84.48 108.01,84.48 106.4,86.09 98.62,86.09 93.83,81.3 89.45,81.3 83.71,75.56 65.84,75.56 60.17,81.24 60.17,82.68 58.15,84.71 56.58,84.71 52.65,88.63 33.72,88.63 25.34,97.02 22.44,97.02 v2(22.17,97.29)
  BOTTOM w0.102: C498.1 15.77,96.99 17.26,96.99 ; v2(22.17,97.29) 21.87,96.99 17.26,96.99 ; v3(17.26,97.29) 17.26,96.99
SATAHDR_TX_DN2: length 131.3
  TOP w0.102: 124.2,81.72 124.76,81.72 128.32,85.29 129.01,85.29 129.68,85.96 129.74,86.02 130.5,86.02 130.72,85.79 U2.B39 ; 124.2,81.72 121.62,81.72 120.95,81.05 118.99,81.05 118.71,81.33 v2(118.71,81.36) ; 124.2,81.72 v1(124.2,82.1)
  L3 w0.127: v2(118.71,81.36) 118.46,81.11 105.69,81.11 103.55,78.98 90.41,78.98 84.56,73.13 64.99,73.13 59.05,79.07 57.61,79.07 50.38,86.3 28.82,86.3 20.59,78.07 17.37,78.07 v2(17.08,78.35)
  BOTTOM w0.102: v2(17.08,78.35) 16.78,78.05 16.44,78.05 16.01,77.63 16.01,76.95 15.81,76.74 L4103.4
SATAHDR_TX_DN2_EMI: length 3.2
  BOTTOM w0.102: L4103.3 15.81,75.08 16.21,74.67 16.21,74.47 15.7,73.96 15.06,73.96 C496.1
SATAHDR_TX_DN3: length 131.6
  TOP w0.102: v2(120.08,82.94) 119.81,82.67 119.81,82.3 119.88,82.23 120.47,82.23 122.32,84.08 124.83,84.08 ; 124.83,84.08 125.55,84.08 127.56,86.09 128.75,86.09 129.36,86.7 130.14,86.7 U2.A41 ; 124.83,84.08 v1(124.83,84.46)
  L3 w0.127: v2(120.08,82.94) 119.61,83.41 119.23,83.41 118.94,83.7 107.69,83.7 106.19,85.2 99.13,85.2 94.46,80.53 89.77,80.53 84.03,74.79 65.52,74.79 59.69,80.62 58.25,80.62 51.01,87.86 33.28,87.86 27.69,93.45 22.8,93.45 22.55,93.7 v2(22.55,93.72)
  BOTTOM w0.102: v2(22.55,93.72) 22.27,93.44 15.77,93.44 C500.1
SATAHDR_TX_DP2: length 131.3
  TOP w0.102: v2(118.76,80.6) 119,80.83 120.47,80.83 ; 120.47,80.83 v1(120.47,80.45) ; 120.47,80.83 121.04,80.83 121.71,81.51 124.85,81.51 126.65,83.31 126.8,83.31 127.02,83.52 127.02,83.68 127.24,83.9 127.39,83.9 127.61,84.11 127.61,84.27 127.83,84.49 127.98,84.49 128.2,84.7 128.2,84.86 128.41,85.08 129.1,85.08 129.77,85.74 U2.A39
  L3 w0.127: v2(118.76,80.6) 118.52,80.85 117.69,80.85 117.56,80.71 117.18,80.71 117.04,80.85 116.66,80.85 116.52,80.71 116.14,80.71 116,80.85 115.62,80.85 115.48,80.71 115.1,80.71 114.97,80.85 105.8,80.85 103.66,78.71 90.52,78.71 84.67,72.86 64.88,72.86 58.94,78.8 57.5,78.8 50.27,86.03 28.93,86.03 28.53,85.63 28.53,85.43 28.26,85.16 28.07,85.16 27.8,84.9 27.8,84.7 27.53,84.43 27.34,84.43 24.83,81.93 24.83,81.73 24.56,81.47 24.37,81.47 24.1,81.2 24.1,81 23.83,80.73 23.64,80.73 20.7,77.8 17.34,77.8 v2(17.08,77.54)
  BOTTOM w0.102: L4103.1 16.49,76.71 16.23,76.97 16.23,77.54 16.53,77.84 16.78,77.84 v2(17.08,77.54)
SATAHDR_TX_DP2_EMI: length 3.2
  BOTTOM w0.102: C497.1 14.61,73.75 15.79,73.75 16.43,74.38 16.43,75.09 16.49,75.15 L4103.2
SATAHDR_TX_DP3: length 131.6
  TOP w0.102: U2.A40 130.07,86.49 129.45,86.49 128.84,85.88 127.65,85.88 125.63,83.86 123.67,83.86 ; 123.67,83.86 122.41,83.86 120.56,82.02 119.79,82.02 119.59,82.21 119.59,82.67 v2(119.32,82.94) ; 123.67,83.86 v1(123.67,83.5)
  L3 w0.127: v2(22.55,92.91) 22.55,92.92 22.8,93.18 27.58,93.18 27.85,92.91 27.85,92.72 28.12,92.45 28.31,92.45 28.58,92.18 28.58,91.98 28.85,91.71 29.05,91.71 29.32,91.44 29.32,91.25 29.59,90.98 29.78,90.98 30.05,90.71 30.05,90.52 30.32,90.25 30.51,90.25 33.17,87.59 50.9,87.59 58.14,80.35 59.58,80.35 65.41,74.52 84.14,74.52 89.88,80.26 94.57,80.26 99.24,84.94 106.08,84.94 107.58,83.44 118.83,83.44 119.32,82.94 v2(119.32,82.94)
  BOTTOM w0.102: C501.1 15.77,93.22 22.23,93.22 v2(22.55,92.91)
SB3V: length 970.3
  TOP w0.254: U2.AN5 146.39,69.06 v2(146.7,69.36) ; U2.AD41 141.87,86.79 v2(142.3,86.36) ; U2.AL41 144.84,86.74 144.7,86.6 v2(144.54,86.6) 144.47,86.6 144.28,86.79 U2.AJ41 ; v5(150.03,75.43) 150.03,75.45 149.96,75.52 149.96,76.12 U2.BA20
  TOP w0.305: U2.BC42 151.22,86.43 U2.BD40 151.34,86.3 150.67,85.62 v2(150.67,85.57)
  TOP w0.381: v2(125.8,58.41) 125.13,58.41 124.49,59.04 123.89,59.04 123.51,58.66 R285.2 ; R287.1 125.8,60.95 125.46,61.29 124.51,61.29 123.91,60.69 123.51,60.69
  TOP w0.508: v2(22.17,127.32) 22.76,127.32 23.95,128.51 25.19,128.51 26.08,129.4 28.33,129.4 PR123.1 ; v2(156.52,59.36) 156.52,59.37 155.78,60.11 154.72,60.11 R1732.2 ; R79732.1 30.94,54 v2(29.99,53.05) ; v2(163.39,79.49) 163.26,79.36 R103.2 R1922.1 ; v2(163.39,79.49) 163.39,79.17 R96.1 ; v2(163.39,79.49) 164.22,79.49 R203.1 ; R1812.2 141.85,97.83 v2(141.81,97.86) ; R253.1 98.88,62.85 98.62,63.11 v2(98.62,63.74) 98.62,64.76 98.88,65.01 R300.2 ; 94,56.63 94.62,56.63 R1993.2 ; 94,56.63 v2(94,56.6) ; 94,56.63 94,57.66 R337.1 ; R435.1 53.85,45.69 v4(53.43,45.27) ; v4(126.94,251.7) R731.1 ; v2(138.19,13.52) 139.13,14.46 R5216.1 ; v2(125.27,52.82) 125.27,51.71 R79836.2 R284.2 ; R79715.1 R79714.1 29.03,12.94 v2(28.96,13) ; C280.1 v4(49.6,24.75) ; R79741.2 146.25,97.65 145.84,98.05 v2(145.8,98.05) ; v2(111.7,244.46) 111.51,244.27 R1734.1 ; R80240.2 R285.2 ; R7916.1 R7918.1 111.16,43.29 111.55,43.69 111.55,47.18 v2(111.65,47.28) ; R79925.2 105.61,69.32 105.15,69.78 105.15,70.34 104.97,70.52 104.97,71.58 105.97,72.58 106.38,72.58 106.56,72.76 107.43,72.76 107.83,72.36 R279.1 R280.2 ; R79744.1 52.42,16.03 v2(52.14,16.03) ; v2(163.37,88.71) 162.55,88.71 162.31,88.95 R1834.1 159.96,89.71 v2(159.96,90.03) 159.45,90.54 158.63,90.54 R205.2 ; v4(124,47.46) 124.47,47.93 R254.1 ; PR4475.1 148.85,122.41 v2(148.28,122.41) ; R304.2 125.8,57.31 v2(125.8,58.41) R287.1 ; v4(96.34,141.72) 96.34,141.34 96.46,141.21 96.46,134.4 94.79,132.72 94.79,132.53 94.25,131.99 94.16,131.99 R80055.2 ; R1735.1 111.83,238.3 v2(111.83,240.65) ; R79839.1 136.63,94.78 v2(136.83,94.98) ; R1963.1 20.58,155.75 v2(21.02,155.31) ; R1733.1 v5(32.45,13.07) ; v4(139.39,123.3) 138.88,122.8 MEJ1.1 134.75,122.8 R150.1 132.91,122.86 R151.2 ; R1837.1 150.42,99.22 v2(151.1,99.22) ; R455.2 174.95,101.46 174.11,100.62 v2(173.32,100.62) ; R1820.2 138.03,95.59 138.44,96 R1816.2 137.86,96.38 137.64,96.61 v2(137.64,97.14) 138.05,97.14 R1817.2 ; R80201.1 40.43,5 R80202.1 42.42,5 43.31,5.89 R755.1 43.63,6.02 R760.1 44.07,8.81 44.52,9.26 v2(44.52,10.02)
  TOP w0.635: F6.1 176.98,196.66 R474.1 177.36,194.68 v4(181.3,194.68)
  TOP w1.016: v4(36.59,40.45) 34.87,38.72 34.87,36.18 35.91,35.14 v4(36.62,35.14) 37.61,35.14 v4(39.08,36.61)
  L3 w0.508: v2(145.18,50.1) 145.06,49.98 145.06,40.03 146.39,38.7 146.39,33.42 144.33,31.36 144.33,27.93 141.29,24.89 141.29,21.42 138.25,18.38 138.25,13.58 v2(138.19,13.52) ; v2(125.8,58.41) 125.8,57.92 124.91,57.03 124.91,53.94 125.27,53.58 v2(125.27,52.82) 125.27,51.4 124,50.13 v4(124,47.46) ; v2(55.31,257.54) 55.31,259.84 61.21,265.73 124.47,265.73 126.94,263.26 v4(126.94,251.7) ; v2(148.91,94) 148.91,91.93 146.86,89.88 146.7,89.88 145.89,89.06 145.89,88.99 145.38,88.49 145.38,87.44 v2(144.54,86.6) ; v2(150.67,85.57) 150.32,85.23 149.36,85.23 148.65,85.94 147.92,85.94 147,86.86 146.25,86.86 145.99,86.6 v2(144.54,86.6) ; v2(159.96,90.03) 159.38,90.61 158.62,90.61 157.78,89.78 156.79,89.78 156.53,90.03 155.75,90.03 155.36,90.42 155.36,91.2 154.93,91.63 154.93,91.68 153.87,92.75 v2(153.87,92.82) 153.87,93.83 151.4,96.29 151.4,98.92 v2(151.1,99.22) 150.79,99.22 149.55,97.98 148.41,97.98 v2(148.38,97.95) 148.24,97.82 146.04,97.82 v2(145.8,98.05) 142,98.05 v2(141.81,97.86) 140.91,96.96 137.81,96.96 v2(137.64,97.14) ; v2(94,56.6) 96.99,59.59 v2(97.34,59.59) 97.34,62.33 98.62,63.61 v2(98.62,63.74) 98.62,64.5 103.47,69.35 v2(103.47,70.09) ; v2(142.3,86.36) 142.3,86.86 142.85,87.41 143.91,87.41 144.54,86.78 v2(144.54,86.6) ; v2(156.52,59.36) 156.26,59.1 156.26,59.08 155.87,58.7 155.86,58.7 155.49,58.33 155.49,55.59 v2(156.05,55.03) ; v2(52.14,16.03) 52.14,16.04 52.77,16.67 52.77,23.33 53.41,23.96 v4(53.41,24.32) ; v2(20.52,42.79) 19.37,43.93 19.37,44.82 20.26,45.71 v2(20.75,45.71) ; v4(139.39,123.3) 139.39,122.26 140.3,121.35 147.21,121.35 v2(148.28,122.41) ; v5(150.03,75.43) 151.32,75.43 152.06,74.69 154.24,74.69 154.27,74.66 155.01,74.66 157.04,72.63 v2(157.04,71.87) ; v2(22.17,127.32) 19.5,124.65 19.5,113.03 v4(19.77,112.76) 19.8,112.72 19.8,110.88 20.37,110.31 23.6,110.31 28.24,105.68 v4(30.55,105.68)
  L3 w1.016: v4(49.6,24.75) 52.75,24.75 53.18,24.32 v4(53.41,24.32)
  L4 w0.305: v5(150.03,75.43) 150.01,75.43 149.45,74.87 145.76,74.87 145.38,74.48 145.38,72.64 146.07,71.94 146.07,71.61 147.16,70.52 147.16,69.83 v2(146.7,69.36)
  L4 w0.508: v2(62.2,58.28) 62.48,58.56 81.25,58.56 81.87,57.94 85.97,57.94 86.54,57.36 91.27,57.36 92.04,56.6 v2(94,56.6) ; v4(139.39,123.3) 139.39,122.31 144.34,117.36 144.34,107.94 148.39,103.89 148.39,102.11 151.1,99.4 v2(151.1,99.22) ; v2(148.38,97.95) 148.38,94.53 v2(148.91,94) ; v2(22.17,127.32) 22.17,129.33 21.91,129.58 21.91,130.13 22,130.22 22,146.89 21.02,147.86 v2(21.02,155.31) ; v2(145.18,50.1) 144.47,49.39 129.45,49.39 127.75,47.69 124.22,47.69 v4(124,47.46) ; v2(52.14,16.03) 51.67,16.03 46.3,10.65 45.15,10.65 v2(44.52,10.02) ; v2(157.04,71.87) 157.04,72.88 157.54,73.38 159.53,73.38 163.14,76.98 163.14,79.23 v2(163.39,79.49) 164.03,80.12 164.03,87.44 163.38,88.09 163.38,88.7 v2(163.37,88.71) 163.37,89.85 168.92,95.4 168.92,96.21 v2(173.32,100.62) ; v2(30.18,44.94) 30.18,44.82 36.82,38.17 36.82,35.34 v4(36.62,35.14) ; v2(23.56,250.43) 25.22,252.08 25.22,255.05 26.31,256.15 27.5,256.15 v2(29.28,257.92) 31.41,255.79 33.11,255.79 33.54,255.36 36.07,255.36 37.55,256.84 47.88,256.84 48.46,256.27 54.55,256.27 55.31,257.03 v2(55.31,257.54)
  L4 w1.016: v4(42.31,43.19) 43.93,43.19 44.65,43.9 46.3,43.9 47.66,45.26 47.66,46.47 48.42,47.23 49.35,47.23 v2(49.82,46.76) 49.94,46.76 50.23,46.47 52.24,46.47 v4(53.43,45.27) ; v4(49.6,24.75) 48.46,24.75 46.99,23.29 45.13,23.29 39.95,28.47 39.95,35.75 v4(39.08,36.61)
  L4 w1.27: v4(181.3,194.68) 182.12,195.5 182.12,216.42 165.74,232.8 154.4,232.8 153.92,232.32 v2(145.9,232.32)
  BOTTOM w0.406: C12166.2 24.58,251.57 23.44,251.57 23.12,251.89 U3.5
  BOTTOM w0.508: v2(151.1,99.22) 150.89,99.02 R1838.1 ; PR5302.1 17.88,110.73 19.77,112.62 v4(19.77,112.76) ; v2(20.75,45.71) 20.96,45.71 21.21,45.96 R531.1 21.21,46.94 22.24,47.97 22.24,49.07 24.77,51.6 26.44,51.6 26.71,51.32 27.3,51.32 27.77,51.78 27.77,52.3 28.52,53.05 v2(29.99,53.05) ; v4(126.94,251.7) 124.02,251.7 121.1,248.78 116.02,248.78 v2(111.7,244.46) 111.17,243.93 111.17,241.31 v2(111.83,240.65) 111.83,238.49 109.8,236.46 109.8,234.17 v2(110.56,233.41) ; v2(44.52,10.02) 43.38,11.16 40.83,11.16 36.89,15.1 34.49,15.1 v5(32.45,13.07) 32.39,13 v2(28.96,13) ; C11836.1 142.69,87.99 142.76,87.92 142.76,86.94 142.41,86.58 142.41,86.47 v2(142.3,86.36) ; v2(145.8,98.05) 146.3,98.05 146.58,97.77 R1839.2 ; 109.29,54.22 109.8,54.72 111.58,54.72 ; 109.29,54.22 109.29,52.94 110.24,51.99 110.24,49.35 111.65,47.94 v2(111.65,47.28) 120.54,47.28 121.38,48.12 123.34,48.12 v4(124,47.46) ; 109.29,54.22 107.93,54.22 107.39,54.76 106.58,54.76 103.65,57.69 99.24,57.69 v2(97.34,59.59) ; v2(137.64,97.14) 136.83,96.34 v2(136.83,94.98) 137.55,94.98 R1815.2 ; R1730.2 162.24,88.71 v2(163.37,88.71) ; R9606.1 50.26,47.17 49.94,46.85 49.9,46.85 v2(49.82,46.76) ; v2(29.28,257.92) 29.79,257.92 30.23,257.48 R1970.1 ; R105.2 v2(153.87,92.82) R79740.2 ; R79833.1 152.02,88.35 R341.1 152.02,86.43 151.16,85.57 v2(150.67,85.57) ; R886.1 156.04,71.87 v2(157.04,71.87) ; v2(148.28,122.41) 148.28,122.29 148.66,121.91 PR207.1 ; R104.2 149.93,90.85 R1794.1 149.23,91.87 148.79,92.32 148.47,92.32 R221.1 148.91,93.14 v2(148.91,94) 148.4,94 148.18,94.22 R222.1 ; v2(20.52,42.79) 20.64,42.66 24.2,42.66 26.55,45.01 R79730.1 R79806.1 27.37,46.47 28.9,44.94 v2(30.18,44.94) ; C12166.2 R80229.1 23.82,250.18 v2(23.56,250.43) ; v2(52.14,16.03) 52.14,17.19 52.77,17.83 R79743.1 ; v2(163.39,79.49) 163.84,79.49 165.35,77.98 170.48,77.98 172.08,76.38 172.08,70.9 171.44,70.27 171.44,61.2 170.38,60.13 170.38,58.66 166.88,55.17 R2091.1 164.14,55.17 163.49,54.52 160.14,54.52 159.63,55.03 v2(156.05,55.03) 156.05,54.3 153.45,51.7 151.64,51.7 150.9,50.96 149.99,50.96 148.75,49.72 145.56,49.72 v2(145.18,50.1)
  BOTTOM w1.016: v4(36.59,40.45) 37.38,40.45 Q9601.D 38.83,41.9 40.09,41.9 40.63,42.43 41.55,42.43 v4(42.31,43.19) ; v4(53.43,45.27) 58.63,50.47
  vias: v2(145.43,233.79) v3(143.05,230.8) v3(145.38,235.04) v4(30.55,104.63) v4(30.55,103.65) v4(58.93,129.04) v4(60.29,129.04) v4(94.94,141.85) v4(108.4,231.51) v4(108.91,230.49) v4(110.05,230.49) v4(143.45,233.79) v4(143.45,232.65)
SB3V_CT2: length 4.3
  BOTTOM w0.203: v3(69.59,49.77) 70.27,49.77 71.27,50.77 U22.10
  BOTTOM w0.254: v3(69.59,49.77) 68.69,49.77 C382.1
SB3V_EN: length 9.3
  BOTTOM w0.102: C381.1 76.37,49.81 76.37,51.33 76.05,51.65 75.56,51.65 75.48,51.57 U22.3 ; C381.1 75.89,49.96 75.89,50.41 75.53,50.77 U22.5 ; C381.1 76.21,49.2 v3(76.78,48.63) 76.97,48.44 R513.2 PR7.2
SB5V: length 909.8
  TOP w0.305: PC63.1 21.51,170.47 21.14,170.11 PU32.7
  TOP w0.508: v4(160.09,210.17) 160.09,210.6 161.7,212.2 PR181.2 ; R250.2 91.83,56.86 90.75,57.94 v4(90.75,59.04) ; R756.1 R751.1 37.41,11.92 v2(37.15,11.67) ; v2(154.5,101.31) 154.16,101.31 R117.1 ; v2(172.21,94.02) CN3.1 ; v4(16.16,250.09) 20.9,245.35 30.42,245.35 30.93,244.84 PR4477.1 ; PC63.1 21.72,171.88 v2(22.29,171.31)
  TOP w0.635: v4(178.25,201.03) 178.38,200.9 178.38,200.77 182.43,196.71 v4(183.58,196.71) ; v4(160.09,210.17) 160.09,209.24 PR184.2
  TOP w1.016: v4(26.36,143.38) 28.35,143.38 PR8.1 PR2.1 30.93,142.91 31.46,143.45 v4(32.43,143.45) ; v4(133.8,125.54) 119.12,125.54 118.92,125.74 114.01,125.74 v4(113.61,125.34)
  L3 w0.508: v2(63.37,52.06) 58.33,52.06 57.37,53.02 44.83,53.02 43.66,54.19 32.3,54.19 30.5,52.39 29.13,52.39 28.93,52.59 28.38,52.59 27.99,52.2 27.99,48.85 22.6,43.45 22.6,29.15 v2(21.13,27.67)
  L3 w0.762: v4(49.01,257.29) 46.98,259.32 21.53,259.32 16.16,253.95 v4(16.16,250.09)
  L3 w1.016: v4(168.34,130.54) 165.04,127.24 151.83,127.24 v4(151.12,126.53) 150.78,126.87 136.86,126.87 135.53,125.54 v4(133.8,125.54) ; v4(135.71,266.31) 135.2,266.81 60.67,266.81 53.97,260.11 v4(53.97,257.47)
  L4 w0.508: v2(154.5,101.31) 154.41,101.31 148.51,107.21 148.51,119.77 151.12,122.38 v4(151.12,126.53) ; v2(37.15,11.67) 37.1,11.67 28.34,20.43 25.17,20.43 22.14,23.46 22.14,25.03 21.13,26.05 v2(21.13,27.67)
  L4 w0.762: v4(16.16,250.09) 15.79,250.09 5.78,240.09 5.78,186.55 11.5,180.83 11.5,171.09 13.31,169.28 15.55,169.28 17.2,167.63 18.1,167.63 18.61,168.13 v4(18.61,168.39)
  L4 w1.016: v4(102.79,111.37) 101.72,111.37 100.87,110.51 100.87,109.23 100.9,109.2 100.9,103.21 100.75,103.06 100.75,99.41 103.46,96.7 103.46,94.43 103.93,93.96 103.93,90.51 102.05,88.63 102.05,86.09 104.03,84.11 104.03,80.96 96.59,73.52 v2(96.59,73.01)
  BOTTOM w0.508: 166.19,205.01 166.19,204.85 167.59,203.44 171.01,203.44 173.42,201.03 v4(178.25,201.03) ; 166.19,205.01 160.71,205.01 158.67,207.06 158.67,209.05 159.79,210.17 v4(160.09,210.17) 160.37,209.89 162.54,209.89 R1956.1 ; 166.19,205.01 R1954.1 ; v2(154.5,101.31) 158.12,97.69 164.11,97.69 167.01,94.79 170.92,94.79 171.69,94.02 v2(172.21,94.02) ; 108.1,55.97 107.61,55.49 106.76,55.49 103.91,58.33 100.91,58.33 98.81,60.43 98.32,60.43 95.95,62.8 94.35,62.8 93.59,63.56 v4(93.59,63.71)
  BOTTOM w0.762: v2(22.29,171.31) 22.29,170.55 21.28,169.53 19.75,169.53 v4(18.61,168.39) 18.61,166.91 18.99,166.53 18.99,152.77 22.68,149.08 22.68,147.06 v4(26.36,143.38) ; v4(32.43,143.45) 32.38,143.5 31.9,143.5 29.96,141.57 29.96,136.89 29.41,136.33 29.41,112.92 28.26,111.78 28.26,109.57 30.81,107.02 31.04,107.02 31.74,106.32 31.74,102 29.53,99.79 29.53,87.24 22.8,80.5 22.8,71.49 33.17,61.12 51.32,61.12 51.93,61.73 60.5,61.73 63.44,58.79 63.44,53.83
  BOTTOM w1.016: v4(113.61,125.34) 113.48,125.21 109.41,125.21 103.45,119.24 103.45,114.16 102.79,113.5 v4(102.79,111.37) ; v4(135.71,266.31) 137.1,266.31 176.85,226.55 176.85,221.76 183.58,215.03 v4(183.58,196.71) 183.08,196.2 181.42,196.2 176.35,191.13 176.35,157.34 172.66,153.66 172.66,134.86 v4(168.34,130.54)
  vias: v3(47.57,256.65) v4(64.2,52.06)
SB5V_CT1: length 3.8
  BOTTOM w0.203: 71.82,51.57 U22.12
  BOTTOM w0.254: C383.1 70.36,50.98 69.92,51.42 v3(69.92,51.68) 70.05,51.8 70.68,51.8 70.92,51.57 71.82,51.57
SCALAR_ACK: length 156.3
  TOP w0.102: U2.AL39 145.17,86 v2(145.56,85.61) ; SCA1.53 35.51,46.58 36.01,46.09 38.42,46.09 39.19,46.85 40.9,46.85 41.41,46.34 41.41,45.36 41.32,45.27 41.32,44.55 v2(41.79,44.08)
  L3 w0.127: v2(145.46,92.98) 145.11,92.98 142.52,95.56 142.52,96.66 142.1,97.09 141.71,97.09 138.66,94.04 138.66,92.37 136.09,89.8 136.09,87.74 134.94,86.6 134.94,85.97 133.32,84.35 132.37,84.35 131.64,83.63 131.64,83.02 129.38,80.76 123.29,80.76 121,78.47 119.07,78.47 117.34,76.74 116.2,76.74 109.38,69.92 108.75,69.92 106.44,67.62 106.44,66.22 103.84,63.61 103.04,63.61 100.41,60.98 100.41,58.99 98.34,56.93 98.34,54.39 97.49,53.54 90.97,53.54 90.29,52.87 86.9,52.87 82.08,48.06 80.94,48.06 79.57,46.68 64.53,46.68 63.4,47.82 57.07,47.82 55.49,46.25 50.67,46.25 49.75,45.33 44.65,45.33 43.29,43.97 42.27,43.97 42.15,44.08 v2(41.79,44.08)
  BOTTOM w0.102: R79940.1 144.62,93.97 145.46,93.13 v2(145.46,92.98) 145.46,92.39 145.77,92.08 145.77,91.17 146.2,90.74 146.2,89.8 145.92,89.52 145.92,89.06 145.74,88.88 145.74,87.29 145.56,87.11 v3(145.56,86.55) v2(145.56,85.61)
SCALAR_EN: length 90
  TOP w0.102: U109.120 114.57,50.09 114.01,50.66 113.76,50.66 111.91,52.51 110,52.51 v2(109.24,51.75)
  L3 w0.127: v2(109.24,51.75) 103.47,45.99 90.2,45.99 88.25,44.03 88.25,41.43 86.11,39.3 86.11,36.97 85.14,36 79.12,36 77.19,34.06 66.81,34.06 65.7,32.96 61.18,32.96 v2(58.74,35.39)
  L4 w0.127: v2(58.74,35.39) 56.73,35.39 54.51,37.61 54.51,39.04 53.99,39.57 53.17,39.57 v2(51.43,41.31)
  BOTTOM w0.102: R79809.2 47.63,46.53 48.38,45.78 49,45.78 49.5,46.28 R9606.2 51.19,46.28 51.55,45.91 51.55,44.6 51.4,44.44 v3(51.4,44.44) 51.4,44.39 51.55,44.24 51.55,41.44 v2(51.43,41.31)
SCALAR_EN_G: length 4.7
  BOTTOM w0.102: PQ5007.2 47.74,44.61 48.02,44.89 48.02,45.63 46.81,46.85 R79809.1 46.74,46.85 45.74,46.85 v3(45.71,46.87)
SCALAR_MUTE: length 168.8
  TOP w0.102: SCA1.35 44.9,45.45 45.28,45.83 45.28,47.48 46.1,48.3 v2(46.1,48.46) 46.1,48.46 46.1,49.17 v1(46.24,49.31) 46.5,49.31 46.73,49.08 48.9,49.08 R79949.2 ; Q9620.2 181.17,28.82 181.3,28.69 181.3,27.67 180.79,27.16 v2(180.28,27.16)
  L4 w0.127: v2(46.1,48.46) 46.83,49.19 49.08,49.19 49.89,50 61.39,50 64.5,46.89 76.37,46.89 76.4,46.86 103.56,46.86 107.8,42.62 107.8,41.86 109.16,40.5 109.16,39.86 117.81,31.21 119.26,31.21 123.17,27.3 126.35,27.3 126.94,26.71 127.56,26.71 128.34,25.93 135.25,25.93 138.64,22.54 141.32,22.54 141.78,22.08 149.65,22.08 153.08,18.66 157.7,18.66 157.91,18.87 164.15,18.87 167.5,15.52 172.36,15.52 180.28,23.44 v2(180.28,27.16)
SCALAR_OUT_L: length 5.6
  TOP w0.203: C12192.1 42.91,51.69 v1(41.42,50.2) 41.39,50.18 40.1,50.18 39.51,49.59 SCA1.45
SCALAR_OUT_L_C: length 250.9
  TOP w0.203: v2(39.95,52.72) 39.95,52.69 40.07,52.82 40.07,52.89 40.43,53.25 41.71,53.25 v1(42.15,52.81) 42.15,51.86 C12192.2 ; U9615.2 177.23,46.09 v2(177.87,45.45)
  L3 w0.203: v2(34.23,18.15) 33.51,18.15 32.71,18.95 32.71,29.11 33.24,29.65 33.24,30.35 34.16,31.27 34.16,40.26 35.77,41.87 35.77,46.69 36.31,47.23 37.43,47.23 39.52,49.32 39.52,52.11 39.95,52.54 v2(39.95,52.72)
  L4 w0.203: v2(177.87,45.45) 181.33,45.45 186.16,40.62 186.16,28.19 162.96,4.99 117.72,4.99 115.46,7.24 115.46,10.82 107.41,18.87 107.41,20.08 105.24,22.24 82.8,22.24 78.99,18.43 68.69,18.43 59.11,8.85 57.07,8.85 53.62,12.31 50.29,12.31 47.5,9.51 44.31,9.51 43.63,10.19 43.63,10.29 42.88,11.04 42.05,11.04 34.94,18.15 v2(34.23,18.15)
SCALAR_OUT_R: length 3.5
  TOP w0.203: C12193.1 39.3,50.85 v1(39.01,50.56) 39.03,50.53 39.03,49.93 39.01,49.91 SCA1.46
SCALAR_OUT_R_C: length 250.2
  TOP w0.203: U9615.10 v2(180.49,47.28) ; v2(39.19,52.72) 38.55,52.72 38.3,52.46 v1(38.3,52.21) 38.77,51.74 C12193.2
  L3 w0.203: v2(39.19,52.72) 39.19,52.61 38.93,52.35 38.93,49.56 37.19,47.81 35.11,47.81 33.85,46.55 33.85,41.5 33.06,40.71 33.06,34.5 32,33.44 32,18.67 33.28,17.39 v2(34.23,17.39)
  L4 w0.203: v2(34.23,17.39) 34.88,17.39 42.62,9.64 43.36,9.64 44.07,8.93 48.46,8.93 50.57,11.04 53.07,11.04 55.84,8.27 59.36,8.27 68.93,17.84 79.23,17.84 83.05,21.66 105,21.66 106.83,19.84 106.83,18.63 114.88,10.58 114.88,7 117.47,4.41 163.2,4.41 186.75,27.95 186.75,41.02 v2(180.49,47.28)
