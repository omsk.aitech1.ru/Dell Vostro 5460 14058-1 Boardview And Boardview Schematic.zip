# Allegro board 14058-1.0623WZS1658.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM: 91.64,82.41 91.38,82.66 91.38,88.89 90.87,89.39 90.87,89.9 91,90.03 91.64,90.03 92.27,89.39 92.27,88.63 93.03,87.87 93.03,82.66 92.78,82.41 ; 9 cut-outs
GND on BOTTOM: 153.1,163.05 152.98,163.18 152.98,165.85 153.23,166.1 156.28,166.1 156.53,165.85 156.53,163.82 155.77,163.05
GND on BOTTOM: 15.18,184.14 14.8,184.52 13.91,184.52 12.13,186.3 12.13,187.06 12.39,187.31 12.85,187.31 13.23,187.69 13.23,189.5 13.53,189.8 13.53,189.85 16.45,192.77 16.96,192.77 17.09,192.65 17.09,192.39 16.71,192.01 16.71,190.74 16.96,190.49 18.48,190.49 18.48,187.18 17.21,187.18 17.09,187.06 17.09,184.52 16.71,184.14
GND on BOTTOM: 30.68,31.1 30.55,31.23 30.55,31.61 30.17,31.99 29.28,31.99 29.15,32.12 29.15,32.63 29.28,32.75 30.3,32.75 30.68,32.37 31.69,32.37 32.45,33.13 32.96,33.13 33.6,32.5 35.38,32.5 35.88,31.99 35.88,31.48 35.5,31.1
GND on BOTTOM: 77.29,189.09 77.03,189.34 77.03,191.03 76.68,191.38 70.81,191.38 69.92,192.26 69.92,194.46 70.17,194.71 79.7,194.71 79.7,194.68 80.21,194.17 80.21,193.15 79.83,192.77 79.06,192.77 78.81,192.52 78.81,189.22 78.68,189.09 ; 1 cut-out
GND on BOTTOM: 47.44,212.46 46.93,212.97 46.93,214.87 47.31,215.25 49.09,215.25 49.35,215 49.35,212.84 48.96,212.46
GND on BOTTOM: 153.49,170.8 153.23,171.06 153.23,173.85 153.49,174.1 156.28,174.1 156.53,173.85 156.53,172.96 156.03,172.45 155.14,172.45 154.88,172.2 154.88,170.8
GND on BOTTOM: 81.73,105.02 81.35,105.4 81.35,106.92 81.73,107.3 81.73,107.81 81.98,108.06 81.98,108.83 81.22,109.59 81.22,114.67 81.1,114.79 81.1,115.43 81.35,115.68 81.73,115.68 81.98,115.43 81.98,115.05 82.37,114.67 83.51,114.67 83.89,115.05 85.16,115.05 85.79,114.41 85.79,114.03 84.27,114.03 84.14,113.91 82.75,113.91 82.62,114.03 82.37,114.03 81.86,113.52 81.86,113.02 82.24,112.64 82.87,112.64 83.25,112.25 83.25,110.73 83,110.48 83,108.19 82.75,107.94 82.75,105.27 82.49,105.02 ; 8 cut-outs
GND on BOTTOM: 35.96,76.29 35.4,76.85 34.89,76.85 34.69,76.64 34.33,76.64 34.16,76.82 34.16,77.2 33.7,77.66 33.34,77.66 33.32,77.68 33.32,78.85 33.34,78.88 36.14,78.88 36.75,79.49 37.46,79.49 37.58,79.36 37.58,77.46 36.42,76.29 ; 1 cut-out
GND on BOTTOM: 67,19.29 66.36,19.93 66.36,23.99 67.95,25.58 67.95,26.85 67.89,26.91 67.89,28.94 64.71,32.12 63.32,32.12 62.3,33.13 62.3,35.67 61.28,36.69 59.51,36.69 55.44,40.75 55.44,42.28 55.95,42.79 56.2,42.79 57.73,41.26 57.73,41.01 58.62,40.12 61.41,40.12 63.57,42.28 63.57,43.55 62.68,44.44 62.68,45.2 63.06,45.58 69.87,45.58 70.81,46.52 72.36,46.52 72.81,46.98 72.81,49.08 73.17,49.44 73.17,52.49 74.03,52.49 74.03,49.24 74.11,49.16 74.11,45.58 75.38,44.31 75.38,43.93 75.13,43.67 73.98,43.67 72.87,44.79 70.53,44.79 69.79,44.06 67.25,44.06 66.87,43.67 66.87,38.98 68.27,37.58 68.27,36.05 69.41,34.91 70.81,34.91 70.94,34.78 70.94,33.39 72.97,31.36 72.97,26.4 72.08,25.51 72.08,24.12 73.73,22.47 79.32,22.47 79.57,22.21 79.57,19.93 78.94,19.29 ; 5 cut-outs
GND on BOTTOM: 151.58,115.18 151.45,115.3 151.45,118.6 152.47,119.62 155.64,119.62 156.03,119.24 156.03,115.56 155.64,115.18
GND on BOTTOM: 63.57,67.8 62.17,69.2 62.17,71.87 62.68,72.38 68.78,72.38 70.68,70.47 70.68,67.93 70.55,67.8
GND on BOTTOM: 13.4,11.87 13.3,11.97 13.3,12.94 13.73,13.37 14.47,13.37 14.6,13.24 14.6,11.95 14.52,11.87
GND on BOTTOM: 142.82,160.39 141.67,161.53 141.67,167.88 142.69,168.9 142.69,170.04 143.45,170.8 144.47,170.8 144.6,170.67 144.6,160.51 144.47,160.39 ; 12 cut-outs
GND on BOTTOM: 96.97,260.97 96.72,261.23 96.72,262.62 96.21,263.13 96.21,264.53 96.59,264.91 103.32,264.91 103.57,264.65 103.57,263.38 104.21,262.75 104.21,262.24 104.08,262.11 102.94,262.11 102.43,262.62 100.4,262.62 100.27,262.5 100.27,260.97
GND on BOTTOM: 13.02,128 12.77,128.26 12.77,130.42 12.52,130.67 11.12,130.67 10.86,130.92 10.86,138.29 10.99,138.42 13.28,138.42 13.53,138.16 13.53,130.92 13.91,130.54 15.06,130.54 15.44,130.92 15.44,133.72 15.69,133.97 17.47,133.97 17.85,133.59 17.85,132.19 17.6,131.94 17.6,130.54 17.21,130.16 15.69,130.16 15.56,130.03 15.56,128.38 15.18,128 ; 2 cut-outs
GND on BOTTOM: 60.01,26.15 59.63,26.53 59.63,29.45 60.14,29.96 61.54,29.96 62.55,28.94 64.46,28.94 64.71,28.69 64.71,26.28 64.59,26.15 ; 7 cut-outs
GND on BOTTOM: 7.44,218.3 7.05,218.68 7.05,226.68 7.44,227.06 18.61,227.06 18.87,226.81 18.87,225.28 18.61,225.03 17.47,225.03 16.71,224.27 16.71,223 16.96,222.74 18.48,222.74 18.48,219.44 17.47,219.44 16.33,218.3
GND on BOTTOM: 68.01,48.58 66.64,49.95 66.64,51.55 66.97,51.88 68.12,51.88 68.62,52.39 69.16,52.39 69.36,52.18 69.36,51.37 69.59,51.14 69.69,51.14 69.82,51.01 69.82,50.51 69.67,50.35 68.27,50.35 68.09,50.18 68.09,49.41 68.5,49.01 68.5,48.8 68.27,48.58 ; 2 cut-outs
GND on BOTTOM: 155.64,208.77 155.26,209.16 155.26,210.55 154.63,211.19 151.83,211.19 151.83,214.49 152.72,215.38 152.72,216.52 152.98,216.78 158.44,216.78 158.82,216.39 158.82,210.17 157.42,208.77 ; 3 cut-outs
GND on BOTTOM: 6.93,4.3 6.8,4.43 6.8,6.72 7.18,7.1 10.74,7.1 10.99,6.84 10.99,4.81 10.48,4.3
GND on BOTTOM: 57.73,123.81 57.6,123.94 57.6,125.72 57.22,126.1 55.82,126.1 55.44,125.72 55.44,124.95 55.31,124.83 51.12,124.83 50.87,125.08 50.23,125.08 50.11,125.21 50.11,125.84 51,126.73 63.82,126.73 64.33,126.22 64.33,125.08 64.08,124.83 58.74,124.83 58.49,124.57 58.49,124.07 58.24,123.81 ; 9 cut-outs
GND on BOTTOM: 64.71,254.24 64.71,257.54 65.47,258.3 69.41,258.3 69.67,258.56 70.68,258.56 70.81,258.43 70.81,256.02 70.55,255.76 69.92,255.76 69.67,256.02 68.27,256.02 68.01,255.76 68.01,254.24
GND on BOTTOM: outline of 518 points within 1.02,1.02 203.98,268.98 ; 46 cut-outs
GND on BOTTOM: 141.67,172.2 141.42,172.45 141.42,174.48 142.06,175.12 145.61,175.12 145.74,174.99 145.74,174.36 145.61,174.23 145.1,174.23 144.85,173.98 144.85,172.33 144.72,172.2 ; 7 cut-outs
GND on BOTTOM: 17.6,174.36 16.83,175.12 16.83,177.28 17.47,177.91 22.8,177.91 23.06,177.66 23.06,176.52 20.9,174.36 ; 1 cut-out
GND on BOTTOM: 29.53,148.2 29.28,148.45 29.28,152.13 29.66,152.51 31.06,152.51 31.31,152.77 31.31,154.29 34.61,154.29 34.61,152.64 35.12,152.13 35.12,150.1 34.61,149.59 32.84,149.59 31.44,148.2
GND on BOTTOM: 35.63,68.69 34.87,69.46 32.45,69.46 31.95,69.96 31.95,70.98 32.33,71.36 34.23,71.36 34.99,72.12 34.99,73.01 36.01,74.03 41.09,74.03 41.22,73.9 41.22,69.58 41.09,69.46 39.19,69.46 38.42,68.69 ; 1 cut-out
GND on BOTTOM: 82.87,18.02 82.29,18.6 82.29,20.48 82.54,20.74 86.73,20.74 87.37,20.1 87.37,18.45 86.94,18.02
GND on BOTTOM: 89.99,53.45 88.84,54.6 88.08,54.6 87.95,54.72 87.95,59.55 88.08,59.68 88.97,59.68 89.6,59.04 89.6,55.99 90.75,54.85 90.75,53.58 90.62,53.45 ; 3 cut-outs
GND on BOTTOM: 169.87,160.9 169.74,161.02 169.74,175.37 170.12,175.75 171.65,175.75 171.9,175.5 171.9,162.42 170.38,160.9 ; 7 cut-outs
GND on BOTTOM: 87.57,69.2 87.19,69.58 85.41,69.58 85.29,69.71 85.29,70.73 85.41,70.85 88.33,70.85 89.1,70.09 89.1,69.33 88.97,69.2 ; 2 cut-outs
GND on L2GND: outline of 214 points within 1.02,1.02 203.98,268.98 ; 23 cut-outs
GND on L3: 67.63,25.26 67.63,30.09 68.27,30.72 72.71,30.72 73.22,30.21 73.22,26.66 72.08,25.51 72.08,24.12 73.86,22.34 79.44,22.34 79.57,22.21 79.57,19.93 78.94,19.29 66.87,19.29 66.24,19.93 66.24,23.86
GND on L3: outline of 189 points within 1.02,1.02 203.98,268.98
GND on L3: 57.73,46.34 62.43,46.34 63.57,45.2 63.57,41.13 62.05,39.61 57.98,39.61 56.46,41.13 56.46,45.07
GND on L4: outline of 204 points within 1.02,1.02 203.98,268.98
GND on L4: 58.11,46.85 61.54,46.85 63.82,44.56 63.82,41.13 61.79,39.1 58.62,39.1 56.08,41.64 56.08,44.82
GND on L5GND: outline of 138 points within 1.02,1.02 203.98,268.98 ; 25 cut-outs
PVCC_3V3 on TOP: 60.65,8.62 60.14,9.13 60.14,10.4 60.65,10.91 63.57,10.91 64.46,10.02 64.46,9.64 64.2,9.38 63.57,9.38 63.44,9.51 62.68,9.51 62.55,9.38 62.55,9 62.17,8.62 ; 2 cut-outs
PVCC_3V3 on BOTTOM: 32.07,40.12 31.69,40.5 31.69,46.34 32.45,47.1 33.09,47.1 33.34,46.85 33.34,40.5 32.96,40.12 ; 2 cut-outs
V1P0_PCH_S5 on TOP: 159.84,89.78 158.57,91.05 155.9,91.05 154.88,92.06 154.88,96.76 155.26,97.14 161.49,97.14 161.87,96.76 161.87,90.03 161.61,89.78
V1P0_PCH_S5 on BOTTOM: 141.04,73.65 140.53,74.15 140.53,74.28 139.13,74.28 138.75,73.9 137.61,73.9 136.09,75.42 136.09,75.55 138.12,77.58 138.12,79.87 138.37,80.12 142.06,80.12 142.69,79.49 143.45,79.49 143.96,78.98 143.96,76.44 142.82,75.3 141.8,75.3 141.29,74.79 141.29,73.9 ; 1 cut-out
V1P0_PCH_S5 on BOTTOM: 136.85,99.43 136.72,99.55 136.72,100.57 136.85,100.7 138.63,100.7 138.75,100.57 138.75,99.68 138.5,99.43 ; 1 cut-out
V1P0_PCH_S5 on L4: 136.98,82.66 136.98,86.73 136.64,87.06 136.64,89.09 135.02,90.71 135.02,93.38 133.04,95.36 133.04,99.81 135.71,102.48 136.85,102.48 139.13,100.19 139.13,95.49 160.22,95.49 160.85,94.86 160.85,81.49 156.56,77.2 153.87,77.2 153.61,77.46 152.47,77.46 151.07,76.06 138.37,76.06 137.99,76.44 137.99,81.65
VBAT1 on TOP: 125.16,105.52 123.89,106.79 123.89,110.86 125.04,112 128.59,112 128.72,111.87 128.72,108.19 126.05,105.52 ; 2 cut-outs
VBAT1_R on TOP: 123.26,100.06 122.88,100.44 122.88,101.59 124.4,103.11 124.4,104.89 124.78,105.27 126.31,105.27 127.7,103.87 127.7,101.71 127.45,101.46 126.56,101.46 126.43,101.59 124.78,101.59 124.4,101.21 124.4,100.44 124.02,100.06 ; 2 cut-outs
VCC on TOP: 21.41,111.37 21.15,111.62 21.15,113.27 21.41,113.52 28.64,113.52 28.77,113.4 28.77,112.51 28.52,112.25 25.72,112.25 25.09,111.62 23.69,111.62 23.44,111.37 ; 2 cut-outs
VCC on BOTTOM: 18.99,48.88 18.87,49.01 18.87,51.04 18.99,51.17 19.5,51.17 19.75,51.42 19.75,54.98 20.01,55.23 21.53,55.23 21.79,54.98 21.79,50.15 20.52,48.88 ; 2 cut-outs
VCC on BOTTOM: 21.91,57.9 21.15,58.66 21.15,63.74 17.34,67.55 17.34,71.87 17.72,72.25 17.72,83.17 23.82,89.27 23.82,100.06 21.15,102.73 21.15,113.14 23.18,115.18 23.95,115.18 25.47,113.65 25.47,101.84 25.98,101.33 25.98,88.38 19.88,82.28 19.88,70.85 19.25,70.22 19.25,68.82 23.44,64.63 23.44,58.41 22.93,57.9
VCC on BOTTOM: 81.78,61.53 81.25,62.06 81.25,65.47 81.48,65.7 82.59,65.7 83.71,64.58 84.93,64.58 85.18,64.32 85.18,61.86 84.85,61.53 ; 2 cut-outs
VCC on L3: 83,64.88 83.13,64.76 83.13,63.11 78.17,58.15 22.04,58.15 21.41,58.79 21.41,60.57 22.17,61.33 63.32,61.33 63.95,61.96 74.36,61.96 75.89,63.49 75.89,65.14 76.27,65.52 79.83,65.52 80.46,64.88
VCC on L4: 19.12,48.75 19.5,48.75 19.75,48.5 20.52,48.5 20.9,48.88 20.9,49.39 20.96,49.45 20.96,55.55 23.18,57.77 23.18,58.53 22.17,59.55 21.53,59.55 18.87,56.88 18.87,49.01
VCC3 on TOP: 180.92,49.52 180.54,49.9 180.54,50.79 181.17,51.42 181.55,51.42 181.93,51.04 181.93,49.77 181.68,49.52 ; 1 cut-out
VCC3 on TOP: 140.05,45.07 139.41,45.71 139.41,46.62 139.64,46.85 142.18,46.85 142.82,47.48 144.6,47.48 144.85,47.23 145.74,47.23 147.26,45.71 149.17,45.71 150.44,46.98 151.33,46.98 151.45,46.85 151.45,45.2 151.33,45.07 ; 2 cut-outs
VCC3 on BOTTOM: 132.28,129.02 129.74,131.56 127.45,131.56 126.05,130.16 123.01,130.16 122.37,130.8 122.37,131.43 122.5,131.56 123.39,131.56 125.8,133.97 129.99,133.97 133.67,130.29 133.67,129.53 133.17,129.02
VCC3 on BOTTOM: 86.68,66.53 85.41,67.8 83.13,67.8 82.49,67.17 81.48,67.17 81.48,68.57 81.98,69.07 82.62,69.07 83.25,69.71 84.78,69.71 85.29,69.2 87.19,69.2 87.45,68.95 89.73,68.95 89.86,68.82 89.86,66.79 89.6,66.53 ; 2 cut-outs
VCC3 on BOTTOM: 113.1,58.66 112.72,59.04 112.72,59.93 111.96,60.69 111.45,60.69 111.32,60.82 111.32,61.33 111.58,61.58 112.08,61.58 112.21,61.71 112.21,61.96 112.46,62.22 112.95,62.22 113.1,62.06 113.66,62.06 113.89,61.84 113.89,61.17 114.12,60.95 114.12,60.18 114.24,60.06 117.54,60.06 117.8,59.8 117.8,59.3 117.42,58.91 117.04,58.91 116.91,58.79 116.66,58.79 116.53,58.66 ; 2 cut-outs
VCC3 on BOTTOM: 189.81,144.89 188.54,146.16 188.54,146.93 187.9,147.56 186.12,147.56 185.87,147.81 185.87,150.23 186.12,150.48 186.76,150.48 187.65,149.59 187.65,148.83 188.03,148.45 188.16,148.45 188.54,148.07 188.54,147.94 188.92,147.56 189.05,147.56 190.44,146.16 190.44,145.02 190.32,144.89
VCC3 on L4: 121.86,128.76 122.37,128.76 123.77,130.16 123.77,131.43 123.64,131.56 122.62,131.56 121.1,130.03 121.1,129.53
VCC3 on L4: 147.9,133.46 168.73,133.46 171.14,135.88 171.14,137.27 150.06,137.27 149.29,136.51 146.88,136.51 145.99,135.62 145.99,133.21 146.12,133.08 147.52,133.08
VCC3 on L4: 88.46,67.42 90.62,67.42 92.53,69.33 92.53,73.27 92.14,73.65 91.38,73.65 90.87,73.14 90.87,70.34 90.11,69.58 88.97,69.58 88.21,68.82 88.21,67.68
VCC3_CAM on TOP: 174.69,194.42 174.44,194.68 174.44,210.81 174.57,210.93 175.71,210.93 175.84,210.81 175.84,209.03 176.35,208.52 176.35,206.62 176.09,206.36 176.09,194.55 175.96,194.42 ; 5 cut-outs
VCC5_PANEL on TOP: 21.41,54.98 21.02,55.36 21.02,56.88 23.82,56.88 23.95,56.76 23.95,55.49 23.44,54.98
VCC5_PANEL on BOTTOM: 22.68,52.56 22.42,52.82 22.42,55.23 22.17,55.49 21.02,55.49 20.64,55.87 20.64,56.76 20.9,57.01 23.95,57.01 24.96,58.03 27.5,58.03 27.76,57.77 27.76,57.01 27.37,56.63 25.6,56.63 25.22,56.25 25.22,53.45 24.33,52.56 ; 3 cut-outs
VCC5_USB on TOP: 107.64,35.93 107.26,36.31 107.26,37.45 107.51,37.71 108.27,37.71 108.65,38.09 108.65,39.36 109.42,40.12 110.31,40.12 110.43,39.99 110.43,39.41 110.1,39.08 110.1,36.49 109.54,35.93 ; 1 cut-out
VCC5_USB on TOP: 177.62,86.6 176.47,87.74 176.47,89.52 176.73,89.78 178.25,89.78 178.89,89.14 181.3,89.14 181.43,89.01 181.43,87.36 180.66,86.6 ; 4 cut-outs
VCC5_USB on TOP: 111.83,20.05 111.19,20.69 111.19,23.35 111.7,23.86 112.97,23.86 113.48,23.35 113.48,20.56 112.97,20.05
VCC5_USB on BOTTOM: 110.56,7.23 110.05,7.73 110.05,22.97 106.24,26.78 106.24,35.8 106.37,35.93 106.37,41.01 103.45,43.93 91.13,43.93 90.34,44.72 89.25,44.72 81.22,52.74 81.22,59.42 81.86,60.06 86.56,60.06 87.7,58.91 87.7,54.72 88.21,54.22 88.84,54.22 94.3,48.75 105.61,48.75 113.1,41.26 113.23,41.26 115.64,38.85 115.64,18.53 114.75,17.64 114.75,14.72 115.64,13.83 115.64,7.61 115.26,7.23 ; 4 cut-outs
VCC5_USB on L3: 135.83,11.42 138.37,8.88 141.93,8.88 143.33,10.27 151.2,10.27 151.71,10.78 151.71,14.97 154.5,17.77 154.5,29.2 151.71,31.99 151.71,48.5 155.64,52.44 155.64,57.26 157.3,58.91 167.2,58.91 167.2,59.8 168.75,61.35 168.75,72.02 171.01,74.28 171.01,75.17 172.66,76.82 173.55,76.82 174.76,78.03 174.76,80.95 178.76,84.95 178.76,88 179.39,88.63 181.04,88.63 182.19,87.49 182.19,83.81 182.06,83.81 178.5,80.25 178.5,77.33 172.03,70.85 172.03,60.95 171.39,60.31 171.39,56.12 170.63,55.36 170.63,54.72 169.49,53.58 169.49,51.93 166.19,48.63 164.53,48.63 163.14,47.23 159.58,47.23 158.82,46.47 158.82,5.96 157.42,4.56 110.56,4.56 110.18,4.94 110.18,10.15 111.45,11.42
3P3V_LAN on TOP: 56.33,24.75 55.7,25.39 55.7,26.28 55.44,26.53 53.66,26.53 52.14,25.01 51.5,25.01 51.38,25.13 51.38,26.28 51.76,26.66 51.76,27.04 52.9,28.18 55.57,28.18 56.84,26.91 56.84,26.4 57.6,25.64 58.74,25.64 59.25,26.15 60.01,26.15 60.01,25.51 59.25,24.75 ; 3 cut-outs
3P3V_LAN on BOTTOM: 59,19.54 58.87,19.67 58.87,23.1 58.36,23.61 58.36,24.12 59.25,24.12 59.76,23.61 59.76,21.96 60.01,21.7 61.41,21.7 62.17,20.94 62.17,20.56 61.16,19.54 ; 3 cut-outs
3P3V_LAN on L4: 59,25.39 64.46,25.39 64.71,25.13 66.36,25.13 66.49,25.26 66.49,26.15 66.11,26.53 58.11,26.53 57.6,26.02 57.6,25.13 57.85,24.88 58.49,24.88
3P3V_SPI on TOP: 152.27,86.35 152.04,86.57 151.91,86.57 151.73,86.75 151.73,87.87 151.81,87.95 153.03,87.95 153.74,87.24 153.74,86.6 153.49,86.35
3P3V_SPI on BOTTOM: 152.6,86.22 152.09,86.73 152.09,87.74 152.34,88 154.12,88 154.37,87.74 154.37,86.85 153.74,86.22 ; 2 cut-outs
+V_1P05_VGA on TOP: 91.89,124.83 90.87,125.84 89.48,125.84 88.97,126.35 88.97,127.11 89.35,127.49 89.6,127.49 89.99,127.88 89.99,128.51 90.49,129.02 93.03,129.02 93.41,128.64 93.41,125.21 93.03,124.83 ; 2 cut-outs
+V_1P05_VGA on TOP: 75.76,115.94 75.51,116.19 74.87,116.19 74.11,116.95 74.11,117.08 73.98,117.21 73.6,117.21 71.06,119.75 70.43,119.75 70.17,120 70.17,120.51 69.67,121.02 69.67,123.56 68.52,124.7 68.52,125.72 68.65,125.84 69.79,125.84 69.92,125.97 69.92,127.62 70.17,127.88 71.19,127.88 71.57,128.26 74.49,128.26 74.87,127.88 74.87,126.99 73.48,125.59 72.97,125.59 72.97,125.08 72.59,124.7 72.59,123.56 72.33,123.3 72.08,123.3 71.19,122.41 71.19,121.4 75.63,116.95 79.57,116.95 79.7,116.83 79.7,116.45 79.19,115.94 ; 2 cut-outs
+V_1P05_VGA on BOTTOM: 74.49,115.94 74.36,116.06 74.36,117.08 73.86,117.59 73.09,117.59 70.05,120.64 70.05,122.54 68.4,124.19 68.4,126.45 69.82,127.88 73.48,127.88 74.49,126.86 74.49,124.95 74.24,124.7 73.6,124.7 72.71,125.59 72.21,125.59 71.82,125.21 71.82,122.8 71.19,122.16 71.19,120.89 71.57,120.51 73.73,120.51 73.98,120.26 73.98,119.71 74.33,119.37 74.62,119.37 75.38,118.6 75.38,117.33 75.89,116.83 76.78,116.83 76.9,116.95 76.9,117.21 77.16,117.46 77.67,117.46 77.67,117.33 78.17,116.83 79.19,116.83 79.32,116.7 81.48,116.7 82.11,117.33 82.49,117.33 82.87,116.95 82.87,116.06 82.75,115.94 ; 11 cut-outs
+V_1P05_VGA on L3: 91.13,126.61 91.13,128.26 90.75,128.64 70.94,128.64 69.79,127.49 69.79,125.97 71.06,124.7 75.13,124.7 76.02,125.59 90.11,125.59
+V_1P35_VGA on TOP: outline of 254 points within 45.54,72.76 91.26,125.34 ; 59 cut-outs
+V_1P35_VGA on TOP: 72.59,87.36 72.46,87.49 72.46,87.62 73.09,88.25 73.09,89.14 73.48,89.52 73.98,89.52 74.24,89.78 74.24,90.16 73.86,90.54 73.86,90.79 73.35,91.3 73.35,93.33 73.73,93.71 75.13,93.71 75.38,93.46 75.38,92.57 74.75,91.93 74.75,90.41 75,90.16 75,89.27 74.75,89.01 74.75,88.51 73.98,87.74 73.48,87.74 73.09,87.36
+V_1P35_VGA on TOP: 90.49,85.46 90.24,85.71 89.35,85.71 88.84,86.22 88.84,86.98 88.59,87.24 88.08,87.24 87.57,87.74 87.32,87.74 86.81,87.24 86.68,87.24 86.56,87.36 86.56,87.49 86.94,87.87 86.94,88.89 87.45,89.39 87.45,91.93 86.94,92.44 86.94,92.82 87.19,93.08 87.19,93.33 86.56,93.97 86.56,94.09 85.67,94.98 82.62,94.98 82.24,94.6 82.24,92.44 81.98,92.19 80.71,92.19 79.95,91.43 79.95,91.3 80.21,91.05 81.1,91.05 81.35,90.79 81.35,90.66 80.97,90.28 79.57,90.28 79.32,90.54 79.32,91.17 78.3,92.19 78.17,92.06 77.41,92.06 77.16,92.32 77.16,92.44 77.54,92.82 77.92,92.82 78.43,93.33 78.43,93.97 80.46,96 88.59,96 89.1,95.49 89.1,91.81 89.35,91.55 89.35,89.14 88.59,88.38 88.59,87.74 88.72,87.62 89.1,87.62 89.48,87.24 91.13,87.24 91.26,87.11 91.26,85.46 ; 2 cut-outs
+V_1P35_VGA on TOP: 75.25,104 75.13,104.13 75.13,104.51 75.25,104.63 75.25,104.89 75.13,105.02 75.13,105.65 74.49,106.29 74.49,106.92 74.75,107.17 74.75,107.68 74.11,108.32 74.11,108.7 74.24,108.83 74.49,108.83 74.75,109.08 74.75,115.81 75,116.06 75.51,116.06 76.02,115.56 76.02,107.3 77.79,105.52 81.86,105.52 82.37,105.02 82.37,104.76 82.24,104.63 81.73,104.63 81.35,104.25 81.35,104.13 81.22,104 80.97,104 79.95,105.02 79.7,105.02 79.57,104.89 77.92,104.89 77.79,104.76 76.14,104.76 75.38,104
+V_1P35_VGA on TOP: 57.85,105.52 57.47,105.9 57.47,106.54 57.73,106.79 57.73,107.17 57.47,107.43 56.84,107.43 56.71,107.56 56.71,109.21 56.84,109.33 57.47,109.33 57.98,109.84 61.16,109.84 61.79,109.21 62.17,109.21 62.81,109.84 62.81,110.1 62.93,110.22 63.57,110.22 63.7,110.35 63.7,111.09 63.39,111.39 63.39,111.8 62.93,112.25 59.25,112.25 59.12,112.38 59.12,113.27 57.47,114.92 57.47,115.56 57.6,115.68 57.85,115.68 58.36,115.18 59.38,115.18 59.51,115.3 59.76,115.3 60.14,114.92 60.14,114.03 60.27,113.91 60.78,113.91 60.9,114.03 60.9,114.41 61.41,114.92 63.44,114.92 63.82,114.54 63.95,114.54 64.08,114.67 64.08,115.18 64.59,115.68 65.35,115.68 65.98,115.05 65.98,114.79 64.97,113.78 64.97,113.5 64.38,112.91 64.38,112 64.74,111.64 64.74,110.88 64.97,110.65 64.97,110.35 65.6,109.71 65.73,109.71 65.98,109.46 65.98,107.17 65.35,106.54 64.71,106.54 64.33,106.16 61.41,106.16 60.39,107.17 60.39,107.94 59.51,108.83 58.74,108.83 58.62,108.7 58.62,108.19 59.12,107.68 59.12,106.79 59.51,106.41 59.51,106.03 59.12,105.65 57.98,105.65 ; 2 cut-outs
+V_1P35_VGA on BOTTOM: 79.7,83.04 79.44,83.3 79.44,83.43 78.57,84.3 77.17,84.3 76.05,85.42 76.05,85.8 74.24,87.62 73.35,87.62 72.97,87.24 72.61,87.24 72.48,87.36 72.48,87.64 73.64,88.8 75.72,88.8 76.07,88.45 76.07,87.29 76.73,86.63 76.73,86.04 76.85,85.91 79.75,85.91 80.08,85.58 80.84,85.58 81.22,85.2 81.22,83.17 81.1,83.04
+V_1P35_VGA on BOTTOM: outline of 251 points within 44.52,73.52 92.27,131.94 ; 66 cut-outs
+V_1P35_VGA on BOTTOM: 65.73,87.24 64.84,88.12 63.44,88.12 63.32,88 62.55,88 62.43,88.12 62.43,88.76 62.68,89.01 63.44,89.01 63.95,89.52 63.95,91.17 65.98,93.2 67.25,93.2 67.76,92.7 67.76,91.43 65.98,89.65 65.98,89.01 66.36,88.63 66.62,88.63 66.87,88.89 66.87,89.39 67.13,89.65 67.76,89.65 68.01,89.39 68.01,87.24
+V_1P35_VGA on L4: 70.3,102.86 70.94,102.86 71.19,102.6 73.35,102.6 73.6,102.86 73.6,103.75 73.09,104.25 72.84,104.25 72.84,105.78 72.97,105.9 73.98,105.9 75.25,104.63 77.41,104.63 78.17,105.4 78.17,106.41 77.79,106.79 76.78,106.79 76.14,107.43 76.14,110.73 76.52,111.11 76.52,114.41 75.89,115.05 75.89,118.35 70.05,124.19 70.05,124.45 69.67,124.83 63.32,124.83 62.81,124.32 59.38,124.32 56.84,121.78 56.84,120 58.24,118.6 62.05,118.6 63.06,119.62 63.82,119.62 64.08,119.87 64.08,120.13 63.95,120.26 63.63,120.26 63.51,120.38 63.51,122.86 64.46,123.81 68.4,123.81 74.36,117.84 74.36,114.79 75.13,114.03 75.13,112.25 75.51,111.87 75.51,109.84 75,109.33 73.09,109.33 72.33,110.1 70.81,110.1 70.25,109.54 70.25,107.17 69.92,106.84 69.92,104.96 70.21,104.67 70.21,102.94
+V_3P3_VGA on BOTTOM: 97.43,90.41 97.35,90.49 97.35,92.95 97.73,93.33 100.91,93.33 101.03,93.2 101.03,92.32 100.91,92.19 99.26,92.19 99.13,92.06 99.13,90.79 98.75,90.41
+V_VGA_CORE on TOP: 84.02,105.54 83.78,105.78 82.75,105.78 82.73,105.76 78.03,105.76 76.82,106.96 76.82,108.53 76.78,108.57 76.72,108.57 76.21,109.08 76.21,115.44 76.34,115.57 86.5,115.57 86.88,115.19 86.88,107.95 84.47,105.54
+V_VGA_CORE on TOP: 106.88,109.71 105.35,111.24 104.08,111.24 102.81,112.51 102.81,114.16 103.19,114.54 104.59,114.54 104.97,114.92 104.97,116.45 104.72,116.7 103.83,116.7 102.69,117.84 102.69,118.99 103.57,119.87 105.35,119.87 105.73,120.26 105.73,123.43 106.5,124.19 117.16,124.19 120.85,120.51 120.85,116.95 121.74,116.06 121.74,111.62 119.83,109.71
+V_VGA_CORE on BOTTOM: 79.19,105.9 78.3,106.79 78.3,108.44 77.41,109.33 77.41,110.98 77.92,111.49 77.92,114.54 77.67,114.79 76.52,114.79 76.14,115.18 76.14,115.43 76.52,115.81 80.71,115.81 81.1,115.43 81.1,109.46 81.86,108.7 81.86,108.06 81.1,107.3 81.1,106.29 80.71,105.9 ; 10 cut-outs
+V_VGA_CORE on BOTTOM: 107,109.59 105.48,111.11 105.48,112.25 106.24,113.02 106.37,113.02 106.37,113.14 110.05,116.83 121.48,116.83 122.37,115.94 122.37,111.62 120.34,109.59
+V_VGA_CORE on BOTTOM: 83.03,106.22 82.9,106.35 82.9,107.67 82.88,107.69 82.88,107.82 83.13,108.06 83.13,110.6 83.38,110.86 83.38,112.25 82.87,112.76 82.24,112.76 81.98,113.02 81.98,113.52 82.49,114.03 85.03,114.03 85.16,113.91 85.67,113.91 86.05,114.29 86.05,114.54 85.29,115.3 83.76,115.3 83.38,114.92 82.11,114.92 82.11,115.57 82.24,115.7 85.23,115.7 85.28,115.75 85.28,116.31 85.61,116.64 86.96,116.64 87.52,116.08 87.52,115.44 87.77,115.19 87.77,114.56 87.14,113.92 87.14,113.03 87.39,112.78 87.64,112.78 87.77,112.65 87.77,111.76 87.52,111.51 86.16,111.51 85.96,111.31 85.96,108.97 86.3,108.63 86.3,108.44 86.15,108.3 85.65,108.3 85.1,108.84 84.47,108.84 84.22,108.59 84.22,106.4 84.04,106.22 ; 13 cut-outs
+V_VGA_CORE on L3: 88.08,115.91 76.37,115.91 76.14,115.68 76.14,115.05 76.4,114.79 76.4,114.54 76.65,114.29 76.65,108.29 79.19,105.75 90.49,105.75 92.93,108.19 94.05,108.19 96.08,110.22 106.24,110.22 106.75,109.71 119.83,109.71 121.74,111.62 121.74,116.06 120.97,116.83 120.97,119.62 118.69,121.91 94.07,121.91
+V_VGA_CORE on L4: 106.24,110.22 103.96,110.22 103.57,110.6 103.57,111.62 103.32,111.87 101.16,111.87 99.51,110.22 96.34,110.22 93.16,107.05 77.54,107.05 76.78,107.81 76.78,114.54 76.14,115.18 76.14,115.68 76.52,116.06 88.21,116.06 94.43,122.29 118.56,122.29 120.85,120 120.85,116.95 121.74,116.06 121.74,111.62 119.83,109.71 106.75,109.71
AD_JK on TOP: 81.22,20.94 80.97,21.2 80.97,22.08 80.46,22.59 75.63,22.59 73.48,24.75 73.48,30.34 74.36,31.23 83.38,31.23 83.51,31.1 83.51,26.78 83.25,26.53 83.25,21.45 82.75,20.94 ; 4 cut-outs
AD_JK on BOTTOM: 75.63,22.59 73.48,24.75 73.48,31.61 75.25,33.39 84.65,33.39 85.16,32.88 85.16,26.28 84.78,25.89 83.64,25.89 80.33,22.59 ; 4 cut-outs
AD_JK on L3: 73.6,24.75 73.6,29.7 74.11,30.21 76.65,30.21 77.92,28.94 82.37,28.94 83.38,27.93 83.38,23.48 82.37,22.47 75.89,22.47
AD_JK on L4: 74.49,22.59 80.71,22.59 83.25,25.13 83.25,28.18 82.49,28.94 78.17,28.94 76.9,30.21 74.11,30.21 73.6,29.7 73.6,23.48
CAGND on TOP: 14.67,13.7 14.29,14.08 14.29,16.62 14.17,16.75 12.26,16.75 12.13,16.62 10.86,16.62 10.61,16.88 10.61,17.26 11.75,18.4 13.91,18.4 14.8,17.51 15.82,17.51 16.58,16.75 16.58,13.83 16.45,13.7 ; 2 cut-outs
DC_19V on TOP: 80.33,33.77 79.95,34.15 79.95,41.26 80.71,42.02 80.71,43.09 80.79,43.17 84.91,43.17 85.29,42.79 85.29,33.9 85.16,33.77 ; 2 cut-outs
DC_19V on BOTTOM: 80.33,33.77 79.95,34.15 79.95,41.26 80.59,41.9 84.65,41.9 85.29,41.26 85.29,33.9 85.16,33.77 ; 2 cut-outs
DCBATOUT on TOP: 37.79,108.7 37.53,108.95 37.53,111.37 38.04,111.87 39.31,111.87 39.36,111.82 39.36,109.51 39.06,109.21 38.55,109.21 38.3,108.95 38.3,108.83 38.17,108.7 ; 3 cut-outs
DCBATOUT on TOP: 2.86,9.77 2.61,10.02 2.61,14.21 2.86,14.46 5.66,14.46 5.91,14.21 5.91,13.32 6.29,12.94 6.93,12.94 7.18,12.69 7.18,9.89 7.05,9.77 ; 1 cut-out
DCBATOUT on TOP: 132.4,103.62 132.02,104 132.02,107.81 132.28,108.06 149.93,108.06 152.34,110.48 160.6,110.48 160.85,110.22 160.85,107.81 159.84,106.79 154.88,106.79 151.71,103.62
DCBATOUT on TOP: outline of 180 points within 1.92,41.9 138.12,267.58 ; 14 cut-outs
DCBATOUT on BOTTOM: 132.53,103.49 131.9,104.13 131.9,107.94 132.53,108.57 133.42,108.57 134.31,107.68 134.31,103.75 134.05,103.49 ; 1 cut-out
DCBATOUT on BOTTOM: 31.82,92.44 30.93,93.33 30.93,99.43 33.22,101.71 33.22,108.44 35.12,110.35 35.88,110.35 37.1,111.57 39.16,111.57 39.57,111.16 39.57,108.32 38.8,107.56 37.03,107.56 35.5,106.03 35.5,98.79 34.84,98.13 34.21,98.13 33.85,97.78 33.85,92.82 33.47,92.44
DCBATOUT on BOTTOM: 108.4,85.97 106.88,87.49 106.88,94.86 107.64,95.62 107.64,99.94 107.77,100.06 112.21,100.06 112.27,100 113.16,100 113.99,99.17 113.99,88.76 112.97,87.74 112.97,86.47 112.46,85.97 ; 2 cut-outs
DCBATOUT on BOTTOM: 152.98,18.66 152.6,19.04 152.6,19.8 152.85,20.05 155.52,20.05 156.53,21.07 156.53,30.47 161.87,35.8 163.39,35.8 163.77,35.42 163.77,34.15 163.52,33.9 162.12,33.9 158.06,29.83 158.06,20.56 156.15,18.66 ; 1 cut-out
DCBATOUT on BOTTOM: 108.53,17.51 108.15,17.89 108.15,18.66 108.02,18.78 107.51,18.78 106.75,19.54 106.75,20.81 107.26,21.32 108.02,21.32 109.67,19.67 109.67,17.89 109.29,17.51 ; 2 cut-outs
DCBATOUT on BOTTOM: 12.52,141.72 11.88,142.35 11.88,148.58 8.71,151.75 2.48,151.75 1.97,152.26 1.97,248.02 2.48,248.53 5.78,248.53 6.17,248.14 6.17,234.68 4.9,233.41 4.9,164.32 6.42,162.8 6.42,161.91 6.55,161.78 6.93,161.78 16.2,152.51 16.2,142.23 15.69,141.72 ; 5 cut-outs
DCBATOUT on L3: 6.45,113.65 7.43,114.43 6.43,115.17 6.42,115.18 4.26,115.18 4.13,115.3 4.13,118.48 7.05,121.4 11.75,121.4 12.01,121.65 12.01,130.54 11.75,130.8 10.23,130.8 9.09,131.94 9.09,138.29 11.5,140.7 15.82,140.7 16.07,140.45 16.07,118.1 14.67,116.7 14.67,71.61 20.64,65.65 20.64,58.91 21.79,57.77 78.3,57.77 83.76,63.23 83.76,70.15 90.56,76.95 96.05,76.95 97.07,77.96 103.83,77.96 106.18,80.31 109.73,80.31 110.05,80 110.05,78.22 105.86,74.03 96.59,74.03 89.73,67.17 89.73,62.72 87.45,60.44 86.18,60.44 78.94,53.2 62.93,53.2 62.43,52.69 58.49,52.69 57.6,53.58 45.41,53.58 44.14,54.85 31.57,54.85 30.3,53.58 20.64,53.58 20.14,53.07 15.94,53.07 13.91,55.1 13.91,64.12 12.32,65.71 5.47,65.71 1.97,69.2 1.97,103.24 4.13,105.4 4.13,113.52 4.26,113.65 ; 3 cut-outs
DCBATOUT on L3: 130.5,96 130.5,90.77 125.24,85.51 109.37,85.51 107.13,87.74 107.13,93.33 107.77,93.97 111.58,93.97 114.75,90.79 117.54,90.79 122.37,95.62 122.37,101.21 129.36,108.19 149.42,108.19 151.71,110.48 160.47,110.48 160.85,110.1 160.85,107.81 159.84,106.79 154.88,106.79 151.71,103.62 138.12,103.62
DCBATOUT on L4: 14.55,61.07 15.56,62.09 17.85,62.09 18.48,61.45 18.48,34.02 18.74,33.77 18.74,20.31 12.64,14.21 6.29,14.21 4.39,12.31 2.99,12.31 2.36,12.94 2.36,14.59 8.71,20.94 12.13,20.94 14.55,23.35
DCBATOUT on L4: 124.28,95.11 124.28,89.39 122.12,87.24 118.94,87.24 117.42,85.71 114.12,85.71 113.61,85.2 113.61,81.9 109.42,77.71 106.11,77.71 104.84,78.98 104.84,81.52 107.13,83.81 107.13,93.59 107.51,93.97 111.7,93.97 115.51,90.16 116.78,90.16 117.29,90.66 119.2,90.66 123.01,94.47 123.01,95.62 122.37,96.25 122.37,99.68 122.62,99.94 124.02,99.94 124.15,99.81 124.15,95.24
DCBATOUT on L4: 5.4,102.73 4.51,103.62 4.51,116.57 9.34,121.4 11.75,121.4 12.01,121.65 12.01,131.3 11.63,131.69 7.31,131.69 6.29,132.7 6.29,141.73 9.29,142.8 10.62,145.69 9.21,149.46 5.26,150.25 2.04,153.47 2.04,247.95 16.96,262.88 41.6,262.88 43.63,260.84 47.57,260.84 54.3,267.58 132.02,267.58 138.25,261.35 138.25,254.88 137.61,254.24 135.83,254.24 133.04,257.03 124.4,257.03 123.26,258.18 123.26,259.96 123.39,260.08 123.39,264.53 122.75,265.16 60.78,265.16 53.54,257.92 41.85,257.92 40.71,259.07 19.63,259.07 5.53,244.97 5.53,241.03 5.02,240.52 5.02,186.04 5.53,185.53 5.53,164.07 16.71,152.89 16.71,150.23 16.33,149.85 16.33,138.67 17.85,137.15 17.85,105.52 15.06,102.73 ; 4 cut-outs
DCBATOUT_1D35V_VGA on TOP: 43.25,101.46 43.12,101.59 43.12,102.48 42.87,102.73 42.61,102.73 42.49,102.86 42.49,105.4 42.64,105.55 43.02,105.55 43.12,105.65 43.12,106.72 43.07,106.77 41.62,106.77 40.96,107.43 40.96,109.59 40.58,109.97 40.23,109.97 40.02,110.17 40.02,112.1 39.44,112.69 39.44,113.47 39.74,113.78 41.73,113.78 42.36,113.14 42.36,107.68 42.87,107.17 43.25,107.17 43.4,107.02 43.4,105.65 43.48,105.57 44.09,105.57 44.14,105.52 44.14,101.59 44.01,101.46 ; 3 cut-outs
DDR_VREF_PWR on BOTTOM: 171.39,215.76 171.27,215.89 171.27,216.14 171.9,216.78 171.9,217.16 171.77,217.28 170.88,217.28 170.38,216.78 169.36,216.78 169.36,217.79 170.25,218.68 175.84,218.68 176.35,219.19 178.63,219.19 179.52,218.3 179.52,216.27 173.3,216.27 172.79,215.76
GPU_1D05V on TOP: 94.05,124.83 93.54,125.34 93.54,128.51 94.43,129.4 103.57,129.4 103.83,129.15 103.83,126.22 103.07,125.46 102.3,125.46 101.67,126.1 95.57,126.1 95.32,125.84 95.32,125.21 94.94,124.83 ; 4 cut-outs
GPU_3D3V_S0_THERM_2 on TOP: 94.3,83.17 94.05,83.43 93.41,83.43 93.29,83.55 93.29,86.98 92.65,87.62 92.65,88.76 92.78,88.89 93.67,88.89 94.05,88.51 94.05,84.44 94.18,84.31 94.68,84.31 95.19,83.81 95.19,83.43 94.94,83.17 ; 1 cut-out
ISW_1 on BOTTOM: 11.63,5.7 11.37,5.96 11.37,7.1 10.61,7.86 5.28,7.86 5.02,8.11 5.02,10.4 5.28,10.65 6.17,10.65 7.31,9.51 10.74,9.51 11.12,9.13 13.15,9.13 13.15,5.83 13.02,5.7
LX on TOP: 15.94,5.45 15.94,12.69 16.45,13.19 19.37,13.19 19.75,12.81 19.75,9.89 20.64,9 20.64,5.83 20.26,5.45
LX on BOTTOM: 16.07,5.32 15.69,5.7 15.69,10.02 15.89,10.22 18.15,10.22 18.18,10.2 18.18,9.82 18.8,9.19 18.81,9.19 18.95,9.05 20.74,9.05 21.05,8.75 23.82,8.75 24.07,8.5 24.07,5.7 23.95,5.57 23.06,5.57 22.8,5.32
MCT_R on TOP: 79.88,3.59 79.75,3.72 79.75,6.01 79.49,6.26 77.84,6.26 77.59,6.01 77.59,4.1 77.34,3.85 76.95,3.85 76.83,3.97 76.83,5.88 76.32,6.39 75.05,6.39 74.54,5.88 74.54,4.1 74.41,3.97 73.91,3.97 73.78,4.1 73.78,6.01 73.4,6.39 72,6.39 71.62,6.01 71.62,3.97 71.49,3.85 70.86,3.85 70.73,3.97 70.73,6.01 70.86,6.13 70.86,6.77 71.06,6.97 80.21,6.97 83.76,10.53 83.76,15.48 84.14,15.86 86.18,15.86 86.61,15.43 86.61,8.42 81.78,3.59 ; 2 cut-outs
MCT_R_1 on TOP: 86.99,10.7 86.86,10.83 86.86,12.74 87.11,12.99 88,12.99 88.13,12.86 88.13,10.83 88,10.7 ; 1 cut-out
MCT_R_1 on BOTTOM: 86.99,10.7 86.86,10.83 86.86,12.86 85.97,13.75 83.81,13.75 83.69,13.88 83.69,15.66 83.94,15.91 87.11,15.91 88.38,14.64 88.38,11.09 88,10.7
P1P2V on BOTTOM: 37.79,31.99 36.65,33.13 33.34,33.13 33.09,33.39 32.45,33.39 31.95,32.88 28.01,32.88 27.88,33.01 27.88,34.78 28.39,35.29 28.9,35.29 29.91,34.28 31.95,34.28 32.45,34.78 36.9,34.78 38.04,35.93 40.84,35.93 40.96,35.8 40.96,32.37 40.58,31.99 ; 3 cut-outs
P3P3V on BOTTOM: 33.09,35.17 32.84,35.42 32.84,36.56 32.58,36.82 30.68,36.82 30.55,36.94 30.55,38.59 30.42,38.72 30.17,38.72 29.91,38.98 29.91,39.61 30.04,39.74 35.5,39.74 35.63,39.61 37.41,39.61 37.66,39.36 37.66,37.2 35.63,35.17 ; 6 cut-outs
PEX_PLLVDD_GPU on BOTTOM: 78.81,116.93 76.78,118.96 76.78,119.21 76.9,119.34 76.9,120.48 76.64,120.75 76.03,120.75 75.63,121.14 75.63,122.41 75.25,122.8 75.25,124.57 74.87,124.95 74.87,125.72 75,125.84 75.89,125.84 76.02,125.72 76.02,124.95 76.27,124.7 76.65,124.7 77.03,124.32 77.03,122.54 77.41,122.16 78.17,122.16 78.56,121.78 78.56,121.14 78.3,120.89 78.05,120.89 77.67,120.51 77.67,118.99 77.65,118.97 78.94,117.69 80.59,117.69 80.97,117.31 80.97,117.18 80.71,116.93 ; 1 cut-out
PWR_1D0V on TOP: 162.63,90.03 162.5,90.16 162.5,97.4 162.25,97.65 155.01,97.65 154.76,97.9 154.76,104.63 156.03,105.9 160.09,105.9 161.23,107.05 171.01,107.05 171.9,106.16 171.9,97.27 171.01,96.38 171.01,92.7 170.12,91.81 167.2,91.81 165.42,90.03 ; 2 cut-outs
PWR_1D0V_PHASE on TOP: 161.74,110.86 161.11,111.49 161.11,117.21 161.61,117.72 165.17,117.72 165.17,116.19 165.42,115.94 167.58,115.94 167.84,116.19 167.84,121.37 167.99,121.53 173.55,121.53 174.06,121.02 174.06,111.87 173.04,110.86
PWR_1D0V_PHASE on BOTTOM: 161.74,110.86 161.11,111.49 161.11,117.21 161.61,117.72 167.07,117.72 167.46,118.1 167.46,120.89 168.09,121.53 173.55,121.53 174.06,121.02 174.06,111.75 173.17,110.86 ; 2 cut-outs
PWR_1D35V on TOP: 125.04,209.03 123.13,210.93 123.13,222.36 125.16,224.4 128.09,224.4 128.47,224.78 128.47,226.05 135.07,226.05 137.1,224.01 137.1,210.68 135.45,209.03 ; 1 cut-out
PWR_1D35V on BOTTOM: 121.99,205.09 121.48,205.6 121.48,223 123.26,224.78 136.21,224.78 138.12,222.87 138.12,206.11 137.1,205.09
PWR_1D35V_VGA on TOP: 41.34,84.06 41.09,84.31 41.09,91.81 39.82,93.08 39.82,94.47 40.58,95.24 45.54,95.24 46.81,93.97 46.81,91.71 46.56,91.46 46.56,91.22 46.55,91.21 46.55,84.87 46.56,84.87 46.56,84.45 46.17,84.06 ; 12 cut-outs
PWR_3D3V on TOP: 47.95,74.66 47.06,75.55 47.06,82.03 47.44,82.41 50.49,82.41 53.66,79.23 55.44,79.23 56.46,80.25 57.09,80.25 57.73,80.89 59.25,80.89 59.51,81.14 60.39,81.14 60.52,81.01 60.52,74.92 60.27,74.66 ; 2 cut-outs
PWR_3D3V_HG2R on TOP: 40.25,82.61 40.2,82.66 40.2,83.43 40.58,83.81 41.98,83.81 42.23,83.55 42.23,83.04 41.8,82.61
PWR_3D3V_HG2R on BOTTOM: 39.95,82.54 39.82,82.66 39.82,83.81 39.95,83.93 41.98,83.93 41.99,83.92 42.84,83.92 42.84,83.91 43.1,83.65 43.1,82.76 42.87,82.54
PWR_3D3V_LGATE2 on TOP: 37.15,75.04 36.9,75.3 36.9,76.57 37.92,76.57 37.92,75.3 37.66,75.04
PWR_3D3V_PHASE2 on TOP: 38.42,75.55 38.42,78.98 38.93,79.49 39.82,79.49 40.2,79.87 40.2,82.23 44.19,82.23 44.65,81.77 44.65,76.95 43.25,75.55
PWR_5V on TOP: 70.43,54.6 62.55,62.47 57.09,62.47 55.57,63.99 55.57,73.27 56.2,73.9 61.16,73.9 61.54,73.52 61.54,69.46 63.57,67.42 72.97,67.42 74.75,65.65 74.75,62.09 74.36,61.71 74.36,54.72 74.24,54.6 ; 2 cut-outs
PWR_5V on BOTTOM: 71.19,54.85 69.16,56.88 68.01,56.88 61.92,62.98 61.87,62.98 61.61,63.23 56.33,63.23 55.57,63.99 55.57,73.27 56.2,73.9 61.03,73.9 61.54,73.39 61.54,69.46 63.57,67.42 72.97,67.42 74.62,65.77 74.62,55.36 74.11,54.85
PWR_5V_LGATE1 on TOP: 40.71,68.31 40.33,68.69 40.33,70.09 41.78,70.09 41.8,70.06 41.8,68.64 41.47,68.31
PWR_5V_LGATE1 on TOP: 41.47,68.31 40.71,68.31 40.33,68.69 40.33,70.09 41.78,70.09 41.8,70.06 41.8,68.64
PWR_5V_PHASE1 on TOP: 47.57,66.03 47.69,66.15 47.69,68.44 47.31,68.82 42.11,68.82 42.11,74.41 50.11,74.41 52.39,72.12 52.39,65.52 49.09,62.22 45.79,62.22 45.66,62.34 45.66,66.03
PWR_5V_PHASE1 on BOTTOM: 30.04,72.76 30.42,72.38 30.42,70.85 30.55,70.73 31.31,70.73 31.44,70.85 31.44,72.63 30.68,73.39 30.3,73.39 30.04,73.14
PWR_5V_UGATE1 on BOTTOM: 28.9,73.01 28.9,71.49 29.03,71.36 29.53,71.36 29.66,71.49 29.66,73.01 29.41,73.27 29.15,73.27
PWR_5V_UGATE1_G on TOP: 45.74,66.53 45.71,66.56 45.71,67.98 46.04,68.31 46.81,68.31 47.19,67.93 47.19,66.53
PWR_12V on BOTTOM: 5.91,128 5.66,128.26 5.66,131.69 7.05,133.08 7.05,137.78 8.32,139.05 9.72,139.05 10.48,138.29 10.48,130.54 10.74,130.29 10.74,128.26 10.48,128
PWR_12V_DCBATOUT on TOP: 6.42,106.23 6.29,106.36 6.29,110.68 6.42,110.81 7.56,110.81 9.72,108.65 9.72,106.51 9.44,106.23
PWR_12V_DCBATOUT on BOTTOM: 5.91,109.59 4.9,110.6 4.9,110.86 5.66,111.62 5.91,111.62 6.42,111.11 8.58,111.11 8.96,110.73 8.96,109.97 8.58,109.59
PWR_12V_DCBATOUT on BOTTOM: 12.01,118.48 11.88,118.6 11.88,120.26 11.63,120.51 10.74,120.51 10.61,120.64 10.61,121.53 10.86,121.78 12.64,121.78 13.15,121.27 13.15,118.6 13.02,118.48
PWR_12V_SW on BOTTOM: 13.79,118.1 13.28,118.6 13.28,121.53 12.9,121.91 6.29,121.91 5.78,122.41 5.78,125.21 6.04,125.46 11.37,125.46 13.02,127.11 15.18,127.11 15.94,127.88 17.85,127.88 18.48,127.24 18.48,119.37 17.21,118.1 ; 2 cut-outs
PWR_81203_VCC on BOTTOM: 41.98,249.67 41.98,250.68 42.74,251.45 42.74,254.62 42.36,255 42.36,255.89 42.11,256.15 42.11,257.8 44.65,257.8 45.15,257.29 45.15,254.62 45.03,254.49 44.39,254.49 43.88,253.99 43.88,251.32 42.23,249.67 ; 2 cut-outs
PWR_DCBATOUT_1D0V on TOP: 152.85,110.98 152.72,111.11 152.72,114.54 152.98,114.79 155.9,114.79 156.41,115.3 156.41,120.51 157.17,121.27 159.71,121.27 161.11,122.67 161.11,125.21 162.12,126.22 165.42,126.22 166.06,125.59 166.06,124.07 166.44,123.68 167.2,123.68 167.33,123.56 167.33,118.22 167.07,117.97 161.23,117.97 160.72,117.46 160.72,111.11 160.6,110.98
PWR_DCBATOUT_1D0V on BOTTOM: 161.11,123.68 161.11,125.21 161.99,126.1 165.55,126.1 166.06,125.59 166.06,124.32 165.42,123.68
PWR_DCBATOUT_3V on TOP: 33.09,79.36 32.71,79.74 28.01,79.74 27.5,80.25 23.06,80.25 22.29,81.01 22.29,85.33 22.93,85.97 29.03,85.97 30.8,84.19 38.58,84.19 38.88,83.88 39.36,83.88 39.69,83.55 39.69,80.12 39.31,79.74 36.39,79.74 36.01,79.36 ; 2 cut-outs
PWR_DCBATOUT_3V on BOTTOM: 33.6,79.23 33.34,79.49 33.34,82.03 33.47,82.16 36.65,82.16 36.9,81.9 36.9,80.25 35.88,79.23
PWR_DCBATOUT_5V on TOP: 36.14,62.22 33.85,64.5 29.79,64.5 26.87,67.42 26.87,72 27.37,72.5 28.26,72.5 31.95,68.82 34.99,68.82 36.01,67.8 45.41,67.8 45.41,62.22 ; 2 cut-outs
PWR_DCBATOUT_VCC on TOP: 13.66,193.28 13.02,193.92 8.07,193.92 7.69,194.3 7.05,194.3 6.93,194.42 6.93,199.88 7.31,200.27 10.86,200.27 11.5,199.63 13.4,199.63 15.18,201.41 22.04,201.41 22.29,201.15 22.29,195.57 21.91,195.19 17.98,195.19 16.07,193.28
PWR_DCBATOUT_VCC on BOTTOM: 8.96,193.28 7.94,194.3 7.05,194.3 6.93,194.42 6.93,199.88 7.31,200.27 10.86,200.27 11.5,199.63 13.4,199.63 15.18,201.41 22.04,201.41 22.29,201.15 22.29,195.57 14.8,195.57 12.52,193.28
PWR_DCBATOUT_VCC2 on TOP: 7.31,212.08 7.05,212.33 7.05,217.66 7.31,217.92 22.04,217.92 22.29,217.66 22.29,212.08 13.53,212.08 12.77,212.84 9.21,212.84 8.45,212.08
PWR_DCBATOUT_VCC2 on BOTTOM: 7.31,212.08 7.05,212.33 7.05,217.66 7.31,217.92 22.04,217.92 22.29,217.66 22.29,212.08
PWR_DCBATOUT_VCC3 on TOP, BOTTOM: 7.05,227.44 7.05,232.9 7.56,233.41 10.86,233.41 11.5,232.78 15.44,232.78 16.07,233.41 22.29,233.41 22.29,227.82 21.91,227.44
PWR_DCBATOUT_VCCIO on TOP: 16.2,178.17 15.69,178.68 15.69,184.52 15.94,184.77 21.66,184.77 24.45,181.98 24.45,178.42 24.2,178.17
PWR_DCBATOUT_VCCSA on TOP: 21.53,145.02 21.53,150.61 22.68,151.75 22.68,157.85 22.93,158.1 28.52,158.1 28.77,157.85 28.77,150.48 27.5,149.21 27.5,145.27 27.25,145.02
PWR_DCBATOUT_VCCSA on BOTTOM: 25.34,148.2 24.96,148.58 24.96,151.88 25.34,152.26 28.52,152.26 28.77,152.01 28.77,148.45 28.52,148.2
PWR_DCBATOUT_VDDQ on TOP: 148.28,215.76 148.02,216.01 148.02,222.24 149.29,223.51 153.99,223.51 164.03,233.54 164.03,240.27 159.77,244.52 148.85,244.52 138.88,254.49 138.88,260.97 139.13,261.23 141.29,261.23 151.33,251.19 162.63,251.19 170.63,243.19 170.63,230.87 163.01,223.25 163.01,221.86 161.87,220.71 161.87,217.92 161.23,217.28 153.74,217.28 153.36,216.9 153.36,216.01 153.1,215.76 ; 4 cut-outs
PWR_DCBATOUT_VDDQ on BOTTOM: 152.72,217.54 151.07,219.19 151.07,221.22 151.83,221.98 158.57,221.98 159.07,221.47 159.07,218.05 158.57,217.54 ; 2 cut-outs
PWR_VCC_LX1 on TOP: 18.99,186.3 18.74,186.55 18.74,192.26 19.25,192.77 22.29,192.77 22.55,193.03 22.55,194.55 22.8,194.8 23.44,194.8 23.82,195.19 23.82,195.69 23.56,195.95 22.68,195.95 22.55,196.07 22.55,199.38 24.2,199.38 24.71,199.88 25.6,199.88 25.72,200.01 25.72,200.77 25.98,201.03 28.39,201.03 28.77,200.65 28.77,186.8 28.26,186.3 ; 1 cut-out
PWR_VCC_LX1 on BOTTOM: 18.99,186.3 18.74,186.55 18.74,193.66 18.87,193.79 19.75,193.79 20.77,192.77 23.95,192.77 24.33,193.15 24.33,197.09 24.07,197.34 22.55,197.34 22.55,200.77 22.8,201.03 28.39,201.03 28.77,200.65 28.77,186.8 28.26,186.3
PWR_VCC_LX1 on L4: 18.74,186.55 18.74,192.26 19.25,192.77 22.29,192.77 22.55,193.03 22.55,194.55 22.8,194.8 23.44,194.8 23.82,195.19 23.82,195.69 23.56,195.95 22.68,195.95 22.55,196.07 22.55,199.38 24.2,199.38 24.71,199.88 25.6,199.88 25.72,200.01 25.72,200.77 25.98,201.03 28.39,201.03 28.77,200.65 28.77,186.8 28.26,186.3 18.99,186.3
PWR_VCC_LX2 on TOP: 19.12,202.81 18.74,203.19 18.74,209.03 18.99,209.28 22.29,209.28 22.55,209.54 22.55,211.31 22.68,211.44 23.56,211.44 23.82,211.7 23.82,212.2 23.44,212.58 22.55,212.58 22.55,215.89 24.33,215.89 24.58,216.14 25.72,216.14 25.98,216.39 25.98,217.28 26.23,217.54 28.26,217.54 28.77,217.03 28.77,203.31 28.26,202.81 ; 2 cut-outs
PWR_VCC_LX2 on BOTTOM: 19.12,202.81 18.74,203.19 18.74,210.17 18.87,210.3 19.75,210.3 20.77,209.28 23.95,209.28 24.33,209.66 24.33,213.6 24.07,213.85 22.55,213.85 22.55,217.16 22.93,217.54 28.26,217.54 28.77,217.03 28.77,203.31 28.26,202.81
PWR_VCC_LX2 on L4: 18.74,203.19 18.74,209.03 18.99,209.28 22.29,209.28 22.55,209.54 22.55,211.31 22.68,211.44 23.56,211.44 23.82,211.7 23.82,212.2 23.44,212.58 22.55,212.58 22.55,215.89 24.33,215.89 24.58,216.14 25.72,216.14 25.98,216.39 25.98,217.28 26.23,217.54 28.26,217.54 28.77,217.03 28.77,203.31 28.26,202.81 19.12,202.81
PWR_VCC_LX3 on TOP: 18.99,218.68 18.74,218.93 18.74,224.52 19.12,224.9 22.17,224.9 22.55,225.28 22.55,227.06 22.68,227.19 23.44,227.19 23.82,227.57 23.82,227.95 23.44,228.33 22.55,228.33 22.55,231.63 24.2,231.63 24.45,231.89 25.72,231.89 25.98,232.14 25.98,233.54 26.23,233.79 28.01,233.79 28.77,233.03 28.77,219.19 28.26,218.68 ; 2 cut-outs
PWR_VCC_LX3 on BOTTOM: 18.99,218.68 18.74,218.93 18.74,224.52 19.12,224.9 22.17,224.9 22.55,225.28 22.55,226.94 22.8,227.19 23.56,227.19 24.33,227.95 24.33,229.35 24.07,229.6 22.55,229.6 22.55,233.16 23.18,233.79 28.01,233.79 28.77,233.03 28.77,219.19 28.26,218.68
PWR_VCC_LX3 on L4: 18.99,218.68 28.26,218.68 28.77,219.19 28.77,233.03 28.01,233.79 26.23,233.79 25.98,233.54 25.98,232.14 25.72,231.89 24.45,231.89 24.2,231.63 22.55,231.63 22.55,228.33 23.44,228.33 23.82,227.95 23.82,227.57 23.44,227.19 22.68,227.19 22.55,227.06 22.55,225.28 22.17,224.9 19.12,224.9 18.74,224.52 18.74,218.93
PWR_VCCIO on TOP: 32.58,174.23 31.95,174.87 31.95,183.88 32.26,184.2 42.04,184.2 44.14,182.1 44.14,181.47 44.77,180.83 44.77,174.87 44.14,174.23 ; 2 cut-outs
PWR_VCCIO on BOTTOM: 32.58,174.23 31.95,174.87 31.95,183.88 32.26,184.2 42.04,184.2 44.14,182.1 44.14,181.47 44.77,180.83 44.77,174.87 44.14,174.23
PWR_VCCIO_LGATE on TOP: 22.01,173.47 21.53,173.95 21.53,174.71 21.74,174.92 22.68,174.92 22.93,174.66 22.93,173.82 22.57,173.47
PWR_VCCIO_LGATE on TOP: 21.53,169.15 21.53,169.79 22.42,170.67 23.06,170.67 23.44,170.29 23.44,170.04 22.55,169.15
PWR_VCCIO_PHASE on TOP: 23.56,173.85 23.18,174.23 23.18,177.28 23.56,177.66 24.58,177.66 24.96,178.04 24.96,180.58 29.28,180.58 29.91,179.95 29.91,174.36 29.41,173.85
PWR_VCCIO_PHASE on BOTTOM: 23.56,173.85 23.18,174.23 23.18,177.41 23.44,177.66 24.58,177.66 24.96,178.04 24.96,180.58 29.28,180.58 29.91,179.95 29.91,174.36 29.41,173.85
PWR_VCCSA_PHASE on TOP, BOTTOM: 29.41,154.55 29.15,154.8 29.15,158.1 28.9,158.36 24.71,158.36 24.71,160.77 25.22,161.28 25.22,168.9 25.47,169.15 29.15,169.15 29.41,168.9 29.41,165.47 30.17,164.71 31.18,164.71 35.5,160.39 35.5,154.93 35.12,154.55
PWR_VDDQ_PHASE on TOP: 141.93,209.41 140.53,210.81 140.53,221.47 140.79,221.73 147.52,221.73 147.77,221.47 147.77,217.79 145.99,217.79 145.87,217.66 145.87,215.12 145.99,215 151.58,215 151.58,209.41
PWR_VDDQ_PHASE on BOTTOM: 141.93,209.41 140.53,210.81 140.53,221.47 140.79,221.73 147.39,221.73 147.77,221.35 147.77,218.05 148.41,217.41 148.79,217.41 148.91,217.28 148.91,215.25 149.17,215 151.58,215 151.58,209.41
PWR_VGA_CORE_PHASE1 on TOP: 116.4,96.38 116.15,96.63 116.15,98.41 115.51,99.05 114.37,99.05 114.12,99.3 114.12,99.43 113.23,100.32 109.67,100.32 109.54,100.44 109.54,104.63 113.35,108.44 121.35,108.44 122.5,107.3 122.5,97.14 121.74,96.38
PWR_VGA_CORE_PHASE1 on BOTTOM: 116.66,96.38 116.4,96.63 116.4,99.81 115.13,101.08 114.12,101.08 113.99,101.21 113.99,102.22 112.85,103.36 112.21,103.36 111.83,102.98 111.83,100.57 111.45,100.19 108.15,100.19 108.02,100.32 108.02,103.11 113.35,108.44 121.35,108.44 122.5,107.3 122.5,101.84 121.99,101.33 121.99,96.51 121.86,96.38 ; 1 cut-out
PWR_VGA_VRAM_LX on TOP: 41.34,96.63 39.82,98.16 37.79,98.16 37.28,98.67 37.28,99.94 37.71,100.37 41.04,100.37 41.62,100.95 44.01,100.95 44.39,101.33 44.39,105.4 44.52,105.52 44.9,105.52 45.15,105.78 45.15,106.54 45.79,107.17 45.79,109.08 45.92,109.21 46.93,109.21 47.06,109.08 47.06,105.4 46.42,104.76 45.79,104.76 45.41,104.38 45.41,97.27 44.77,96.63 ; 1 cut-out
PWR_VGT_DRVLA2 on TOP: 93.54,261.1 93.54,261.73 94.05,262.24 97.61,262.24 97.73,262.11 97.73,261.35 97.61,261.23 93.92,261.23 93.8,261.1
PWR_VGT_LX1A on TOP: 66.74,243.19 63.82,246.11 63.82,253.61 64.2,253.99 69.79,253.99 70.94,255.13 77.16,255.13 77.16,253.48 77.41,253.22 78.94,253.22 79.19,252.97 79.19,249.8 78.22,248.83 75.43,248.83 74.49,247.89 74.49,243.95 73.73,243.19
PWR_VGT_LX1A on BOTTOM: 66.74,243.19 63.82,246.11 63.82,253.61 64.2,253.99 72.84,253.99 73.48,253.35 75,253.35 75.13,253.48 75.13,255.13 78.43,255.13 78.43,253.61 79.19,252.84 79.19,249.8 78.05,248.65 75.25,248.65 74.49,247.89 74.49,243.95 73.73,243.19 ; 2 cut-outs
PWR_VGT_LX1A on L4: 74.49,243.95 74.49,247.89 75.25,248.65 78.05,248.65 79.19,249.8 79.19,252.97 78.94,253.22 77.54,253.22 77.16,253.61 77.16,255.13 70.94,255.13 69.79,253.99 64.2,253.99 63.82,253.61 63.82,246.11 66.74,243.19 73.73,243.19
PWR_VGT_LX2A on TOP: 97.1,250.43 96.21,251.32 96.21,260.46 96.46,260.72 102.18,260.72 102.43,260.46 102.43,258.69 102.81,258.3 104.59,258.3 104.97,257.92 104.97,255.76 105.23,255.51 105.73,255.51 105.99,255.76 105.99,256.78 109.29,256.78 109.29,251.07 108.65,250.43
PWR_VGT_LX2A on BOTTOM: 97.1,250.43 96.21,251.32 96.21,260.46 96.46,260.72 102.18,260.72 102.43,260.46 102.43,258.69 102.81,258.3 104.59,258.3 104.97,257.92 104.97,256.65 104.72,256.4 104.08,256.4 103.83,256.15 103.83,255.38 103.96,255.26 104.59,255.26 104.84,255 107.13,255 107.26,255.13 107.26,256.78 110.81,256.78 111.07,256.53 111.07,252.84 108.65,250.43 ; 2 cut-outs
PWR_VGT_LX2A on L4: 108.65,250.43 97.1,250.43 96.21,251.32 96.21,260.46 96.46,260.72 102.18,260.72 102.43,260.46 102.43,258.69 102.81,258.3 104.59,258.3 104.97,257.92 104.97,255.76 105.23,255.51 105.73,255.51 105.99,255.76 105.99,256.78 109.29,256.78 109.29,251.07
PWR_VGT_VIN on TOP: 80.71,253.86 79.19,255.38 73.22,255.38 72.97,255.64 72.97,260.72 73.35,261.1 76.78,261.1 77.03,261.35 77.03,262.75 77.29,263 78.38,263 78.76,262.62 86.4,262.62 86.4,262.6 86.68,262.32 86.68,260.34 84.02,257.67 84.02,254.24 83.64,253.86
PWR_VGT_VIN on BOTTOM: 73.22,255.38 72.97,255.64 72.97,260.72 73.35,261.1 76.78,261.1 77.03,261.35 77.03,262.75 77.29,263 86.3,263 86.68,262.62 86.68,260.34 84.02,257.67 84.02,255.76 83.64,255.38
PWR_VGT_VIN2 on TOP: 105.48,257.03 105.35,257.16 105.35,262.7 104.87,263.18 104.36,263.18 104.21,263.33 104.21,264.65 104.46,264.91 121.1,264.91 121.35,264.65 121.35,257.29 121.1,257.03
PWR_VGT_VIN2 on BOTTOM: 105.48,257.03 105.35,257.16 105.35,264.53 105.73,264.91 121.1,264.91 121.35,264.65 121.35,257.29 121.1,257.03
RING2_CON on TOP: 187.78,75.81 187.65,75.93 187.65,76.69 187.78,76.82 195.78,76.82 195.9,76.69 195.9,75.93 195.78,75.81 ; 4 cut-outs
SB3V on TOP: 102.43,68.31 102.18,68.57 102.18,69.2 103.19,70.22 105.23,70.22 106.11,69.33 106.11,68.82 105.86,68.57 104.08,68.57 103.83,68.31 ; 1 cut-out
SB3V on TOP: 52.39,22.85 52.01,23.23 52.01,24.37 53.92,26.28 55.44,26.28 55.44,25.01 55.95,24.5 55.95,23.74 55.82,23.61 54.17,23.61 53.92,23.86 53.79,23.86 53.66,23.74 53.66,23.1 53.41,22.85 ; 2 cut-outs
SB3V on TOP: 94.68,141.08 94.3,141.46 94.3,146.04 94.94,146.67 94.94,149.08 106.11,160.26 106.11,229.6 108.53,232.02 109.92,232.02 110.81,231.13 110.81,229.86 110.18,229.22 110.18,158.48 97.1,145.4 97.1,141.46 96.72,141.08 ; 2 cut-outs
SB3V on TOP: 145.36,232.02 145.1,232.27 145.1,233.67 144.72,234.05 144.72,236.21 145.1,236.59 146.25,236.59 146.75,236.08 146.75,232.27 146.5,232.02 ; 8 cut-outs
SB3V on BOTTOM: 111.91,52.95 111.85,53 111.85,53.94 111.32,54.47 111.32,54.85 111.45,54.98 111.96,54.98 111.98,54.95 112.67,54.95 112.77,54.85 112.77,54.16 112.62,54.01 112.62,53 112.57,52.95 ; 1 cut-out
SB3V on BOTTOM: 142.31,228.21 141.8,228.71 141.8,233.93 142.56,234.7 144.6,234.7 144.85,234.95 144.85,235.59 144.98,235.71 145.61,235.71 145.62,235.71 146.49,235.71 146.75,235.44 146.75,232.4 145.74,231.38 145.74,228.84 145.1,228.21
SB3V on BOTTOM: 64.97,45.83 63.19,47.6 59.5,49.17 59.44,49.2 58.21,50.43 58.21,58.28 57.19,59.3 54.35,59.3 53.1,58.05 32.94,58.05 20.77,70.22 20.77,81.77 27.12,88.12 27.12,101.71 26.49,102.35 26.49,104.51 28.14,106.16 30.93,106.16 31.06,106.03 31.06,102.28 28.9,100.13 28.9,87.62 22.04,80.76 22.04,71.23 32.84,60.44 51.61,60.44 52.25,61.09 59.85,61.09 62.48,58.46 62.48,52.01 63.19,51.29 63.57,51.29 64.46,50.41 65.86,49.64 66.49,49.64 67.38,48.75 67.51,48.75 68.01,48.25 68.4,48.25 69.69,49.54 70.68,49.54 71.49,50.35 72.33,50.35 72.41,50.28 72.79,50.28 72.84,50.23 72.84,49.49 72.51,49.16 72.51,47.18 72.18,46.85 70.68,46.85 69.67,45.83 ; 2 cut-outs
SB3V on L3: 32.71,103.11 37.66,103.11 40.2,105.65 40.33,105.65 40.71,106.03 40.71,107.94 42.87,110.1 44.52,110.1 47.19,112.76 47.19,121.78 52.39,126.99 60.78,126.99 61.16,127.37 61.16,129.27 60.27,130.16 48.33,130.16 41.85,123.68 41.85,116.83 32.2,107.17 30.93,107.17 28.39,104.63 28.39,102.98 28.9,102.48 32.07,102.48
SB3V on L4: 58.62,128.38 67.38,128.38 70.3,131.3 70.3,132.19 74.11,136 74.11,136.13 87.19,136.13 89.48,138.42 96.84,138.42 97.48,139.05 97.48,141.08 96.34,142.23 94.05,142.23 92.78,140.96 68.01,140.96 58.24,131.18 58.24,128.76
