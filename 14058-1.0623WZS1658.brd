# Allegro board 14058-1.0623WZS1658.brd (continued)
## Library data of the parts (continued)
PR4415 PR8318 R8 R12 R14 R32 R132 R1841 R1842 R79768 R79769 R80241 R80242 = R402H16: tolerance: 64.51R05.6DL
PR4416 PR4419 R258 R612 R613 R2082 R79776 R79982 R79993 R79995 R79997 R79999 R80000 = R402H16: tolerance: 64.49915.6DL
PR4417 PR4420 = R402H16: tolerance: 64.59015.6DL
PR4421 PR4422 PR4431-PR4433 = R402H14: tolerance: 63.10034.1DL
PR4423 PR4434 = R402H16: tolerance: 64.80625.6DL
PR4424 = R402H16: tolerance: 64.22125.6DL
PR4425 = R402H16: tolerance: 64.17435.6DL
PR4427 PR4429 PR4441-PR4443 PR4452 PR4454 = R402H16: tolerance: 64.40215.6DL
PR4435-PR4437 PR5470 = R402H16: tolerance: 64.12035.6DL
PR4438 = R402H16: tolerance: 64.21025.6DL
PR4440 = R402H16: tolerance: 64.18035.6DL
PR4448 R17 = R402H16: tolerance: 64.45R35.6DL
PR4449 = R402H16: tolerance: 64.75R05.6DL
PR4450 PR4455 R76 R78 R82 R84 R87 R89 R93 R95 R1163 R1762 R1766 R1775 R1777-R1779 R1793 R79700 R80228 = R402H16: tolerance: 64.10015.6DL
PR4451 PR4457 = R402H16: tolerance: 64.47R05.6DL
PR4453 PR4456 = R402H16: tolerance: 64.56035.6DL
PR4459 R406 R409 R79706 = R402H14: tolerance: 64.10R05.6DL
PR4460 R45 = R402H16: tolerance: 64.49R95.6DL
PR4462 = R402H16: tolerance: 64.36525.6DL
PR4468 PR8320 PR8339 R25 R28 R31 R41 R65 R126 R139 R140 R246 R247 R333 R342 R375 R425 R451-R454 R456 R465 R468 R505 R506 R513 R701 R702 R704 R706 R707 R710 R713 R716 R718 R721 R729 R758 R759 R1780 R1782 R1823 R1947 R1950 R1958 R1966-R1969 R1971 R1979 R6706 R79656-R79658 R79747 R79765 R79778 R79789 R79796 R79809 R79811 R79832 R79837 R79847 R79851 R79855 R79871 R79872 R79913 R79919 R79920 R79943 R79947 R80045 R80047 R80048 R80059 R80206 R80231 R80245 = R402H16: tolerance: 63.R0034.1DL
PR4474 = R402H16: tolerance: 64.52325.6DL
PR4477 PR8305 R438 = R402H16: tolerance: 64.20015.6DL
PR5270 = R603H22: tolerance: 64.31635.55L
PR5276 = R3720H40: tolerance: 64.R0105.7FL
PR5281 = R402H16: tolerance: 64.1R505.6DL
PR5284 = R805H24: tolerance: 64.20R05.16L
PR5288 = R402H16: tolerance: 63.33534.1DL
PR5306 = R402H16: tolerance: 64.88725.6DL
PR5467 = R402H16: tolerance: 64.10235.6DL
PR5468 = R402H16: tolerance: 64.53625.6DL
PR5469 R894 = R402H16: tolerance: 64.45325.6DL
PR8303 PR8309 R138 R146 R367 R80049 = R402H16: tolerance: 64.20025.6DL
PR8312 = R402H16: tolerance: 64.35725.6DL
PR8316 = R402H16: tolerance: 64.18025.6DL
PR8323 = R603H22: tolerance: 64.59015.55L
PR8326 = R402H16: tolerance: 64.82025.6DL
PR8334 R371 R372 = R402H16: tolerance: 64.47025.6DL
PR8616 = R402H16: tolerance: 64.2R205.6DL
PR8618 R304 R419 R473 R474 R6701 = R603H22: tolerance: 63.00000.00L
PR8625 PR8626 = R402H16: tolerance: 63.33234.1DL
PT1 PT7-PT9 PT15 PT16 PT22 PT25 PT28 PT35 = SE361414H241: tolerance: 79.47612.3GL
PT2-PT6 PT11-PT14 PT17 PT18 PT20 PT26 PT27 PT29 PT30 PT32 PT34 = ECAP-100D6D3H375: tolerance: 09.8271V.08L
PT23 PT24 = SE341619H241: tolerance: 79.22710.3DL
PU1-PU3 PU7 PU8 PU12 PU13 PU17 PU18 PU22 PU23 PU27 PU36 PU39 PU43 PU5203 = PPAK-8P-5262H40: tolerance: 84.06520.037
PU4 PU9 PU14 PU19 PU24 = DFN8G2-G1309-UH40: tolerance: 74.81151.073
PU5 PU6 PU10 PU11 PU15 PU16 PU20 PU21 PU25 PU26 PU29 PU30 PU38 PU41 PU42 PU45 PU46 PU5202 PU5204 = PPAK-8P-5262H40: tolerance: 084.06510.0037
PU28 = QFN16G3-G1D85-UH40: tolerance: 74.05230.073
PU31 PU34 = PPAK-8P-3232H36: tolerance: 84.07410.A37
PU32 PU44 = DFN10G3-G265175H32: tolerance: 74.08237.B73
PU33 PU37 = PPAK-8P-3232H36: tolerance: 84.07506.037
PU35 = QFN20-G1D75H32: tolerance: 074.08243.0073
PU40 = QFN20-G1D75H32: tolerance: 074.08207.0073
PU4401 = LFQFN52J6-G4D8H40: tolerance: 074.81203.0A73
PU5301 = SOIC8-G2D3H70: tolerance: 74.08289.041
PU5302 = SOIC8-G3530H63: tolerance: 74.05930.B3D
PU8602 = QFN23G4-G2PH34: tolerance: 074.08713.0043
PWRCN1 = 51530-01041-W01: tolerance: 20.K0642.010
Q1 Q4 = SOT23DGS2D4H48: tolerance: 84.05067.031
Q2 = SOT23CBE2D4H46: tolerance: 84.T3904.K11
Q3 Q8 Q1227 = SOT23DGS2D4H44: tolerance: 84.27002.Z31
Q5 Q59 = SOT23CBE2D4H44: tolerance: 84.T3906.A11
Q6 Q1233 Q9632 Q9633 = SOT-363H44: tolerance: 75.27002.D7C
Q13 Q23 Q9628 Q9629 = SOT-363H44: tolerance: 84.M3904.B1F
Q14 = SOT23DGS2D4H44: tolerance: 84.27002.W31
Q15-Q17 = SOT23-2D4-312H46: tolerance: 75.05125.07D
Q18 Q26 Q60-Q63 Q76 Q1260 Q1263 Q1265-Q1267 Q6704 Q9631 Q9634 Q9635 = SOT23CBE2D4H44: tolerance: 84.T3904.C11
Q29 = SOIC8H69: tolerance: 84.04468.A37
Q54 Q56 Q1264 Q9648 = SOT23DGS2D8H50: tolerance: 84.03413.B31
Q1234 = SOT23DGS2D8H50: tolerance: 84.03404.D31
Q1259 = SOIC8H69: tolerance: 084.04286.0037
Q7903 = SOT23DGS2D4H44: tolerance: 84.27002.N31
Q9601 Q9619 Q9624 = SOT23DGS2D8H50: tolerance: 84.03418.A31
Q9602 = SOT23CBE2D4H44: tolerance: 84.T3906.E11
R3 R4 R79 R90 = R402H16: tolerance: 64.2R005.6DL
R5 R63 R71 R80 R91 = R402H16: tolerance: 64.24R95.6DL
R6 R7 R9 R11 R13 R15 R80050-R80053 = 0R0402-PAD: tolerance: ZZ.R0402.ZZZ; signal model: 2pins
R16 = R402H16: tolerance: 64.56R25.6DL
R19 R178 R510 R1835 R9547 R79171 R79172 = R402H16: tolerance: 63.10534.1DL
R23 = R402H16: tolerance: 64.22005.6DL
R33 = R402H16: tolerance: 64.60415.6DL
R35 = R402H16: tolerance: 64.28015.6DL
R66 R79774 = R402H16: tolerance: 63.20034.1DL
R68 = R603H22: tolerance: 63.R0033.L0L
R72 = R402H16: tolerance: 64.20R05.6DL
R104 R105 = R402H16: tolerance: 64.49905.6DL
R106 R108 R111 R113 R145 R198 R294 R298 R376 R495 R609 R625 R626 R742 R746 R750 R754 = R402H16: tolerance: 63.33034.1DL
R107 R109 = R402H16: tolerance: 63.33034.1DL; signal model: 2pins
R117 R118 R435 R727 R1129 R79743 R79744 R79766 R79767 = R402H16: tolerance: 63.82234.1DL
R119 R135 R141 R147 R152 R205 R217 R218 R221 R222 R239 R318 R361 R391 R511 R535 R748 R753 R755 R760 R763 R1794 R1798 R1829 R1834 R1946 R5213 R5214 R9503 R9521 R9525 R9528 R9540 R9541 R9548 R79174 R79721 R79722 R79914 R80201 R80202 R80244 = R402H16: tolerance: 63.47234.1DL
R120 R744 R749 = R402H16: tolerance: 63.30234.1DL
R128 R229 R253 R254 R359 R397 R404 R405 R414 R415 R602 R603 R628 R1776 R2083 R2084 R79874 R79944 R79990 = R402H16: tolerance: 63.22234.1DL
R137 R492 = R402H16: tolerance: 63.15234.1DL
R159 = R402H16: tolerance: 64.27015.6DL
R180 = R603H22: tolerance: 64.10055.55L
R188 = R402H16: tolerance: 64.11305.6DL
R193 = R402H16: tolerance: 64.20005.6DL
R194 R241 R245 R80001 = R402H16: tolerance: 64.80R65.6DL
R195 R244 = R402H16: tolerance: 64.16205.6DL
R223 R224 R227 R228 R236 R293 R339 R364 R389 R390 R1797 R1833 R1840 R79861 R79934 = R402H16: tolerance: 63.20334.1DL
R235 R587 R620 R79998 R80020 R80028 R80034 R80040 = R402H16: tolerance: 64.24305.6DL
R250 R80239 = R402H16: tolerance: 64.17825.6DL
R255 = R402H16: tolerance: 64.64915.6DL
R266 R366 = R402H16: tolerance: 64.51015.6DL
R287 R1593 R1594 R1596 R1598 R2085-R2090 = R402H16: tolerance: 64.47015.6DL
R323 R79735 = R603H22: tolerance: 63.33133.15L
R327 = R402H16: tolerance: 63.20234.1DL
R347 R348 R351 R352 R355 = R402H16: tolerance: 63.15034.1DL
R362 = R402H16: tolerance: 64.82015.6DL
R369 = R402H16: tolerance: 64.68R05.6DL
R377 R79844-R79846 R79848 R79849 = R402H16: tolerance: 63.R0034.1DL; signal model: 2pins
R378 R598 = R402H16: tolerance: 63.33334.1DL
R380 = R603H22: tolerance: 63.10033.15L
R385 R386 = R603H22: tolerance: 64.10525.55L
R399 R80220 = R402H16: tolerance: 64.56015.6DL
R400-R403 = R603H22: tolerance: 64.3R305.55L
R408 R442 = R603H22: tolerance: 64.10045.55L
R421 R422 R5210 R5211 R9534 R9535 = R402H16: tolerance: 63.47034.1DL
R485 = R603H22: tolerance: 63.10333.15L
R486 = R603H22: tolerance: 64.56025.55L
R515 = R603H22: tolerance: 63.15234.15L
R604 R608 = R402H16: tolerance: 64.60R45.6DL
R611 = R402H16: tolerance: 64.40R25.6D1
R730 R1195 R79745 = R402H16: tolerance: 64.39225.6DL
R751 R752 R756 R757 R79930 = R603H22: tolerance: 64.75R05.55L
R925 = R402H16: tolerance: 64.47005.6DL
R1592 = R603H22: tolerance: 64.36R05.55L
R1769 = R402H16: tolerance: 64.15005.6DL
R1804 R1996 = R402H16: tolerance: 63.56134.1DL
R1807 R1983 R9502 R9504 R9506 R79734 = R402H16: tolerance: 63.22034.1DL
R1811 R1981 R1982 R79775 = R402H16: tolerance: 63.30034.1DL
R1839 = R402H16: tolerance: 64.15035.6DL
R1972 R1980 = R402H16: tolerance: 64.24905.6DL
R1985 R1986 = R1206H26: tolerance: 63.R0037.L0L
R2081 = R603H22: tolerance: 64.18005.55L
R5212 R5219 R7513 R7514 R7539 R7541 = R402H14: tolerance: 63.10134.1DL
R9501 = R402H16: tolerance: 63.56034.1DL
R9519 = R402H16: tolerance: 63.62234.1DL
R9531 R79840 = R402H16: tolerance: 64.62015.6DL
R9602 = R402H16: tolerance: 63.33434.1DL
R79697 R79716 = 0R1206-PAD-1: tolerance: ZZ.R1206.ZZ1
R79698 R79703 = R1206H26: tolerance: 64.R3305.41L
R79702 R79707 = R402H16: tolerance: 64.30035.6DL
R79710 = R805H24: tolerance: 63.20131.16L
R79739 = R402H16: tolerance: 64.43R25.6DL
R79742 R79978 = R402H16: tolerance: 64.24915.6DL
R79782 = R402: tolerance: 63.51034.1D1
R79788 = R402H16: tolerance: 64.49R95.6D1
R79829 = R402H16: tolerance: 63.51134.1DL
R79858 = R805H24: tolerance: 64.10025.16L
R79979 = R402H16: tolerance: 64.42R25.6DL
R80217 = R402H16: tolerance: 64.15015.6DL
R80218 = R402H16: tolerance: 63.18234.1DL
RJ1 = 23-01120-2A03-A: tolerance: 062.10032.0041
RN1 RN3 = ARES8-CN24-MUH20: tolerance: 66.10336.08L
RN2 = ARES8-CN24-UH20: tolerance: 66.33036.A8L
RN5 RN6 = ARES2H18: tolerance: 66.10336.04L
RN7501 RN7505 RN7506 = ARES8-CN24H20: tolerance: 66.10136.A8L
RN7502-RN7504 RN7507-RN7517 = SMD-ARES4H18: tolerance: 66.10136.04L
RN9503 = ARES8-CN24H20: tolerance: 66.47236.08L
RT1-RT3 = NTC-402H24-U: tolerance: 69.60013.161
RV5 = TVS5436-1121H105: tolerance: 069.A0007.0001
SATAP1 = CI2505P1H00-LF-U: tolerance: 021.60197.0105
SCA1 = TQFP128H63: tolerance: 071.02586.000G
SPK1 = A1501WV0-6PS-5E: tolerance: 21.D0278.106
SPR1 SPR2 = SPR10637H367: tolerance: 34.39S07.003
SRCON1 = G6179-1000000-U: tolerance: 62.10076.011
SSUSB1 SSUSB2 = SKT-USB11-138165-1: tolerance: 022.10005.0391
TC2 TC4 = ECAP-100D6D3H237: tolerance: 09.1071D.A5L
TC3 = CT3528H79: tolerance: 77.21071.07L
TC5 = ECAP-100D6D3H473: tolerance: 09.2271D.X8L
TC6 = CT7343H75: tolerance: 77.23371.13L
TOUCH2 = 3703K-Q05N-11L: tolerance: 020.F0146.0005
TP1-TP21 TP31-TP34 TP36 TP40-TP42 TP44 TP45 TP47 TP49 TP51-TP56 TP58 TP60-TP69 TP71 TP83 TP85 TP99 TP103-TP105 TP107-TP109 TP113-TP118 TP135-TP137 TP142 TP144 TP149-TP155 TP163-TP165 TP167 TP169 TP171 TP172 TP174-TP195 TP199-TP205 TP216 TP217 TP220-TP254 TP256-TP258 TP260-TP266 = TPAD28: tolerance: ZZ.PAD28.XXX
TP43 TP72 = TPAD24: tolerance: ZZ.PAD24.001
TR1-TR7 TR12 TR13 = L125100-4P-1H37: tolerance: 68.01012.201; signal model: 4pins1
TR16-TR19 = L125100-4P-1H28: tolerance: 68.10129.201; signal model: 4pins1
TR5201-TR5204 = L125100-4P-1H28: tolerance: 068.10129.2011; signal model: 4pins1
U1 = SOT-6-1H50: tolerance: 84.06402.B3D
U2 = BGA837M23-1H58: tolerance: 071.SUNRI.0A0U
U3 = SC70-5H44: tolerance: 73.01G08.DHG
U6 U33 = SOIC8H69: tolerance: 72.25106.001
U9 = QFN48J6-G465H40: tolerance: 71.03661.003
U10 = QFN32-G3D55H40: tolerance: 74.03131.013
U11 U9614 U9624 = SOT-6H58: tolerance: 75.01215.07C
U14 = QFN32J4-G2D9-U1H36: tolerance: 071.05250.0A03
U15 U16 U26 U28 U29 = DFN10G2510H26: tolerance: 75.01045.073
U17 U18 = SOIC8H69: tolerance: 84.04407.G37
U21 U22 = SON14J3020-G2610H34: tolerance: 74.22966.093
U55 = QFN20G3D5-G2D15H40: tolerance: 74.24727.A73
U109 = LQFP128H63: tolerance: 071.08739.000G
U118 = QFN40J5-G3D65H32: tolerance: 071.08407.0003; signal model: QFN40J5-G3D65H32_PS8407ATQFN40GTR2-A1-GP
U119 = SOT-89-4541H63: tolerance: 074.01117.0038
U120 = QFN20-G2D1H32: tolerance: 074.00554.0073
U171 U173 U175 U176 = SOT-363H44: tolerance: 75.27002.F7C
U5201 = SOIC8H69: tolerance: 72.02402.F01
U5202 U5203 = SOT-23-9H44: tolerance: 75.23C62.07D
U6701 = LGA16G3-1H40: tolerance: 074.01010.00B3
U9501 = SOIC8H69: tolerance: 72.25020.E01
U9502 = SOIC8H69: tolerance: 72.24C16.Y01
U9601 = SOT-223H71: tolerance: 74.D1117.G3C
U9615 = MSOP10H44: tolerance: 73.52364.009
U9619 = LFQFN24G4-G2D9H40: tolerance: 74.81172.073
U9621 = SC70-5H44: tolerance: 73.7SZ08.DAH
U9622 = SOIC8-1H86: tolerance: 72.25128.0E1
U9623 = QFN32J4-G2D9-U1H36: tolerance: 71.08111.U03
U9625 = QFN16-G1D8-UH32: tolerance: 74.02546.073; signal model: QFN16-G1D8-UH32_TPS2546RTER-GP
UHS1 = 2SJ3082-038111F: tolerance: 022.10002.0881
UR6 UR7 = R402H16: tolerance: 64.33005.6DL
USB1-USB4 = SKT-USB6-146072: tolerance: 22.10218.0A1
VRAM1-VRAM8 = BGA96D075130H48: tolerance: 72.51G63.H0U
WEBCM1 = A1251WR0-8PS-5E: tolerance: 20.F1245.008
X1 = OSC-3225-4P-3H36: tolerance: 82.30004.891
X2 = SMD49-6914-0403H56: tolerance: 82.30001.G11
X3 = OSC-3225-4P-4H36: tolerance: 82.30020.G71
X5 = OSC-3225-4P-4H30: tolerance: 82.30034.641
X9502 = OSC-3225-4P-3H36: tolerance: 82.30005.E21
XDPC1 = DM-BSH-03001-FDA-01: tolerance: ZZ.F0441.06001
XF3 = XFORM24Z151100H160: tolerance: 68.89240.30B

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
0R0402-PAD
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
0R0402-PAD-1
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
0R0603-PAD
  custom 0.216x0.216 smd: 1(0,0.851) 2(0,-0.673)
0R0805-PAD
  rect 1.397x1.562 smd: 1(0,0.965)
  rect 1.397x1.569 smd: 2(0,-0.965)
0R1206-PAD-1
  rect 1.651x2.057 smd: 1(0,1.397) 2(0,-1.397)
2DC3115-000111F
  oval 1.422x2.413 hole 0.711x1.702: 1(-1.1,1.46)
  oval 1.473x2.413 hole 0.762x1.702: 2(2.5,0) 5(4.375,0.7) 7(-4.375,0.7)
  oval 1.524x2.413 hole 0.813x1.702: 3(0,-1.13)
  oval 2.413x1.473 hole 1.702x0.762: 4(1.35,3.375) 6(1.35,-3.375)
2SJ3082-038111F
  round 0.254 hole 1.27 unplated: (0,0) (0,-6)
  oval 1.321x2.134 hole 0.61x1.422: 1(3.8,3.1) 2(-3.7,-4.5) 3(3.7,-6.8) 4(-2.7,-6.6) 5(-2.2,3.1) 6(-3.8,3.1) MS1(-4.6,-1.5) MS2(4.6,-2.5)
15-02070-5A61-A
  round 1.041 hole 0.762: 1(3.81,-0.25) 2(2.54,-0.25) 3(1.27,-0.25) 4(0,-0.25) 5(-1.27,-0.25) 6(-2.54,-0.25) 7(-3.81,-0.25)
  round 1.93 hole 1.524: 8(6.37,0) 9(-6.37,0)
23-01120-2A03-A
  rect 0.813x3.988 smd: 1(-4.445,13.3) 2(-3.175,13.3) 3(-1.905,13.3) 4(-0.635,13.3) 5(0.635,13.3) 6(1.905,13.3) 7(3.175,13.3) 8(4.445,13.3)
  round 1.321 hole 0.914: 9(-6.645,0) 10(-4.355,0) 11(4.355,0) 12(6.645,0)
  rect 8.992x3.404 smd: 13(0,-3.5)
156-2131302600
  round 0.254 hole 0.864 unplated: (-12.675,0) (12.675,0)
  rect 0.813x1.397 smd: 1(-6.75,0.42) 2(-5.35,0.42) 3(-3.95,0.42) 4(-2.55,0.42) 5(1.6,0.42) 6(4.4,0.42) 7(5.8,0.42) 8(7.2,0.42) 9(-8.15,0.42) CD(3,0.42) WP(8.6,0.42)
  rect 1.397x0.813 smd: 10(-14.03,-18.05) 11(-14.03,-19.15) 12(-14.03,-20.25) 13(-14.03,-21.35) 14(14.03,-21.35) 15(14.03,-20.25) 16(14.03,-19.15) 17(14.03,-18.05)
  rect 1.854x1.803 smd: GND1(-10.375,0.22)
  rect 1.499x1.803 smd: GND2(10.65,0.22)
  rect 1.803x1.499 smd: GND3(-13.55,-15.8) GND4(13.55,-15.8)
210-41-02GB01
  round 1.422 hole 1.016: 1(-1.27,0) 2(1.27,0)
3703K-Q05N-11L
  rect 0.61x1.549 smd: 1(-2,3.775) 2(-1,3.775) 3(0,3.775) 4(1,3.775) 5(2,3.775)
  rect 1.194x2.007 smd: 6(-3.3,0) 7(3.3,0)
50524-0300N-001
  rect 0.305x1.295 smd: 1(-14.5,5.65) 2(-13.5,5.65) 3(-12.5,5.65) 4(-11.5,5.65) 5(-10.5,5.65) 6(-9.5,5.65) 7(-8.5,5.65) 8(-7.5,5.65) 9(-6.5,5.65) 10(-5.5,5.65) 11(-4.5,5.65) 12(-3.5,5.65) 13(-2.5,5.65) 14(-1.5,5.65) 15(-0.5,5.65) 16(0.5,5.65) 17(1.5,5.65) 18(2.5,5.65) 19(3.5,5.65) 20(4.5,5.65) 21(5.5,5.65) 22(6.5,5.65) 23(7.5,5.65) 24(8.5,5.65) 25(9.5,5.65) 26(10.5,5.65) 27(11.5,5.65) 28(12.5,5.65) 29(13.5,5.65) 30(14.5,5.65)
  rect 1.803x2.21 smd: 31(-17.15,0) 32(17.15,0)
51530-01041-W01
  rect 0.305x0.838 smd: 1(-2.25,3.175) 2(-1.75,3.175) 3(-1.25,3.175) 4(-0.75,3.175) 5(-0.25,3.175) 6(0.25,3.175) 7(0.75,3.175) 8(1.25,3.175) 9(1.75,3.175) 10(2.25,3.175)
  rect 0.813x2.007 smd: 11(-3.95,0) 12(3.95,0)
88459-047N
  rect 0.508x0.991 smd: 1(1.2,1.455) 2(0.4,1.455) 3(-0.4,1.455) 4(-1.2,1.455)
  rect 1.194x1.702 smd: 5(2.5,0) 6(-2.5,0)
2199230-7
  round 0.254 hole 1.6 unplated: (-10,0)
  round 0.254 hole 1.118 unplated: (10,0)
  rect 0.305x1.854 smd: 1(9.25,-5.423) 2(9,2.423) 3(8.75,-5.423) 4(8.5,2.423) 5(8.25,-5.423) 6(8,2.423) 7(7.75,-5.423) 16(5.5,2.423) 17(5.25,-5.423) 18(5,2.423) 19(4.75,-5.423) 20(4.5,2.423) 21(4.25,-5.423) 22(4,2.423) 23(3.75,-5.423) 24(3.5,2.423) 25(3.25,-5.423) 26(3,2.423) 27(2.75,-5.423) 28(2.5,2.423) 29(2.25,-5.423) 30(2,2.423) 31(1.75,-5.423) 32(1.5,2.423) 33(1.25,-5.423) 34(1,2.423) 35(0.75,-5.423) 36(0.5,2.423) 37(0.25,-5.423) 38(0,2.423) 39(-0.25,-5.423) 40(-0.5,2.423) 41(-0.75,-5.423) 42(-1,2.423) 43(-1.25,-5.423) 44(-1.5,2.423) 45(-1.75,-5.423) 46(-2,2.423) 47(-2.25,-5.423) 48(-2.5,2.423) 49(-2.75,-5.423) 50(-3,2.423) 51(-3.25,-5.423) 52(-3.5,2.423) 53(-3.75,-5.423) 54(-4,2.423) 55(-4.25,-5.423) 56(-4.5,2.423) 57(-4.75,-5.423) 58(-5,2.423) 59(-5.25,-5.423) 60(-5.5,2.423) 61(-5.75,-5.423) 62(-6,2.423) 63(-6.25,-5.423) 64(-6.5,2.423) 65(-6.75,-5.423) 66(-7,2.423) 67(-7.25,-5.423) 68(-7.5,2.423) 69(-7.75,-5.423) 70(-8,2.423) 71(-8.25,-5.423) 72(-8.5,2.423) 73(-8.75,-5.423) 74(-9,2.423) 75(-9.25,-5.423)
  rect 1.194x2.743 smd: 76(10.35,-4.5) 77(-10.35,-4.5)
A1251WR0-8PS-5E
  rect 0.813x1.6 smd: 1(-4.375,2.9) 2(-3.125,2.9) 3(-1.875,2.9) 4(-0.625,2.9) 5(0.625,2.9) 6(1.875,2.9) 7(3.125,2.9) 8(4.375,2.9)
  rect 2.108x2.997 smd: 9(-6.925,0) 10(6.925,0)
A1501WV0-6PS-5E
  rect 0.711x3.505 smd: 1(3.75,2) 2(2.25,2) 3(0.75,2) 4(-0.75,2) 5(-2.25,2) 6(-3.75,2)
  rect 1.499x2.311 smd: 7(5.8,0) 8(-5.8,0)
A2541WV0-1EX2PA-6T
  round 1.397 hole 0.991: 1(-1.27,0) 2(1.27,0)
AAA-BAT-034-K01
  round 0.254 hole 1.067 unplated: (-7.5,0)
  round 0.254 hole 1.372 unplated: (0,0)
  rect 2.794x3.607 smd: 1(6.2,0)
  rect 2.997x2.591 smd: 2(-15.1,0)
ARES2H18
  rect 0.356x0.66 smd: 1(-0.325,-0.599) 2(0.325,-0.599) 3(0.325,0.599) 4(-0.325,0.599)
ARES8-CN24-MUH20
  rect 0.61x0.66 smd: 1(-0.9,-0.486) 4(0.9,-0.486) 5(0.9,0.486) 8(-0.9,0.486)
  rect 0.305x0.66 smd: 2(-0.25,-0.486) 3(0.25,-0.486) 6(0.25,0.486) 7(-0.25,0.486)
ARES8-CN24-UH20
  rect 0.61x0.66 smd: 1(-0.9,-0.486) 4(0.9,-0.486) 5(0.9,0.486) 8(-0.9,0.486)
  rect 0.305x0.66 smd: 2(-0.25,-0.486) 3(0.25,-0.486) 6(0.25,0.486) 7(-0.25,0.486)
ARES8-CN24H20
  rect 0.61x0.66 smd: 1(-0.9,-0.486) 4(0.9,-0.486) 5(0.9,0.486) 8(-0.9,0.486)
  rect 0.305x0.66 smd: 2(-0.25,-0.486) 3(0.25,-0.486) 6(0.25,0.486) 7(-0.25,0.486)
BGA96D075130H48
  round 0.356 smd: A1(-3.2,6) A2(-2.4,6) A3(-1.6,6) A7(1.6,6) A8(2.4,6) A9(3.2,6) B1(-3.2,5.2) B2(-2.4,5.2) B3(-1.6,5.2) B7(1.6,5.2) B8(2.4,5.2) B9(3.2,5.2) C1(-3.2,4.4) C2(-2.4,4.4) C3(-1.6,4.4) C7(1.6,4.4) C8(2.4,4.4) C9(3.2,4.4) D1(-3.2,3.6) D2(-2.4,3.6) D3(-1.6,3.6) D7(1.6,3.6) D8(2.4,3.6) D9(3.2,3.6) E1(-3.2,2.8) E2(-2.4,2.8) E3(-1.6,2.8) E7(1.6,2.8) E8(2.4,2.8) E9(3.2,2.8) F1(-3.2,2) F2(-2.4,2) F3(-1.6,2) F7(1.6,2) F8(2.4,2) F9(3.2,2) G1(-3.2,1.2) G2(-2.4,1.2) G3(-1.6,1.2) G7(1.6,1.2) G8(2.4,1.2) G9(3.2,1.2) H1(-3.2,0.4) H2(-2.4,0.4) H3(-1.6,0.4) H7(1.6,0.4) H8(2.4,0.4) H9(3.2,0.4) J1(-3.2,-0.4) J2(-2.4,-0.4) J3(-1.6,-0.4) J7(1.6,-0.4) J8(2.4,-0.4) J9(3.2,-0.4) K1(-3.2,-1.2) K2(-2.4,-1.2) K3(-1.6,-1.2) K7(1.6,-1.2) K8(2.4,-1.2) K9(3.2,-1.2) L1(-3.2,-2) L2(-2.4,-2) L3(-1.6,-2) L7(1.6,-2) L8(2.4,-2) L9(3.2,-2) M1(-3.2,-2.8) M2(-2.4,-2.8) M3(-1.6,-2.8) M7(1.6,-2.8) M8(2.4,-2.8) M9(3.2,-2.8) N1(-3.2,-3.6) N2(-2.4,-3.6) N3(-1.6,-3.6) N7(1.6,-3.6) N8(2.4,-3.6) N9(3.2,-3.6) P1(-3.2,-4.4) P2(-2.4,-4.4) P3(-1.6,-4.4) P7(1.6,-4.4) P8(2.4,-4.4) P9(3.2,-4.4) R1(-3.2,-5.2) R2(-2.4,-5.2) R3(-1.6,-5.2) R7(1.6,-5.2) R8(2.4,-5.2) R9(3.2,-5.2) T1(-3.2,-6) T2(-2.4,-6) T3(-1.6,-6) T7(1.6,-6) T8(2.4,-6) T9(3.2,-6)
BGA595M23H83
  round 0.432 smd: A2(-9.9,10.7) A3(-9.1,10.7) A25(9.1,10.7) A26(9.9,10.7) AE1(-10.7,-9.1) AE2(-9.9,-9.1) AE3(-9.1,-9.1) AE25(9.1,-9.1) AE26(9.9,-9.1) AE27(10.7,-9.1) AF1(-10.7,-9.9) AF2(-9.9,-9.9) AF3(-9.1,-9.9) AF25(9.1,-9.9) AF26(9.9,-9.9) AF27(10.7,-9.9) AG2(-9.9,-10.7) AG3(-9.1,-10.7) AG25(9.1,-10.7) AG26(9.9,-10.7) B1(-10.7,9.9) B2(-9.9,9.9) B3(-9.1,9.9) B25(9.1,9.9) B26(9.9,9.9) B27(10.7,9.9) C1(-10.7,9.1) C2(-9.9,9.1) C3(-9.1,9.1) C25(9.1,9.1) C26(9.9,9.1) C27(10.7,9.1)
  round 0.381 smd: A4(-8.3,10.7) A6(-6.6,10.7) A7(-5.8,10.7) A9(-4.12,10.7) A10(-3.32,10.7) A12(-1.64,10.7) A13(-0.84,10.7) A15(0.84,10.7) A16(1.64,10.7) A18(3.32,10.7) A19(4.12,10.7) A21(5.8,10.7) A22(6.6,10.7) A24(8.3,10.7) AA1(-10.7,-5.8) AA2(-9.9,-5.8) AA3(-9.1,-5.8) AA4(-8.3,-5.8) AA5(-7.5,-5.8) AA6(-6.66,-5.8) AA7(-5.8,-5.8) AA8(-4.96,-5.8) AA9(-4.12,-5.86) AA10(-3.32,-5.86) AA12(-1.64,-5.86) AA13(-0.84,-5.86) AA14(0,-5.86) AA15(0.84,-5.86) AA16(1.64,-5.86) AA18(3.32,-5.86) AA19(4.12,-5.86) AA20(4.96,-5.8) AA21(5.8,-5.8) AA22(6.66,-5.8) AA23(7.5,-5.8) AA24(8.3,-5.8) AA25(9.1,-5.8) AA26(9.9,-5.8) AA27(10.7,-5.8) AB1(-10.7,-6.6) AB2(-9.9,-6.6) AB3(-9.1,-6.6) AB4(-8.3,-6.6) AB5(-7.5,-6.6) AB6(-6.6,-6.6) AB7(-5.8,-6.66) AB8(-4.96,-6.66) AB9(-4.12,-6.66) AB10(-3.32,-6.66) AB11(-2.48,-6.66) AB12(-1.64,-6.66) AB13(-0.84,-6.66) AB14(0,-6.66) AB15(0.84,-6.66) AB16(1.64,-6.66) AB17(2.48,-6.66) AB18(3.32,-6.66) AB19(4.12,-6.66) AB20(4.96,-6.66) AB21(5.8,-6.66) AB22(6.6,-6.6) AB23(7.5,-6.6) AB24(8.3,-6.6) AB25(9.1,-6.6) AB26(9.9,-6.6) AB27(10.7,-6.6) AC2(-9.9,-7.45) AC3(-9.1,-7.45) AC4(-8.3,-7.45) AC5(-7.45,-7.45) AC6(-6.6,-7.5) AC7(-5.8,-7.5) AC8(-4.96,-7.5) AC9(-4.12,-7.5) AC10(-3.32,-7.5) AC11(-2.48,-7.5) AC12(-1.64,-7.5) AC13(-0.84,-7.5) AC14(0,-7.5) AC15(0.84,-7.5) AC16(1.64,-7.5) AC17(2.48,-7.5) AC18(3.32,-7.5) AC19(4.12,-7.5) AC20(4.96,-7.5) AC21(5.8,-7.5) AC22(6.6,-7.5) AC23(7.45,-7.45) AC24(8.3,-7.45) AC25(9.1,-7.45) AC26(9.9,-7.45) AD1(-10.7,-8.3) AD2(-9.9,-8.3) AD3(-9.1,-8.3) AD4(-8.3,-8.3) AD5(-7.45,-8.3) AD6(-6.6,-8.3) AD7(-5.8,-8.3) AD8(-4.96,-8.3) AD9(-4.12,-8.3) AD10(-3.32,-8.3) AD11(-2.48,-8.3) AD12(-1.64,-8.3) AD13(-0.84,-8.3) AD14(0,-8.3) AD15(0.84,-8.3) AD16(1.64,-8.3) AD17(2.48,-8.3) AD18(3.32,-8.3) AD19(4.12,-8.3) AD20(4.96,-8.3) AD21(5.8,-8.3) AD22(6.6,-8.3) AD23(7.45,-8.3) AD24(8.3,-8.3) AD25(9.1,-8.3) AD26(9.9,-8.3) AD27(10.7,-8.3) AE4(-8.3,-9.1) AE5(-7.45,-9.1) AE6(-6.6,-9.1) AE7(-5.8,-9.1) AE8(-4.96,-9.1) AE9(-4.12,-9.1) AE10(-3.32,-9.1) AE11(-2.48,-9.1) AE12(-1.64,-9.1) AE13(-0.84,-9.1) AE14(0,-9.1) AE15(0.84,-9.1) AE16(1.64,-9.1) AE17(2.48,-9.1) AE18(3.32,-9.1) AE19(4.12,-9.1) AE20(4.96,-9.1) AE21(5.8,-9.1) AE22(6.6,-9.1) AE23(7.45,-9.1) AE24(8.3,-9.1) AF4(-8.3,-9.9) AF5(-7.45,-9.9) AF6(-6.6,-9.9) AF7(-5.8,-9.9) AF8(-4.96,-9.9) AF9(-4.12,-9.9) AF10(-3.32,-9.9) AF11(-2.48,-9.9) AF12(-1.64,-9.9) AF13(-0.84,-9.9) AF14(0,-9.9) AF15(0.84,-9.9) AF16(1.64,-9.9) AF17(2.48,-9.9) AF18(3.32,-9.9) AF19(4.12,-9.9) AF20(4.96,-9.9) AF21(5.8,-9.9) AF22(6.6,-9.9) AF23(7.45,-9.9) AF24(8.3,-9.9) AG4(-8.3,-10.7) AG6(-6.6,-10.7) AG7(-5.8,-10.7) AG9(-4.12,-10.7) AG10(-3.32,-10.7) AG12(-1.64,-10.7) AG13(-0.84,-10.7) AG15(0.84,-10.7) AG16(1.64,-10.7) AG18(3.32,-10.7) AG19(4.12,-10.7) AG21(5.8,-10.7) AG22(6.6,-10.7) AG24(8.3,-10.7) B4(-8.3,9.9) B5(-7.45,9.9) B6(-6.6,9.9) B7(-5.8,9.9) B8(-4.96,9.9) B9(-4.12,9.9) B10(-3.32,9.9) B11(-2.48,9.9) B12(-1.64,9.9) B13(-0.84,9.9) B14(0,9.9) B15(0.84,9.9) B16(1.64,9.9) B17(2.48,9.9) B18(3.32,9.9) B19(4.12,9.9) B20(4.96,9.9) B21(5.8,9.9) B22(6.6,9.9) B23(7.45,9.9) B24(8.3,9.9) C4(-8.3,9.1) C5(-7.45,9.1) C6(-6.6,9.1) C7(-5.8,9.1) C8(-4.96,9.1) C9(-4.12,9.1) C10(-3.32,9.1) C11(-2.48,9.1) C12(-1.64,9.1) C13(-0.84,9.1) C14(0,9.1) C15(0.84,9.1) C16(1.64,9.1) C17(2.48,9.1) C18(3.32,9.1) C19(4.12,9.1) C20(4.96,9.1) C21(5.8,9.1) C22(6.6,9.1) C23(7.45,9.1) C24(8.3,9.1) D1(-10.7,8.3) D2(-9.9,8.3) D3(-9.1,8.3) D4(-8.3,8.3) D5(-7.45,8.3) D6(-6.6,8.3) D7(-5.8,8.3) D8(-4.96,8.3) D9(-4.12,8.3) D10(-3.32,8.3) D11(-2.48,8.3) D12(-1.64,8.3) D13(-0.84,8.3) D14(0,8.3) D15(0.84,8.3) D16(1.64,8.3) D17(2.48,8.3) D18(3.32,8.3) D19(4.12,8.3) D20(4.96,8.3) D21(5.8,8.3) D22(6.6,8.3) D23(7.45,8.3) D24(8.3,8.3) D25(9.1,8.3) D26(9.9,8.3) D27(10.7,8.3) E2(-9.9,7.45) E3(-9.1,7.45) E4(-8.3,7.45) E5(-7.45,7.45) E6(-6.6,7.5) E7(-5.8,7.5) E8(-4.96,7.5) E9(-4.12,7.5) E10(-3.32,7.5) E11(-2.48,7.5) E12(-1.64,7.5) E13(-0.84,7.5) E14(0,7.5) E15(0.84,7.5) E16(1.64,7.5) E17(2.48,7.5) E18(3.32,7.5) E19(4.12,7.5) E20(4.96,7.5) E21(5.8,7.5) E22(6.6,7.5) E23(7.45,7.45) E24(8.3,7.45) E25(9.1,7.45) E26(9.9,7.45) F1(-10.7,6.6) F2(-9.9,6.6) F3(-9.1,6.6) F4(-8.3,6.6) F5(-7.5,6.6) F6(-6.6,6.6) F7(-5.8,6.66) F8(-4.96,6.66) F9(-4.12,6.66) F10(-3.32,6.66) F11(-2.48,6.66) F12(-1.64,6.66) F13(-0.84,6.66) F14(0,6.66) F15(0.84,6.66) F16(1.64,6.66) F17(2.48,6.66) F18(3.32,6.66) F19(4.12,6.66) F20(4.96,6.66) F21(5.8,6.66) F22(6.6,6.6) F23(7.5,6.6) F24(8.3,6.6) F25(9.1,6.6) F26(9.9,6.6) F27(10.7,6.6) G1(-10.7,5.8) G2(-9.9,5.8) G3(-9.1,5.8) G4(-8.3,5.8) G5(-7.5,5.8) G6(-6.66,5.8) G7(-5.8,5.8) G8(-4.96,5.8) G9(-4.12,5.86) G10(-3.32,5.86) G12(-1.64,5.86) G13(-0.84,5.86) G14(0,5.86) G15(0.84,5.86) G16(1.64,5.86) G18(3.32,5.86) G19(4.12,5.86) G20(4.96,5.8) G21(5.8,5.8) G22(6.66,5.8) G23(7.5,5.8) G24(8.3,5.8) G25(9.1,5.8) G26(9.9,5.8) G27(10.7,5.8) H2(-9.9,4.96) H3(-9.1,4.96) H4(-8.3,4.96) H5(-7.5,4.96) H6(-6.66,4.96) H22(6.66,4.96) H23(7.5,4.96) H24(8.3,4.96) H25(9.1,4.96) H26(9.9,4.96) J1(-10.7,4.12) J2(-9.9,4.12) J3(-9.1,4.12) J4(-8.3,4.12) J5(-7.5,4.12) J6(-6.66,4.12) J7(-5.86,4.12) J21(5.86,4.12) J22(6.66,4.12) J23(7.5,4.12) J24(8.3,4.12) J25(9.1,4.12) J26(9.9,4.12) J27(10.7,4.12) K1(-10.7,3.32) K2(-9.9,3.32) K3(-9.1,3.32) K4(-8.3,3.32) K5(-7.5,3.32) K6(-6.66,3.32) K7(-5.86,3.32) K21(5.86,3.32) K22(6.66,3.32) K23(7.5,3.32) K24(8.3,3.32) K25(9.1,3.32) K26(9.9,3.32) K27(10.7,3.32) L2(-9.9,2.48) L3(-9.1,2.48) L4(-8.3,2.48) L5(-7.5,2.48) L6(-6.66,2.48) L22(6.66,2.48) L23(7.5,2.48) L24(8.3,2.48) L25(9.1,2.48) L26(9.9,2.48) M1(-10.7,1.64) M2(-9.9,1.64) M3(-9.1,1.64) M4(-8.3,1.64) M5(-7.5,1.64) M6(-6.66,1.64) M7(-5.86,1.64) M21(5.86,1.64) M22(6.66,1.64) M23(7.5,1.64) M24(8.3,1.64) M25(9.1,1.64) M26(9.9,1.64) M27(10.7,1.64) N1(-10.7,0.84) N2(-9.9,0.84) N3(-9.1,0.84) N4(-8.3,0.84) N5(-7.5,0.84) N6(-6.66,0.84) N7(-5.86,0.84) N21(5.86,0.84) N22(6.66,0.84) N23(7.5,0.84) N24(8.3,0.84) N25(9.1,0.84) N26(9.9,0.84) N27(10.7,0.84) P2(-9.9,0) P3(-9.1,0) P4(-8.3,0) P5(-7.5,0) P6(-6.66,0) P22(6.66,0) P23(7.5,0) P24(8.3,0) P25(9.1,0) P26(9.9,0) R1(-10.7,-0.84) R2(-9.9,-0.84) R3(-9.1,-0.84) R4(-8.3,-0.84) R5(-7.5,-0.84) R6(-6.66,-0.84) R7(-5.86,-0.84) R21(5.86,-0.84) R22(6.66,-0.84) R23(7.5,-0.84) R24(8.3,-0.84) R25(9.1,-0.84) R26(9.9,-0.84) R27(10.7,-0.84) T1(-10.7,-1.64) T2(-9.9,-1.64) T3(-9.1,-1.64) T4(-8.3,-1.64) T5(-7.5,-1.64) T6(-6.66,-1.64) T7(-5.86,-1.64) T21(5.86,-1.64) T22(6.66,-1.64) T23(7.5,-1.64) T24(8.3,-1.64) T25(9.1,-1.64) T26(9.9,-1.64) T27(10.7,-1.64) U2(-9.9,-2.48) U3(-9.1,-2.48) U4(-8.3,-2.48) U5(-7.5,-2.48) U6(-6.66,-2.48) U22(6.66,-2.48) U23(7.5,-2.48) U24(8.3,-2.48) U25(9.1,-2.48) U26(9.9,-2.48) V1(-10.7,-3.32) V2(-9.9,-3.32) V3(-9.1,-3.32) V4(-8.3,-3.32) V5(-7.5,-3.32) V6(-6.66,-3.32) V7(-5.86,-3.32) V21(5.86,-3.32) V22(6.66,-3.32) V23(7.5,-3.32) V24(8.3,-3.32) V25(9.1,-3.32) V26(9.9,-3.32) V27(10.7,-3.32) W1(-10.7,-4.12) W2(-9.9,-4.12) W3(-9.1,-4.12) W4(-8.3,-4.12) W5(-7.5,-4.12) W6(-6.66,-4.12) W7(-5.86,-4.12) W21(5.86,-4.12) W22(6.66,-4.12) W23(7.5,-4.12) W24(8.3,-4.12) W25(9.1,-4.12) W26(9.9,-4.12) W27(10.7,-4.12) Y2(-9.9,-4.96) Y3(-9.1,-4.96) Y4(-8.3,-4.96) Y5(-7.5,-4.96) Y6(-6.66,-4.96) Y22(6.66,-4.96) Y23(7.5,-4.96) Y24(8.3,-4.96) Y25(9.1,-4.96) Y26(9.9,-4.96)
  round 0.457 smd: K10(-4,4) K11(-3,4) K12(-2,4) K13(-1,4) K14(0,4) K15(1,4) K16(2,4) K17(3,4) K18(4,4) L10(-4,3) L11(-3,3) L12(-2,3) L13(-1,3) L14(0,3) L15(1,3) L16(2,3) L17(3,3) L18(4,3) M10(-4,2) M11(-3,2) M12(-2,2) M13(-1,2) M14(0,2) M15(1,2) M16(2,2) M17(3,2) M18(4,2) N10(-4,1) N11(-3,1) N12(-2,1) N13(-1,1) N14(0,1) N15(1,1) N16(2,1) N17(3,1) N18(4,1) P10(-4,0) P11(-3,0) P12(-2,0) P13(-1,0) P14(0,0) P15(1,0) P16(2,0) P17(3,0) P18(4,0) R10(-4,-1) R11(-3,-1) R12(-2,-1) R13(-1,-1) R14(0,-1) R15(1,-1) R16(2,-1) R17(3,-1) R18(4,-1) T10(-4,-2) T11(-3,-2) T12(-2,-2) T13(-1,-2) T14(0,-2) T15(1,-2) T16(2,-2) T17(3,-2) T18(4,-2) U10(-4,-3) U11(-3,-3) U12(-2,-3) U13(-1,-3) U14(0,-3) U15(1,-3) U16(2,-3) U17(3,-3) U18(4,-3) V10(-4,-4) V11(-3,-4) V12(-2,-4) V13(-1,-4) V14(0,-4) V15(1,-4) V16(2,-4) V17(3,-4) V18(4,-4)
BGA837M23-1H58
  round 0.305 smd: A2(10.46,-10.814) A3(9.959,-10.814) A4(9.459,-10.814) A42(-9.459,-10.814) A43(-9.959,-10.814) A44(-10.46,-10.814) AA17(3.099,-0.775) AA18(2.324,-0.775) AA20(1.549,-0.775) AA21(0.775,-0.775) AA23(0,-0.775) AA25(-0.775,-0.775) AA26(-1.549,-0.775) AA28(-2.324,-0.775) AA29(-3.099,-0.775) AB7(8.175,-0.667) AB8(7.413,-0.667) AB10(6.651,-0.667) AB11(5.889,-0.667) AB13(5.127,-0.667) AB14(4.365,-0.667) AB15(3.807,-0.667) AB31(-3.807,-0.667) AB32(-4.365,-0.667) AB33(-5.127,-0.667) AB35(-5.889,-0.667) AB36(-6.651,-0.667) AB38(-7.413,-0.667) AB39(-8.175,-0.667) AC17(3.099,0) AC18(2.324,0) AC20(1.549,0) AC21(0.775,0) AC23(0,0) AC25(-0.775,0) AC26(-1.549,0) AC28(-2.324,0) AC29(-3.099,0) AD7(8.175,0.667) AD8(7.413,0.667) AD10(6.651,0.667) AD11(5.889,0.667) AD13(5.127,0.667) AD14(4.365,0.667) AD15(3.807,0.667) AD31(-3.807,0.667) AD32(-4.365,0.667) AD33(-5.127,0.667) AD35(-5.889,0.667) AD36(-6.651,0.667) AD38(-7.413,0.667) AD39(-8.175,0.667) AE17(3.099,0.775) AE18(2.324,0.775) AE20(1.549,0.775) AE21(0.775,0.775) AE23(0,0.775) AE25(-0.775,0.775) AE26(-1.549,0.775) AE28(-2.324,0.775) AE29(-3.099,0.775) AF17(3.099,1.549) AF18(2.324,1.549) AF20(1.549,1.549) AF21(0.775,1.549) AF23(0,1.549) AF25(-0.775,1.549) AF26(-1.549,1.549) AF28(-2.324,1.549) AF29(-3.099,1.549) AG7(8.175,1.772) AG8(7.413,1.772) AG10(6.651,1.772) AG11(5.889,1.772) AG13(5.127,1.772) AG14(4.365,1.772) AG15(3.807,1.772) AG31(-3.807,1.772) AG32(-4.365,1.772) AG33(-5.127,1.772) AG35(-5.889,1.772) AG36(-6.651,1.772) AG38(-7.413,1.772) AG39(-8.175,1.772) AH17(3.099,2.324) AH18(2.324,2.324) AH20(1.549,2.324) AH21(0.775,2.324) AH23(0,2.324) AH25(-0.775,2.324) AH26(-1.549,2.324) AH28(-2.324,2.324) AH29(-3.099,2.324) AJ7(8.074,2.953) AJ8(7.312,2.953) AJ10(6.55,2.953) AJ11(5.788,2.953) AJ13(5.026,2.953) AJ14(4.315,2.953) AJ15(3.807,2.953) AJ17(3.099,3.099) AJ18(2.324,3.099) AJ20(1.549,3.099) AJ21(0.775,3.099) AJ23(0,3.099) AJ25(-0.775,3.099) AJ26(-1.549,3.099) AJ28(-2.324,3.099) AJ29(-3.099,3.099) AJ31(-3.807,2.953) AJ32(-4.365,2.953) AJ33(-5.127,2.953) AJ35(-5.889,2.953) AJ36(-6.651,2.953) AJ38(-7.413,2.953) AJ39(-8.175,2.953) AL7(8.074,4.071) AL8(7.312,4.071) AL10(6.55,4.071) AL11(5.788,4.071) AL13(5.026,4.071) AL17(2.953,3.807) AL19(1.772,3.807) AL22(0.667,3.807) AL24(-0.667,3.807) AL27(-1.772,3.807) AL29(-2.953,3.807) AL32(-4.34,4.096) AL33(-5.102,4.096) AL35(-5.864,4.096) AL36(-6.626,4.096) AL38(-7.388,4.096) AL39(-8.15,4.096) AM15(4.096,4.34) AM17(2.953,4.365) AM19(1.772,4.365) AM22(0.667,4.365) AM24(-0.667,4.365) AM27(-1.772,4.365) AM29(-2.953,4.315) AN7(8.023,5.036) AN8(7.261,4.985) AN10(6.499,4.985) AN11(5.753,5.026) AN15(4.096,5.102) AN17(2.953,5.127) AN19(1.772,5.127) AN22(0.667,5.127) AN24(-0.667,5.127) AN27(-1.772,5.127) AN29(-2.953,5.026) AN31(-4.071,5.026) AN36(-6.47,5.087) AN38(-7.232,5.087) AN39(-7.994,5.087) AP11(6.04,5.551) AR7(7.999,6.037) AR9(7.084,6.077) AR15(4.096,5.864) AR17(2.953,5.889) AR19(1.772,5.889) AR22(0.667,5.889) AR24(-0.667,5.889) AR27(-1.772,5.889) AR29(-2.953,5.788) AR31(-4.071,5.788) AR33(-5.026,5.753) AR34(-5.551,6.04) AR38(-7.396,6.068) AR39(-8.158,6.068) AT9(6.938,6.713) AT10(6.311,6.663) AT13(5.087,6.47) AT15(4.096,6.626) AT17(2.953,6.651) AT19(1.772,6.651) AT22(0.667,6.651) AT24(-0.667,6.651) AT27(-1.772,6.651) AT29(-2.953,6.55) AT31(-4.071,6.55) AT33(-4.985,6.499) AT36(-6.663,6.311) AU7(7.936,6.994) AU35(-6.077,7.084) AU36(-6.713,6.938) AU39(-7.991,7.141) AV6(8.237,7.645) AV11(6.068,7.396) AV13(5.087,7.232) AV15(4.096,7.388) AV17(2.953,7.413) AV19(1.772,7.413) AV22(0.667,7.413) AV24(-0.667,7.413) AV27(-1.772,7.413) AV29(-2.953,7.312) AV31(-4.071,7.312) AV33(-4.985,7.261) AW9(7.141,7.991) AW11(6.068,8.158) AW13(5.087,7.994) AW15(4.096,8.15) AW17(2.953,8.175) AW19(1.772,8.175) AW22(0.667,8.175) AW24(-0.667,8.175) AW27(-1.772,8.175) AW29(-2.953,8.074) AW31(-4.071,8.074) AW33(-5.036,8.023) AW35(-6.037,7.999) AW37(-6.994,7.936) AY5(8.764,8.585) AY38(-7.645,8.237) B1(10.814,-10.46) B2(10.33,-10.33) B3(9.824,-10.326) B43(-9.8,-10.304) B44(-10.33,-10.33) B45(-10.814,-10.46) BA40(-8.585,8.764) BB1(10.814,9.459) BB45(-10.814,9.459) BC1(10.814,9.959) BC2(10.326,9.824) BC44(-10.304,9.8) BC45(-10.814,9.959) BD1(10.814,10.46) BD2(10.33,10.33) BD3(9.8,10.304) BD43(-9.824,10.326) BD44(-10.33,10.33) BD45(-10.814,10.46) BE2(10.46,10.814) BE3(9.959,10.814) BE4(9.459,10.814) BE42(-9.459,10.814) BE43(-9.959,10.814) BE44(-10.46,10.814) C1(10.814,-9.959) C2(10.304,-9.8) C42(-9.288,-9.86) C44(-10.326,-9.824) C45(-10.814,-9.959) D1(10.814,-9.459) D45(-10.814,-9.459) F8(7.645,-8.237) G9(6.994,-7.936) G11(6.037,-7.999) G13(5.036,-8.023) G15(4.071,-8.074) G17(2.953,-8.074) G19(1.772,-8.175) G22(0.667,-8.175) G24(-0.667,-8.175) G27(-1.772,-8.175) G29(-2.953,-8.175) G31(-4.096,-8.15) G33(-5.087,-7.994) G35(-6.068,-8.158) G37(-7.141,-7.991) H13(4.985,-7.261) H15(4.071,-7.312) H17(2.953,-7.312) H19(1.772,-7.413) H22(0.667,-7.413) H24(-0.667,-7.413) H27(-1.772,-7.413) H29(-2.953,-7.413) H31(-4.096,-7.388) H33(-5.087,-7.232) H35(-6.068,-7.396) J7(7.991,-7.141) J10(6.713,-6.938) J11(6.077,-7.084) J39(-7.936,-6.994) K10(6.663,-6.311) K13(4.985,-6.499) K15(4.071,-6.55) K17(2.953,-6.55) K19(1.772,-6.651) K22(0.667,-6.651) K24(-0.667,-6.651) K27(-1.772,-6.651) K29(-2.953,-6.651) K31(-4.096,-6.626) K33(-5.087,-6.47) K36(-6.311,-6.663) K37(-6.938,-6.713) L7(8.158,-6.068) L8(7.396,-6.068) L12(5.551,-6.04) L13(5.026,-5.753) L15(4.071,-5.788) L17(2.953,-5.788) L19(1.772,-5.889) L22(0.667,-5.889) L24(-0.667,-5.889) L27(-1.772,-5.889) L29(-2.953,-5.889) L31(-4.096,-5.864) L37(-7.084,-6.077) L39(-7.999,-6.037) M35(-6.04,-5.551) N7(7.994,-5.087) N8(7.232,-5.087) N10(6.47,-5.087) N15(4.071,-5.026) N17(2.953,-5.026) N19(1.772,-5.127) N22(0.667,-5.127) N24(-0.667,-5.127) N27(-1.772,-5.127) N29(-2.953,-5.127) N31(-4.096,-5.102) N35(-5.753,-5.026) N36(-6.499,-4.985) N38(-7.261,-4.985) N39(-8.023,-5.036) P17(2.953,-4.315) P19(1.772,-4.365) P22(0.667,-4.365) P24(-0.667,-4.365) P27(-1.772,-4.365) P29(-2.953,-4.365) P31(-4.096,-4.34) R7(8.15,-4.096) R8(7.388,-4.096) R10(6.626,-4.096) R11(5.864,-4.096) R13(5.102,-4.096) R14(4.34,-4.096) R17(2.953,-3.807) R19(1.772,-3.807) R22(0.667,-3.807) R24(-0.667,-3.807) R27(-1.772,-3.807) R29(-2.953,-3.807) R33(-5.026,-4.071) R35(-5.788,-4.071) R36(-6.55,-4.071) R38(-7.312,-4.071) R39(-8.074,-4.071) U7(8.175,-2.953) U8(7.413,-2.953) U10(6.651,-2.953) U11(5.889,-2.953) U13(5.127,-2.953) U14(4.365,-2.953) U15(3.807,-2.953) U17(3.099,-3.099) U18(2.324,-3.099) U20(1.549,-3.099) U21(0.775,-3.099) U23(0,-3.099) U25(-0.775,-3.099) U26(-1.549,-3.099) U28(-2.324,-3.099) U29(-3.099,-3.099) U31(-3.807,-2.953) U32(-4.315,-2.953) U33(-5.026,-2.953) U35(-5.788,-2.953) U36(-6.55,-2.953) U38(-7.312,-2.953) U39(-8.074,-2.953) V17(3.099,-2.324) V18(2.324,-2.324) V20(1.549,-2.324) V21(0.775,-2.324) V23(0,-2.324) V25(-0.775,-2.324) V26(-1.549,-2.324) V28(-2.324,-2.324) V29(-3.099,-2.324) W7(8.175,-1.772) W8(7.413,-1.772) W10(6.651,-1.772) W11(5.889,-1.772) W13(5.127,-1.772) W14(4.365,-1.772) W15(3.807,-1.772) W31(-3.807,-1.772) W32(-4.365,-1.772) W33(-5.127,-1.772) W35(-5.889,-1.772) W36(-6.651,-1.772) W38(-7.413,-1.772) W39(-8.175,-1.772) Y17(3.099,-1.549) Y18(2.324,-1.549) Y20(1.549,-1.549) Y21(0.775,-1.549) Y23(0,-1.549) Y25(-0.775,-1.549) Y26(-1.549,-1.549) Y28(-2.324,-1.549) Y29(-3.099,-1.549)
  round 0.279 smd: A5(8.959,-10.814) A41(-8.959,-10.814) BA1(10.814,8.959) BA45(-10.814,8.959) BE5(8.959,10.814) BE41(-8.959,10.814) E1(10.814,-8.959) E45(-10.814,-8.959)
  round 0.254 smd: A6(8.458,-10.814) A40(-8.458,-10.814) AB4(9.403,-0.482) AB5(8.937,-0.667) AB41(-8.937,-0.667) AD4(9.421,0.509) AD5(8.937,0.667) AD41(-8.937,0.667) AF5(8.885,1.721) AF41(-8.887,1.721) AG4(9.403,1.791) AJ5(8.836,2.953) AJ41(-8.937,2.953) AL4(9.403,4.064) AL5(8.836,4.071) AL41(-8.887,4.096) AN4(9.421,5.056) AN5(8.785,5.163) AN41(-8.756,5.087) AR5(8.886,6.182) AR41(-8.92,6.068) AU41(-9.038,7.09) AV4(9.229,7.321) AW4(9.434,8.204) AW42(-9.24,7.816) AY1(10.814,8.458) AY45(-10.814,8.458) B6(8.45,-10.296) B25(-1.225,-10.306) B40(-8.701,-10.355) BA4(9.602,9.12) BA5(8.767,9.095) BA9(7.09,9.038) BA11(6.068,8.92) BA13(5.087,8.756) BA15(4.096,8.887) BA17(2.953,8.937) BA20(1.721,8.887) BA22(0.667,8.937) BA24(-0.667,8.937) BA26(-1.721,8.885) BA29(-2.953,8.836) BA31(-4.071,8.836) BA33(-5.163,8.785) BA35(-6.182,8.886) BA41(-9.095,8.767) BB3(10.162,9.344) BB7(7.816,9.24) BB38(-7.321,9.229) BB39(-8.204,9.434) BB41(-9.12,9.602) BB43(-9.86,9.288) BC4(9.288,9.86) BC42(-9.344,10.162) BE6(8.458,10.814) BE40(-8.458,10.814) C10(6.724,-9.727) C28(-2.369,-9.727) C37(-6.915,-9.727) D3(9.86,-9.288) D5(9.12,-9.602) D7(8.204,-9.434) D8(7.321,-9.229) D10(6.338,-9.403) D15(4.064,-9.403) D17(2.783,-9.421) D19(1.791,-9.403) D24(-0.482,-9.403) D27(-1.764,-9.421) D29(-2.756,-9.403) D31(-4.037,-9.421) D33(-5.029,-9.403) D36(-6.311,-9.421) D39(-7.816,-9.24) D43(-10.162,-9.344) E5(9.095,-8.767) E6(8.585,-8.764) E11(6.182,-8.886) E13(5.163,-8.785) E15(4.071,-8.836) E17(2.953,-8.836) E20(1.721,-8.885) E22(0.667,-8.937) E24(-0.667,-8.937) E26(-1.721,-8.887) E29(-2.953,-8.937) E31(-4.096,-8.887) E33(-5.087,-8.756) E35(-6.068,-8.92) E37(-7.09,-9.038) E41(-8.767,-9.095) E42(-9.602,-9.12) F1(10.814,-8.458) F41(-8.764,-8.585) F44(-10.296,-8.45) F45(-10.814,-8.458) G4(9.24,-7.816) G42(-9.434,-8.204) H3(9.888,-7.391) H40(-8.237,-7.645) H42(-9.229,-7.321) J3(9.727,-6.915) J5(9.038,-7.09) K4(9.421,-6.311) K42(-9.403,-6.338) K43(-9.727,-6.724) L5(8.92,-6.068) L41(-8.886,-6.182) N4(9.403,-5.029) N5(8.756,-5.087) N41(-8.785,-5.163) R5(8.887,-4.096) R41(-8.836,-4.071) U4(9.403,-2.756) U5(8.937,-2.953) U41(-8.836,-2.953) V3(9.727,-2.369) W4(9.421,-1.764) Y5(8.887,-1.721) Y41(-8.885,-1.721)
  oval 0.203x0.254 smd: A7(7.893,-10.814) A9(6.852,-10.814) A37(-6.839,-10.814) A39(-7.893,-10.814) B7(7.944,-10.306) B39(-7.944,-10.306) BD6(8.701,10.355) BD7(7.944,10.306) BD39(-7.944,10.306) BE7(7.893,10.814) BE9(6.839,10.814) BE37(-6.852,10.814) BE39(-7.893,10.814)
  oval 0.152x0.254 smd: A12(5.595,-10.814) A14(4.553,-10.814) A16(3.321,-10.814) A18(2.28,-10.814) A21(1.048,-10.814) A23(0.007,-10.814) A25(-1.225,-10.814) A28(-2.267,-10.814) A30(-3.499,-10.814) A32(-4.54,-10.814) A35(-5.772,-10.814) AA4(9.326,-1.225) AA42(-9.324,-1.048) AE4(9.324,1.048) AE42(-9.326,1.225) AK4(9.324,3.321) AK42(-9.326,3.499) AP4(9.324,5.595) AR42(-9.326,5.772) B8(7.258,-10.428) B10(6.724,-10.235) B11(6.211,-10.396) B12(5.595,-10.306) B13(4.934,-10.428) B14(4.451,-10.235) B15(3.937,-10.396) B16(3.321,-10.306) B18(2.661,-10.428) B19(2.178,-10.235) B20(1.664,-10.396) B21(1.048,-10.306) B22(0.388,-10.428) B23(-0.096,-10.235) B24(-0.609,-10.396) B27(-1.886,-10.428) B28(-2.369,-10.235) B29(-2.883,-10.396) B30(-3.499,-10.306) B31(-4.159,-10.428) B32(-4.642,-10.235) B33(-5.156,-10.396) B35(-5.772,-10.306) B36(-6.432,-10.428) B37(-6.915,-10.235) B38(-7.391,-10.396) BB10(6.311,9.421) BB13(5.029,9.403) BB15(4.037,9.421) BB17(2.756,9.403) BB19(1.764,9.421) BB22(0.482,9.403) BB24(-0.509,9.421) BB27(-1.791,9.403) BB29(-2.783,9.421) BB31(-4.064,9.403) BB33(-5.056,9.421) BB36(-6.338,9.403) BC8(7.391,9.888) BC9(6.915,9.727) BC10(6.336,9.929) BC13(5.156,9.888) BC14(4.642,9.727) BC15(4.063,9.929) BC17(2.883,9.888) BC18(2.369,9.727) BC19(1.789,9.929) BC22(0.609,9.888) BC23(0.096,9.727) BC24(-0.484,9.929) BC26(-1.664,9.888) BC27(-2.178,9.727) BC29(-2.757,9.929) BC31(-3.937,9.888) BC32(-4.451,9.727) BC33(-5.03,9.929) BC35(-6.211,9.888) BC36(-6.724,9.727) BC38(-7.355,9.929) BD8(7.391,10.396) BD9(6.915,10.235) BD10(6.432,10.428) BD11(5.772,10.306) BD13(5.156,10.396) BD14(4.642,10.235) BD15(4.159,10.428) BD16(3.499,10.306) BD17(2.883,10.396) BD18(2.369,10.235) BD19(1.886,10.428) BD21(1.225,10.306) BD22(0.609,10.396) BD23(0.096,10.235) BD24(-0.388,10.428) BD25(-1.048,10.306) BD26(-1.664,10.396) BD27(-2.178,10.235) BD28(-2.661,10.428) BD30(-3.321,10.306) BD31(-3.937,10.396) BD32(-4.451,10.235) BD33(-4.934,10.428) BD34(-5.595,10.306) BD35(-6.211,10.396) BD36(-6.724,10.235) BD38(-7.258,10.428) BE11(5.772,10.814) BE14(4.54,10.814) BE16(3.499,10.814) BE18(2.267,10.814) BE21(1.225,10.814) BE23(-0.007,10.814) BE25(-1.048,10.814) BE28(-2.28,10.814) BE30(-3.321,10.814) BE32(-4.553,10.814) BE34(-5.595,10.814) C8(7.355,-9.929) C11(6.211,-9.888) C13(5.03,-9.929) C14(4.451,-9.727) C15(3.937,-9.888) C17(2.757,-9.929) C19(2.178,-9.727) C20(1.664,-9.888) C22(0.484,-9.929) C23(-0.096,-9.727) C24(-0.609,-9.888) C27(-1.789,-9.929) C29(-2.883,-9.888) C31(-4.063,-9.929) C32(-4.642,-9.727) C33(-5.156,-9.888) C36(-6.336,-9.929) C38(-7.391,-9.888) D13(5.056,-9.421) D22(0.509,-9.421) L4(9.326,-5.772) M42(-9.324,-5.595) T4(9.326,-3.499) T42(-9.324,-3.321)
  oval 0.254x0.152 smd: AA1(10.814,-1.225) AA2(10.306,-1.225) AA44(-10.306,-1.048) AA45(-10.814,-1.048) AB2(10.396,-0.609) AB3(9.888,-0.609) AB42(-9.421,-0.509) AB43(-9.929,-0.484) AB44(-10.428,-0.388) AC1(10.814,0.007) AC2(10.235,-0.096) AC3(9.727,-0.096) AC43(-9.727,0.096) AC44(-10.235,0.096) AC45(-10.814,-0.007) AD2(10.428,0.388) AD3(9.929,0.484) AD42(-9.403,0.482) AD43(-9.888,0.609) AD44(-10.396,0.609) AE1(10.814,1.048) AE2(10.306,1.048) AE44(-10.306,1.225) AE45(-10.814,1.225) AF2(10.396,1.664) AF3(9.888,1.664) AG2(10.235,2.178) AG3(9.727,2.178) AG42(-9.421,1.764) AG43(-9.929,1.789) AG44(-10.428,1.886) AH1(10.814,2.28) AH2(10.428,2.661) AH43(-9.727,2.369) AH44(-10.235,2.369) AH45(-10.814,2.267) AJ3(9.929,2.757) AJ4(9.421,2.783) AJ42(-9.403,2.756) AJ43(-9.888,2.883) AJ44(-10.396,2.883) AK1(10.814,3.321) AK2(10.306,3.321) AK44(-10.306,3.499) AK45(-10.814,3.499) AL2(10.396,3.937) AL3(9.888,3.937) AL42(-9.421,4.037) AL43(-9.929,4.063) AL44(-10.428,4.159) AM1(10.814,4.553) AM2(10.235,4.451) AM3(9.727,4.451) AM43(-9.727,4.642) AM44(-10.235,4.642) AM45(-10.814,4.54) AN2(10.428,4.934) AN3(9.929,5.03) AN42(-9.403,5.029) AN43(-9.888,5.156) AN44(-10.396,5.156) AP1(10.814,5.595) AP2(10.306,5.595) AR2(10.396,6.211) AR3(9.888,6.211) AR44(-10.306,5.772) AR45(-10.814,5.772) AT2(10.235,6.724) AT3(9.727,6.724) AT4(9.403,6.338) AT42(-9.421,6.311) AT43(-9.929,6.336) AT44(-10.428,6.432) AU43(-9.727,6.915) AU44(-10.235,6.915) AV2(10.428,7.258) AV3(9.929,7.355) AV43(-9.888,7.391) AV44(-10.396,7.391) BB11(5.772,9.326) BB16(3.499,9.326) BB21(1.225,9.326) BB25(-1.048,9.324) BB30(-3.321,9.324) BB34(-5.595,9.324) D12(5.595,-9.324) D16(3.321,-9.324) D21(1.048,-9.324) D25(-1.225,-9.326) D30(-3.499,-9.326) D35(-5.772,-9.326) H2(10.396,-7.391) H43(-9.929,-7.355) H44(-10.428,-7.258) J2(10.235,-6.915) K2(10.428,-6.432) K3(9.929,-6.336) K44(-10.235,-6.724) L1(10.814,-5.772) L2(10.306,-5.772) L43(-9.888,-6.211) L44(-10.396,-6.211) M44(-10.306,-5.595) M45(-10.814,-5.595) N2(10.396,-5.156) N3(9.888,-5.156) N42(-9.421,-5.056) N43(-9.929,-5.03) N44(-10.428,-4.934) P1(10.814,-4.54) P2(10.235,-4.642) P3(9.727,-4.642) P43(-9.727,-4.451) P44(-10.235,-4.451) P45(-10.814,-4.553) R2(10.428,-4.159) R3(9.929,-4.063) R4(9.421,-4.037) R42(-9.403,-4.064) R43(-9.888,-3.937) R44(-10.396,-3.937) T1(10.814,-3.499) T2(10.306,-3.499) T44(-10.306,-3.321) T45(-10.814,-3.321) U2(10.396,-2.883) U3(9.888,-2.883) U42(-9.421,-2.783) U43(-9.929,-2.757) V1(10.814,-2.267) V2(10.235,-2.369) V44(-10.428,-2.661) V45(-10.814,-2.28) W2(10.428,-1.886) W3(9.929,-1.789) W42(-9.403,-1.791) W43(-9.727,-2.178) W44(-10.235,-2.178) Y43(-9.888,-1.664) Y44(-10.396,-1.664)
  oval 0.254x0.203 smd: AU1(10.814,6.852) AU45(-10.814,6.839) AW1(10.814,7.893) AW2(10.306,7.944) AW44(-10.306,7.944) AW45(-10.814,7.893) AY44(-10.355,8.701) F2(10.355,-8.701) G1(10.814,-7.893) G2(10.306,-7.944) G44(-10.306,-7.944) G45(-10.814,-7.893) J1(10.814,-6.839) J45(-10.814,-6.852)
  round 0.368 smd: AY2(10.296,8.45) BD40(-8.45,10.296) C4(9.344,-10.162)
C402H22
  custom 0.152x0.152 smd: 1(0,0.445) 2(0,-0.445)
C603
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
C603H35
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
C603H36
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
C603H40
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
C805H50
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
C805H54
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
C805H56
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
C805H58
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
C1206H71
  rect 1.651x1.27 smd: 1(0,1.397) 2(0,-1.397)
C1808H56
  rect 2.286x1.27 smd: 1(0,2.032) 2(0,-2.032)
CI1410M1VL0-NH
  rect 0.559x1.143 smd: 1A(4.5,0.005) 2A(3.5,0.005) 3A(2.5,0.005) 4A(1.5,0.005) 5A(0.5,0.005) 6A(-0.5,0.005) 7A(-1.5,0.005) 8A(-2.5,0.005) 9A(-3.5,0.005) 10A(-4.5,0.005)
  rect 0.559x1.6 smd: 1B(4.5,2.13) 2B(3.5,2.13) 3B(2.5,2.13) 4B(1.5,2.13) 5B(0.5,2.13) 6B(-0.5,2.13) 7B(-1.5,2.13) 8B(-2.5,2.13) 9B(-3.5,2.13) 10B(-4.5,2.13)
  rect 0.61x1.803 smd: 11(5.55,-0.07) 12(-5.55,-0.07)
CI2505P1H00-LF-U
  round 1.422 hole 1.016: 1(-5,0) 2(-2.5,0) 3(0,0) 4(2.5,0) 5(5,0)
CON2C-U
  custom 0.171x0.171 smd: 1(0,0.533) 2(0,-0.533)
CT3528H79
  rect 2.286x2.286 smd: 1(0,1.905) 2(0,-1.905)
CT7343H75
  rect 2.413x2.286 smd: 1(0,3.15) 2(0,-3.15)
D1608-035030AKH28
  rect 0.559x0.991 smd: A(0,0.691) K(0,-0.691)
D4724AKH44
  rect 2.007x1.549 smd: A(0,2.221) K(0,-2.221)
D5226145AKH91
  rect 1.702x2.032 smd: A(0,2.337) K(0,-2.337)
DAN06-K4406-0103-U
  round 0.254 hole 1.118 unplated: (-33.4,0)
  round 0.254 hole 1.6 unplated: (33.4,0)
  custom 0.114x0.114 smd: 1(31.65,4.1) 2(31.35,-4.1) 3(31.05,4.1) 4(30.751,-4.1) 5(30.45,4.1) 6(30.15,-4.1) 7(29.85,4.1) 8(29.55,-4.1) 9(29.251,4.1) 10(28.95,-4.1) 11(28.65,4.1) 12(28.35,-4.1) 13(28.051,4.1) 14(27.751,-4.1) 15(27.45,4.1) 16(27.15,-4.1) 17(26.851,4.1) 18(26.551,-4.1) 19(26.25,4.1) 20(25.95,-4.1) 21(25.65,4.1) 22(25.35,-4.1) 23(25.051,4.1) 24(24.75,-4.1) 25(24.45,4.1) 26(24.15,-4.1) 27(23.851,4.1) 28(23.55,-4.1) 29(23.25,4.1) 30(22.95,-4.1) 31(22.651,4.1) 32(22.351,-4.1) 33(22.05,4.1) 34(21.75,-4.1) 35(21.451,4.1) 36(21.151,-4.1) 37(20.85,4.1) 38(20.55,-4.1) 39(20.25,4.1) 40(19.95,-4.1) 41(19.65,4.1) 42(19.35,-4.1) 43(19.049,4.1) 44(18.749,-4.1) 45(18.45,4.1) 46(18.15,-4.1) 47(17.85,4.1) 48(17.549,-4.1) 49(17.25,4.1) 50(16.95,-4.1) 51(16.65,4.1) 52(16.349,-4.1) 53(16.049,4.1) 54(15.75,-4.1) 55(15.45,4.1) 56(15.15,-4.1) 57(14.849,4.1) 58(14.549,-4.1) 59(14.25,4.1) 60(13.95,-4.1) 61(13.649,4.1) 62(13.349,-4.1) 63(13.05,4.1) 64(12.75,-4.1) 65(12.45,4.1) 66(12.149,-4.1) 67(11.85,4.1) 68(11.55,-4.1) 69(11.25,4.1) 70(10.95,-4.1) 71(10.649,4.1) 72(10.349,-4.1) 73(7.65,4.1) 74(7.35,-4.1) 75(7.049,4.1) 76(6.749,-4.1) 77(6.45,4.1) 78(6.15,-4.1) 79(5.85,4.1) 80(5.549,-4.1) 81(5.25,4.1) 82(4.95,-4.1) 83(4.65,4.1) 84(4.349,-4.1) 85(4.05,4.1) 86(3.75,-4.1) 87(3.45,4.1) 88(3.15,-4.1) 89(2.849,4.1) 90(2.549,-4.1) 91(2.25,4.1) 92(1.95,-4.1) 93(1.649,4.1) 94(1.349,-4.1) 95(1.05,4.1) 96(0.75,-4.1) 97(0.45,4.1) 98(0.149,-4.1) 99(-0.15,4.1) 100(-0.45,-4.1) 101(-0.75,4.1) 102(-1.051,-4.1) 103(-1.351,4.1) 104(-1.65,-4.1) 105(-1.95,4.1) 106(-2.25,-4.1) 107(-2.551,4.1) 108(-2.851,-4.1) 109(-3.15,4.1) 110(-3.45,-4.1) 111(-3.751,4.1) 112(-4.051,-4.1) 113(-4.35,4.1) 114(-4.65,-4.1) 115(-4.95,4.1) 116(-5.251,-4.1) 117(-5.55,4.1) 118(-5.85,-4.1) 119(-6.15,4.1) 120(-6.451,-4.1) 121(-6.751,4.1) 122(-7.051,-4.1) 123(-7.35,4.1) 124(-7.65,-4.1) 125(-7.951,4.1) 126(-8.251,-4.1) 127(-8.55,4.1) 128(-8.85,-4.1) 129(-9.15,4.1) 130(-9.451,-4.1) 131(-9.75,4.1) 132(-10.05,-4.1) 133(-10.35,4.1) 134(-10.651,-4.1) 135(-10.95,4.1) 136(-11.25,-4.1) 137(-11.55,4.1) 138(-11.85,-4.1) 139(-12.151,4.1) 140(-12.451,-4.1) 141(-12.75,4.1) 142(-13.05,-4.1) 143(-13.351,4.1) 144(-13.651,-4.1) 145(-13.95,4.1) 146(-14.25,-4.1) 147(-14.55,4.1) 148(-14.851,-4.1) 149(-15.15,4.1) 150(-15.45,-4.1) 151(-15.75,4.1) 152(-16.051,-4.1) 153(-16.35,4.1) 154(-16.65,-4.1) 155(-16.95,4.1) 156(-17.25,-4.1) 157(-17.551,4.1) 158(-17.851,-4.1) 159(-18.15,4.1) 160(-18.45,-4.1) 161(-18.751,4.1) 162(-19.051,-4.1) 163(-19.35,4.1) 164(-19.65,-4.1) 165(-19.95,4.1) 166(-20.251,-4.1) 167(-20.55,4.1) 168(-20.85,-4.1) 169(-21.15,4.1) 170(-21.451,-4.1) 171(-21.751,4.1) 172(-22.051,-4.1) 173(-22.35,4.1) 174(-22.65,-4.1) 175(-22.951,4.1) 176(-23.251,-4.1) 177(-23.55,4.1) 178(-23.85,-4.1) 179(-24.151,4.1) 180(-24.451,-4.1) 181(-24.75,4.1) 182(-25.05,-4.1) 183(-25.35,4.1) 184(-25.651,-4.1) 185(-25.95,4.1) 186(-26.25,-4.1) 187(-26.55,4.1) 188(-26.851,-4.1) 189(-27.151,4.1) 190(-27.451,-4.1) 191(-27.75,4.1) 192(-28.05,-4.1) 193(-28.351,4.1) 194(-28.651,-4.1) 195(-28.95,4.1) 196(-29.25,-4.1) 197(-29.55,4.1) 198(-29.851,-4.1) 199(-30.15,4.1) 200(-30.45,-4.1) 201(-30.75,4.1) 202(-31.05,-4.1) 203(-31.349,4.1) 204(-31.649,-4.1)
  rect 3.505x4.597 smd: 205(32.8,12) 206(-32.8,12)
DAN06-K4806-0103
  round 0.254 hole 1.118 unplated: (-33.4,0)
  round 0.254 hole 1.6 unplated: (33.4,0)
  custom 0.114x0.114 smd: 1(31.65,4.1) 2(31.35,-4.1) 3(31.05,4.1) 4(30.75,-4.1) 5(30.45,4.1) 6(30.15,-4.1) 7(29.85,4.1) 8(29.55,-4.1) 9(29.25,4.1) 10(28.95,-4.1) 11(28.65,4.1) 12(28.35,-4.1) 13(28.05,4.1) 14(27.75,-4.1) 15(27.45,4.1) 16(27.15,-4.1) 17(26.85,4.1) 18(26.55,-4.1) 19(26.25,4.1) 20(25.95,-4.1) 21(25.65,4.1) 22(25.35,-4.1) 23(25.05,4.1) 24(24.75,-4.1) 25(24.45,4.1) 26(24.15,-4.1) 27(23.85,4.1) 28(23.55,-4.1) 29(23.25,4.1) 30(22.95,-4.1) 31(22.65,4.1) 32(22.35,-4.1) 33(22.05,4.1) 34(21.75,-4.1) 35(21.45,4.1) 36(21.15,-4.1) 37(20.85,4.1) 38(20.55,-4.1) 39(20.25,4.1) 40(19.95,-4.1) 41(19.65,4.1) 42(19.35,-4.1) 43(19.05,4.1) 44(18.75,-4.1) 45(18.45,4.1) 46(18.15,-4.1) 47(17.85,4.1) 48(17.55,-4.1) 49(17.25,4.1) 50(16.95,-4.1) 51(16.65,4.1) 52(16.35,-4.1) 53(16.05,4.1) 54(15.75,-4.1) 55(15.45,4.1) 56(15.15,-4.1) 57(14.85,4.1) 58(14.55,-4.1) 59(14.25,4.1) 60(13.95,-4.1) 61(13.65,4.1) 62(13.35,-4.1) 63(13.05,4.1) 64(12.75,-4.1) 65(12.45,4.1) 66(12.15,-4.1) 67(11.85,4.1) 68(11.55,-4.1) 69(11.25,4.1) 70(10.95,-4.1) 71(10.65,4.1) 72(10.35,-4.1) 73(7.65,4.1) 74(7.35,-4.1) 75(7.05,4.1) 76(6.75,-4.1) 77(6.45,4.1) 78(6.15,-4.1) 79(5.85,4.1) 80(5.55,-4.1) 81(5.25,4.1) 82(4.95,-4.1) 83(4.65,4.1) 84(4.35,-4.1) 85(4.05,4.1) 86(3.75,-4.1) 87(3.45,4.1) 88(3.15,-4.1) 89(2.85,4.1) 90(2.55,-4.1) 91(2.25,4.1) 92(1.95,-4.1) 93(1.65,4.1) 94(1.35,-4.1) 95(1.05,4.1) 96(0.75,-4.1) 97(0.45,4.1) 98(0.15,-4.1) 99(-0.15,4.1) 100(-0.45,-4.1) 101(-0.75,4.1) 102(-1.05,-4.1) 103(-1.35,4.1) 104(-1.65,-4.1) 105(-1.95,4.1) 106(-2.25,-4.1) 107(-2.55,4.1) 108(-2.85,-4.1) 109(-3.15,4.1) 110(-3.45,-4.1) 111(-3.75,4.1) 112(-4.05,-4.1) 113(-4.35,4.1) 114(-4.65,-4.1) 115(-4.95,4.1) 116(-5.25,-4.1) 117(-5.55,4.1) 118(-5.85,-4.1) 119(-6.15,4.1) 120(-6.45,-4.1) 121(-6.75,4.1) 122(-7.05,-4.1) 123(-7.35,4.1) 124(-7.65,-4.1) 125(-7.95,4.1) 126(-8.25,-4.1) 127(-8.55,4.1) 128(-8.85,-4.1) 129(-9.15,4.1) 130(-9.45,-4.1) 131(-9.75,4.1) 132(-10.05,-4.1) 133(-10.35,4.1) 134(-10.65,-4.1) 135(-10.95,4.1) 136(-11.25,-4.1) 137(-11.55,4.1) 138(-11.85,-4.1) 139(-12.15,4.1) 140(-12.45,-4.1) 141(-12.75,4.1) 142(-13.05,-4.1) 143(-13.35,4.1) 144(-13.65,-4.1) 145(-13.95,4.1) 146(-14.25,-4.1) 147(-14.55,4.1) 148(-14.85,-4.1) 149(-15.15,4.1) 150(-15.45,-4.1) 151(-15.75,4.1) 152(-16.05,-4.1) 153(-16.35,4.1) 154(-16.65,-4.1) 155(-16.95,4.1) 156(-17.25,-4.1) 157(-17.55,4.1) 158(-17.85,-4.1) 159(-18.15,4.1) 160(-18.45,-4.1) 161(-18.75,4.1) 162(-19.05,-4.1) 163(-19.35,4.1) 164(-19.65,-4.1) 165(-19.95,4.1) 166(-20.25,-4.1) 167(-20.55,4.1) 168(-20.85,-4.1) 169(-21.15,4.1) 170(-21.45,-4.1) 171(-21.75,4.1) 172(-22.05,-4.1) 173(-22.35,4.1) 174(-22.65,-4.1) 175(-22.95,4.1) 176(-23.25,-4.1) 177(-23.55,4.1) 178(-23.85,-4.1) 179(-24.15,4.1) 180(-24.45,-4.1) 181(-24.75,4.1) 182(-25.05,-4.1) 183(-25.35,4.1) 184(-25.65,-4.1) 185(-25.95,4.1) 186(-26.25,-4.1) 187(-26.55,4.1) 188(-26.85,-4.1) 189(-27.15,4.1) 190(-27.45,-4.1) 191(-27.75,4.1) 192(-28.05,-4.1) 193(-28.35,4.1) 194(-28.65,-4.1) 195(-28.95,4.1) 196(-29.25,-4.1) 197(-29.55,4.1) 198(-29.85,-4.1) 199(-30.15,4.1) 200(-30.45,-4.1) 201(-30.75,4.1) 202(-31.05,-4.1) 203(-31.35,4.1) 204(-31.65,-4.1)
  rect 4.496x4.597 smd: 205(-37.35,12) 206(37.35,12)
